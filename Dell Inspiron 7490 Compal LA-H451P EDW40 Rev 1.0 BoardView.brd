# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_TXP0_C: length 6.7
  TOP w0.091: C13.2 22.36,71.67 v7(24.8,71.67) 25.82,71.67 26.01,71.87 26.03,71.87 26.42,72.25 26.42,72.27 26.77,72.63 26.77,73.19 v6(26.85,73.27)
  BOTTOM w0.091: v6(26.85,73.27) 26.75,73.18 26.75,72.62 26.75,72.62 JEDP1.36
EDP_TXP1: length 227.4
  IN1 w0.079: v4(37.14,34.97) 36.97,35.14 36.8,35.14 36.74,35.19 36.74,35.19 36.57,35.37 36.57,37.01 38.2,38.64 38.2,44 36.87,45.33 36.87,50.23 37.04,50.4 37.04,51.25 37.34,51.56 37.34,53.31 37.81,53.78 37.81,57.77 36.02,59.56 36.02,60.62 35.03,61.61 35.03,62.47 34.22,63.28 34.22,69.04 31.92,71.34 29.35,71.34 29.03,71.02 26.82,71.02 26.19,71.65 23.75,71.65 22.1,73.3 21.81,73.3 v2(21.6,73.09)
  IN3 w0.079: v4(37.14,34.97) 37.7,34.97 37.87,35.14 39.14,35.14 39.21,35.21 42.51,35.21 42.61,35.32 43.49,35.32 43.57,35.24 46.68,35.24 49.43,32.49 49.43,32.16 50.13,31.46 51.21,31.46 51.52,31.77 52.29,31.77 53.11,30.96 53.64,30.96 54.35,30.24 55,30.24 55.28,29.96 55.28,29.78 56.61,28.44 56.61,27.64 60.24,24.01 60.24,22.56 60.94,21.86 60.94,20.01 61.74,19.21 61.74,18.28 70.51,9.51 79.7,9.51 85.11,4.11 107.11,4.11 107.56,3.65 107.84,3.65 107.94,3.55 108.97,3.55 109.04,3.61 150.89,3.61 151.74,4.46 152.31,4.46 153.19,3.58 158.01,3.58 159.74,5.31 159.74,8.91 165.28,14.45 165.28,22.55 165.28,22.55 165.28,28.35 164.43,31.06 164.43,31.34 164.54,31.45 v5(164.54,31.5)
  BOTTOM w0.076: 163.36,34.6 163.36,34.62 163.34,34.64 163.34,35.91 163.43,36 163.54,36 163.62,35.92 UC1.AG1
  BOTTOM w0.091: 163.36,34.6 163.36,34.36 163.21,34.21 163.21,33.12 163.88,32.46 163.88,32.46 164.23,32.11 164.23,32.1 164.45,31.88 164.45,31.59 v5(164.54,31.5)
EDP_TXP1_C: length 5.5
  TOP w0.091: C15.2 22.39,73.3 v7(23.27,73.3) 24.01,73.3 24.74,72.56 25.37,72.56 25.6,72.8 25.6,73.23 v6(25.67,73.3)
  BOTTOM w0.091: v6(25.67,73.3) 25.55,73.18 JEDP1.39
EDP_VDD_EN: length 164.8
  IN2 w0.066: v4(34.99,57.69) 35.16,57.52 35.16,56.28 35.54,55.9 35.54,55.29 35.97,54.86 35.97,51.14 36.28,50.83 36.28,48.39 40.81,43.87 40.81,41.45 42.52,39.74 51.36,39.74 53.07,38.02 56.91,38.02 65.61,29.33 65.61,22.91 72.98,15.54 80.48,15.54 81.4,16.46 88.56,16.46 89.4,15.62 92.33,15.62 92.56,15.84 110.64,15.84 111.79,16.99 113.28,16.99 114.83,15.45 118.22,15.45 121.59,18.82 121.59,18.82 122.64,18.82 123.73,19.92 123.73,22.5 127.67,26.44 129.41,26.44 131.54,28.57 131.54,32.98 132.53,33.97 132.53,37.3 131.35,38.48 131.35,39.34 132.48,40.47 132.48,40.92 134.2,42.64 134.36,42.64 135.31,42.64 136.29,43.61 140.31,43.61 140.7,43.22 v4(140.7,43.01)
  IN3 w0.064: v5(34.85,58.09) 34.85,57.82 v4(34.99,57.69) ; v4(140.7,43.01) 140.7,42.98 140.7,42.98 140.7,42.35 140.34,42 140.29,42 140.22,41.93 v5(140.22,41.9)
  BOTTOM w0.081: v5(140.22,41.9) 140.22,41.91 140.13,42 139.69,42 139.32,41.63 UC1.CG11 ; D4.2 36.47,62.7 35.94,62.17 35.94,59.17 34.86,58.09 v5(34.85,58.09)
EMMC_RCOMP: length 1.8
  TOP w0.203: RC64.1 v2(137.06,45.3)
  IN1 w0.203: v2(137.06,45.3) 137.23,45.13 137.23,44.96 137.22,44.95 v4(137.22,44.94)
  IN3 w0.203: v5(137.24,44.37) 137.24,44.92 137.22,44.94 v4(137.22,44.94)
  BOTTOM w0.203: UC1.CK15 v5(137.24,44.37)
EN_0.6V:
  vias: v1(191.16,66.73)
EN_1.0V: length 2.8
  BOTTOM w0.254: PRF02.1 117.27,41.5 PCF03.1 117.52,41.87 117.52,42.44 117.25,42.71 PUF01.5
EN_1.05V_PRIM: length 2.5
  BOTTOM w0.254: PUH01.15 126.24,20.83 126.13,20.72 PCH14.1 125.46,21.56 PRH08.2
EN_1.8V_PRIM: length 6.5
  TOP w0.081: PR1810.1 v1(68.15,16)
  TOP w0.254: PU1801.11 69.69,20.22 69.42,19.94 69.42,18.46 69.81,18.06 PC1813.1 68.94,17.9 PR1813.1 68.17,17.89 PR1809.1 68.16,17.1 PR1810.1
EN_3V: length 53.1
  IN1 w0.064: v2(50.41,5.89) 50.32,5.81 50.19,5.81 v4(50,5.62)
  IN2 w0.066: v4(12.04,16.93) 12.01,16.96 11.15,16.96 10.78,16.59 10.78,13.82 13.11,11.49 v4(13.11,7.52)
  IN3 w0.064: v4(50,5.62) 45.19,5.62 43.51,3.94 35.06,3.94 31.07,7.93 16.68,7.93 16.33,7.58 13.17,7.58 v4(13.11,7.52) ; v5(12.65,17.43) 12.54,17.43 v4(12.04,16.93)
  BOTTOM w0.254: v5(12.65,17.43) 12.88,17.43 13.1,17.2 PU301.9
EN_5V: length 239.6
  TOP w0.081: v1(51.26,4.86) 51.17,4.95 v2(51.17,5.37) ; JIO1.12 195.73,13.25 v2(196.16,13.68)
  TOP w0.089: PR522.1 v2(51.17,5.37)
  IN1 w0.064: v2(51.17,5.37) 51.01,5.53 v4(50.84,5.53) ; v2(196.16,13.68) 196.16,11.41 195.99,11.24 195.99,8.22 195.67,7.9 195.08,7.9 194.47,8.51 192.96,8.51 192.46,9.01 181.37,9.01 180.38,8.02 171.56,8.02 171.05,8.52 165.96,8.52 165.38,9.11 163.51,9.11 162.46,10.16 162.46,11.18 162.46,11.18 160.72,12.92 155.19,12.92 154.33,13.78 154.33,15.46 153.55,16.24 150.25,16.24 149.44,17.05 148.29,17.05 148.02,17.31 148.02,17.62 148.03,17.63 148.03,19.06 147.36,19.73 144.09,19.73 143.54,19.17 140.1,19.17 140.01,19.27 139.2,19.27 138.95,19.02 131.99,19.02 131.35,19.67 125.59,19.67 123.12,17.21 119.85,17.21 117.06,14.42 115.28,14.42 114.64,13.78 108.2,13.78 107.3,12.89 101.42,12.89 99.35,10.82 95.83,10.82 93.12,8.11 90.27,8.11 89.41,8.97 83.32,8.97 82.39,9.9 75.68,9.9 75.38,9.6 71.86,9.6 70.97,10.49 v4(62.9,10.49)
  IN2 w0.066: v4(12.03,22.1) 11.11,22.1 9.92,20.91 8.59,20.91 8.27,21.24 7.28,21.24 6.72,20.68 6.72,10.49 7.35,9.86 10.19,9.86 11.08,8.97 11.08,7.31 12.43,5.96 14.7,5.96 17.45,8.71 21.02,8.71 23.83,5.9 28.09,5.9 29.11,4.89 43.57,4.89 44.46,5.78 47.42,5.78 47.96,5.24 50.3,5.24 50.59,5.53 v4(50.84,5.53)
  IN3 w0.064: v4(12.03,22.1) 12.24,22.32 v5(12.24,22.36) ; v4(50.84,5.53) 51.06,5.76 52.01,5.76 52.55,5.22 58.13,5.22 61.35,8.44 61.35,8.94 v4(62.9,10.49)
  BOTTOM w0.089: PU501.15 13.21,22.39 13.05,22.23 12.37,22.23 v5(12.24,22.36)
EN_+1.35VGPU: length 7.7
  TOP w0.254: PCW12.1 PRW22.1 62.69,59.7 PRW19.1 63.95,59.17 64.73,59.17 v1(65.41,58.5) 65.82,58.08 65.82,56.25 66.09,55.98 PUW01.11
EN_CPU: length 4.2
  BOTTOM w0.203: PRZ05.2 PRZ06.1 PCZ01.2 159.33,18.43 158.45,19.3 PUZ01.37
EN_GPU: length 4.4
  TOP w0.203: PRV51.2 37.87,66.5 37.85,66.47 37.85,64.28 38.07,64.06 PUV01.2
  TOP w0.254: PRV03.2 PRV51.2
EN_R: length 1.2
  TOP w0.081: v1(53.11,6.82) 53.1,6.81 PR523.2
EN_VCCIO: length 11.7
  TOP w0.254: CZ11.1 RZ3.2 103.15,21.44 DZ6.2 103.75,23.43 v1(104.93,24.6) 105.88,25.55 110.26,25.55 110.64,25.94 UC18.2
ENLDO_3V5V: length 3.5
  BOTTOM w0.254: PU301.8 12.08,16.18 11.89,16.37 11.89,17.24 11.19,17.93 PR303.1 PR302.1
EQ0: length 2.6
  IN1 w0.064: v2(26.99,41) 26.65,41 26.13,40.48 v4(26.13,40.43)
  IN3 w0.064: v4(26.13,40.43) 25.99,40.43 v5(25.58,40.84)
  BOTTOM w0.081: v5(25.58,40.84) RM40.2 RM41.1
EQ1: length 4
  IN1 w0.064: v4(24.93,42.44) 26.75,42.44 v2(26.99,42.2)
  IN3 w0.064: v5(24.64,42.15) v4(24.93,42.44)
  BOTTOM w0.081: RM43.1 RM42.2 25.25,42.07 25.17,42.15 v5(24.64,42.15)
ESPI_CLK: length 159.6
  TOP w0.081: UE1.B18 v6(50.58,19.99) 50.58,19.79 51.5,18.87 54.72,18.87 54.89,18.7 55.49,18.7 56.55,19.76 56.55,20.69 57.08,21.22 57.08,22.66 57.44,23.02 v1(57.44,24.41) 57.44,25.53 v2(57.27,25.71) ; RC26.1 143.41,56.18 v2(142.82,56.18) ; v2(41.72,6.71) 42.29,6.14 43.93,6.14 44.25,5.82 JESPI1.10
  IN1 w0.064: v4(142.82,55.84) v2(142.82,56.18) ; v2(41.72,6.71) 41.65,6.78 v4(41.65,7.75) ; v2(57.27,25.71) 57.27,25.85 58.37,26.95 59.33,26.95 61.5,29.11 65.44,29.11 65.69,29.36 75.1,29.36 78.31,26.15 78.31,25.07 79.42,23.95 79.43,23.95 79.48,23.9 79.96,23.9 82.33,21.53 82.33,21.42 82.24,21.33 82.16,21.33 80.65,22.84 80.56,22.84 80.47,22.75 80.47,22.67 81.6,21.54 81.6,21.46 81.51,21.37 81.43,21.37 80.87,21.93 80.78,21.93 80.7,21.84 80.7,21.75 81.43,21.02 86.81,21.02 87.11,21.33 87.11,21.81 90.93,25.63 93.32,25.63 94.97,25.63 95.47,26.13 95.62,26.13 96.2,26.7 99.14,26.7 103.44,31 103.44,31 103.59,31.16 103.59,32.62 104.5,33.52 104.5,33.76 104.86,34.12 104.86,35.37 104.99,35.5 104.99,35.94 105.51,36.45 106.76,36.45 106.98,36.23 107.86,36.23 108,36.36 108.7,36.36 v4(109.39,35.68)
  IN3 w0.064: v4(41.65,7.75) 41.65,8.55 42.59,9.49 44.96,9.49 45.13,9.66 45.67,9.66 46.32,10.31 46.32,12.1 47.12,12.9 47.12,13.93 47.28,14.09 47.28,15.07 47.92,15.71 47.92,17.5 48.18,17.76 48.61,17.76 49.64,18.79 49.64,19.26 50.37,19.99 v6(50.58,19.99) ; v4(142.82,55.84) 143.01,55.65 143.01,54.28 142.42,53.68 142.01,53.68 141.59,53.27 140.83,53.27 139.9,52.34 138.77,52.34 138.41,51.98 138.41,51.36 137.58,50.54 137.58,50.46 136.97,49.85 136.97,49.38 136.53,48.94 134.29,48.94 133.98,49.24 133.57,49.24 132.73,48.4 127.38,48.4 127.14,48.15 124.28,48.15 124.27,48.15 123.97,47.84 122.71,47.84 121.84,46.97 120.07,46.97 119.38,47.67 117.66,47.67 117.13,47.13 116.96,47.13 115.92,46.09 114.91,46.09 114.54,45.72 114.54,44.1 113.34,42.91 112.87,42.91 112.33,42.37 112.33,41.39 110.87,39.93 110.87,38.31 109.99,37.43 109.99,36.28 v4(109.39,35.68)
ESPI_CLK_R: length 0.9
  IN1 w0.064: v4(144.02,55.73) 144.01,55.74 144.01,56.17 v2(144,56.18)
  IN3 w0.064: v4(144.02,55.73) 144.02,55.49 v5(144.19,55.32)
ESPI_CS#: length 152.2
  TOP w0.081: UE1.B17 49.98,19.94 50.08,19.85 50.08,19.28 v2(50.33,19.03) ; v1(68.24,13.98) 68.21,14.01 v2(68.21,14.56)
  IN1 w0.064: v2(42.75,5.49) 41.93,6.31 41.47,6.31 41.08,6.7 v4(41.08,7.7) ; v4(111.23,37.72) 111.23,37.47 110.48,36.72 110.48,34.11 111.48,33.11 111.48,33.1 113.41,31.16 113.41,29.51 112.74,28.83 112.74,27.87 113.04,27.56 113.04,27.1 113.04,27.1 113.04,26.4 111.47,24.83 111.47,22.28 111.14,21.96 107.81,21.96 105.82,19.97 105.82,18.98 104.27,17.43 98.26,17.43 97.9,17.08 93.03,17.08 91.12,15.17 91.12,13.92 90.06,12.85 87.4,12.85 86.88,13.38 85.33,13.38 85.29,13.34 84.61,13.34 84.6,13.35 84.02,13.35 83.88,13.49 75.75,13.49 74.68,14.56 v2(68.21,14.56) 68.11,14.56 67.56,15.11 66.65,15.11 65.28,16.47 63.38,16.47 61.92,17.93 61.47,17.93 61.43,17.97 59.82,17.97 59.62,18.17 54.67,18.17 54.17,18.67 52.43,18.67 52.19,18.43 51,18.43 50.4,19.03 v2(50.33,19.03) 50.05,19.03 49.74,19.34 v4(49.09,19.34)
  IN3 w0.064: v4(111.23,37.72) 111.28,37.72 112.22,38.66 112.22,39.77 112.41,39.95 112.41,40.83 112.78,41.2 112.78,42.17 113.08,42.47 113.53,42.47 114.98,43.92 114.98,44.14 116.02,45.18 116.26,45.18 116.49,45.4 116.49,45.86 118.11,47.47 118.94,47.47 119.89,46.53 122.02,46.53 122.89,47.4 124.15,47.4 124.45,47.7 124.46,47.7 127.32,47.7 127.57,47.95 128.47,47.95 128.61,48.1 132.62,48.1 132.75,48.22 132.75,48.22 133.63,49.1 133.92,49.1 134.23,48.8 136.6,48.8 137.11,49.31 137.11,49.79 138.07,50.74 138.07,50.77 138.62,51.33 138.62,51.97 138.85,52.19 139.99,52.19 140.64,52.84 141.03,52.84 141.49,52.38 v5(142.1,52.38) ; v4(41.08,7.7) 41.08,8.61 42.93,10.46 44.46,10.46 44.51,10.41 45.6,10.41 45.87,10.68 45.87,12.28 46.67,13.08 46.67,14.12 46.83,14.28 46.83,15.25 47.48,15.9 47.48,17.68 48,18.2 48.42,18.2 49.09,18.87 v4(49.09,19.34)
  BOTTOM w0.081: v5(142.1,52.38) 142.16,52.38 142.37,52.59 UC1.CA28
ESPI_IO0: length 143.4
  TOP w0.081: v2(40.75,5.49) 40.75,5.87 40.18,6.44 v1(40.18,7.27) ; UE1.A17 51.54,21.18 v2(51.86,20.87)
  IN1 w0.064: v2(40.75,5.49) 40.38,5.49 38.52,7.35 v4(38.52,7.92) ; v4(51.46,20.82) 51.52,20.88 51.85,20.88 v2(51.86,20.87) ; v4(113.14,36.79) 113.81,36.13 113.81,33.23 113.76,33.18 113.76,32.85 113.76,32.85 113.76,32.66 114.53,31.89 114.53,29.04 114.33,28.84 114.33,26.04 113.48,25.2 113.48,24.49 113.37,24.39 113.37,21.96 112.25,20.84 112.09,20.84 108.32,20.84 107.09,19.6 107.09,18.53 104.88,16.32 98.72,16.32 98.37,15.96 93.5,15.96 92.24,14.7 92.24,13.45 90.52,11.74 86.94,11.74 86.41,12.26 85.8,12.26 85.75,12.22 84.14,12.22 84.13,12.23 83.56,12.23 83.41,12.38 75.28,12.38 74.22,13.44 67.83,13.44 67.82,13.43 66.15,13.43 65.27,14.32 65.27,14.9 64.93,15.24 62.82,15.24 62.01,16.05 62.01,16.26 60.87,17.4 59.58,17.4 59.38,17.6 55.07,17.6 54.83,17.36 54.8,17.36 54.17,16.73 52.69,16.73 51.76,15.8 47.25,15.8 46.78,15.33 46.19,15.33 46.08,15.45 45.36,15.45 v4(45.29,15.52)
  IN3 w0.064: v4(113.14,36.79) 113.16,36.79 116.78,40.41 116.97,40.41 119.19,42.63 119.75,42.63 120.8,43.69 122.71,43.69 123.38,44.35 124.28,44.35 124.64,44.72 124.65,44.72 124.83,44.9 v5(124.83,45.15) ; v4(38.52,7.92) 38.52,8.28 38.98,8.74 39.57,8.74 40.33,9.5 40.33,10.15 41.45,11.27 43.38,11.27 45.2,13.09 45.2,15.44 v4(45.29,15.52) 45.19,15.62 45.19,16.24 45.87,16.92 45.87,17.34 47.02,18.49 47.02,18.72 47.97,19.66 47.97,22.03 47.65,22.35 47.65,23.67 48.03,24.05 49.49,24.05 51.26,22.29 51.26,21.18 51.46,20.97 v4(51.46,20.82)
  BOTTOM w0.081: v5(124.83,45.15) 124.99,45.15 RC192.2
ESPI_IO0_R: length 22.9
  IN1 w0.064: v4(142.05,52.85) 141.51,52.3 141.51,51.56 141.13,51.19 v4(141.13,50.34)
  IN3 w0.064: v4(142.05,52.85) 142.37,53.17 v5(142.37,53.37) ; v4(141.13,50.34) 141.09,50.34 140.5,49.74 140.5,48.51 140.39,48.41 140.39,47.94 140.22,47.76 140.22,46.99 139.35,46.13 136.53,46.13 136.19,46.47 135.81,46.47 135.79,46.49 134.83,46.49 134.02,45.68 132.34,45.68 131.71,45.05 131.41,45.05 131.41,45.05 127.14,45.05 v5(127.04,45.15)
  BOTTOM w0.081: v5(127.04,45.15) 126.67,45.15 126.39,45.43 RC192.1
ESPI_IO1: length 140.7
  TOP w0.081: v1(41.85,7.74) 41.8,7.69 41.26,7.69 40.84,7.27 40.84,6.31 41.25,5.91 v2(41.25,5.49)
  IN1 w0.064: v2(41.25,5.49) 41.25,5.72 40.28,6.69 39.67,6.69 39.4,6.96 v4(39.4,7.7) ; v4(50.9,21.89) 51.36,21.89 51.43,21.82 v2(51.43,21.68) ; v4(45.56,16.02) 45.93,16.02 46.23,15.72 46.75,15.72 47.14,16.1 48.19,16.1 48.3,15.99 49.73,15.99 50.11,16.37 50.77,16.37 51.55,17.14 52.33,17.14 52.55,16.92 54.09,16.92 54.72,17.55 54.75,17.55 54.99,17.79 59.46,17.79 59.66,17.59 60.95,17.59 62.2,16.33 62.2,16.13 62.9,15.43 65.01,15.43 65.51,14.94 65.51,14.35 66.23,13.63 67.74,13.63 67.75,13.63 74.3,13.63 75.36,12.57 83.49,12.57 83.64,12.42 84.21,12.42 84.22,12.41 85.67,12.41 85.72,12.45 86.49,12.45 87.02,11.93 90.44,11.93 92.05,13.53 92.05,14.78 93.42,16.15 98.29,16.15 98.64,16.51 104.8,16.51 106.9,18.61 106.9,19.68 108.24,21.03 112.17,21.03 113.18,22.04 113.18,24.46 113.29,24.57 113.29,25.28 114.13,26.12 114.13,28.92 114.34,29.12 114.34,31.81 113.45,32.7 v4(113.45,35.09)
  IN3 w0.064: v4(50.9,21.89) 50.76,22.03 50.76,22.5 49.4,23.86 48.11,23.86 47.84,23.59 47.84,22.82 48.27,22.38 48.27,19.7 47.21,18.64 47.21,18.22 46.82,17.84 46.82,17.2 46.48,16.85 46.16,16.85 45.56,16.26 v4(45.56,16.02) 45.75,15.83 45.75,15.42 45.44,15.12 45.44,13.06 43.46,11.08 42.74,11.08 41.99,10.32 41.42,10.32 39.5,8.4 39.5,7.8 v4(39.4,7.7) ; v4(113.45,35.09) 113.52,35.17 113.52,36.89 116.85,40.22 117.05,40.22 119.01,42.19 119.57,42.19 120.88,43.49 122.79,43.49 123.46,44.16 124.36,44.16 124.72,44.53 124.73,44.53 124.74,44.54 124.84,44.54 v5(125.12,44.82)
  BOTTOM w0.081: RC193.2 v5(125.12,44.82)
ESPI_IO1_R: length 24.4
  IN1 w0.064: v4(143.6,53.08) 143.47,52.95 142.78,52.95 142.37,52.54 142.37,51.69 141.69,51.02 v4(141.69,49.9)
  IN3 w0.064: v4(141.69,49.9) 141.62,49.82 141.62,49.36 141.32,49.07 141.32,48.9 140.84,48.42 140.84,47.74 141.06,47.53 141.06,46.4 140.7,46.03 140.18,46.03 140.13,45.98 137.79,45.98 137.74,45.94 137.15,45.94 136.58,45.36 135.69,45.36 135.43,45.36 135.41,45.35 135.37,45.35 135.36,45.33 133.98,45.33 133.82,45.49 132.42,45.49 131.78,44.86 126.9,44.86 v5(126.83,44.79) ; v5(143.28,53.37) 143.3,53.37 v4(143.6,53.08)
  BOTTOM w0.081: RC193.1 126.81,44.82 v5(126.83,44.79)
ESPI_IO2: length 137
  TOP w0.081: v2(49.29,22.98) 49.56,22.71 49.56,22.54 50.17,21.93 UE1.B20 ; v2(41.75,5.49) 41.75,6 v1(41.24,6.52)
  IN1 w0.064: v4(39.94,7.7) 40.07,7.57 40.07,7.36 40.01,7.3 39.68,7.3 39.62,7.23 39.62,7.11 39.68,7.05 40.19,7.05 41.75,5.49 v2(41.75,5.49) ; v4(45.84,14.99) 45.85,14.99 46.9,14.99 47.31,15.39 51.62,15.39 52.77,16.54 54.28,16.54 55.14,17.41 59.31,17.41 59.5,17.21 60.79,17.21 61.82,16.18 61.82,15.97 62.22,15.57 62.22,14.58 62.56,14.24 63.6,14.24 64.01,13.83 64.35,13.83 64.7,14.19 65.13,14.19 66.07,13.24 67.9,13.24 67.91,13.25 74.14,13.25 75.2,12.19 83.33,12.19 83.48,12.04 84.06,12.04 84.07,12.03 85.83,12.03 85.88,12.07 86.33,12.07 86.86,11.55 90.6,11.55 92.43,13.38 92.43,14.62 93.58,15.77 98.45,15.77 98.8,16.13 104.95,16.13 107.28,18.45 107.28,19.52 108.4,20.65 112.01,20.65 112.76,20.65 113.56,21.45 113.56,24.31 113.67,24.42 113.67,25.12 114.52,25.96 114.52,28.76 114.72,28.96 114.72,31.97 114.64,32.05 114.64,33.47 114.45,33.66 114.45,33.66 114,34.11 114,36.36 v4(114.33,36.69) ; v2(49.29,22.98) 49.29,23.44 48.94,23.79 48.55,23.79 48.26,23.5 v4(48.26,23.5)
  IN3 w0.064: v4(114.33,36.69) 114.86,37.21 115.55,37.21 116.27,37.94 116.68,37.94 117.01,38.27 117.71,38.27 118.84,39.4 119.81,40.37 120.38,40.37 120.83,40.82 123.99,40.82 124.24,40.57 124.85,40.57 v5(125.01,40.41) ; v4(39.94,7.7) 39.76,7.88 39.76,8.37 40.07,8.68 40.16,8.68 40.34,8.5 40.42,8.5 40.51,8.58 40.51,8.67 40.33,8.85 40.33,8.93 41.44,10.05 41.98,10.05 42.82,10.89 43.58,10.89 45.73,13.04 45.73,14.88 v4(45.84,14.99) 45.84,15.14 46.04,15.34 46.04,16.41 46.29,16.66 46.56,16.66 47.02,17.12 47.02,17.76 47.4,18.14 47.4,18.56 48.95,20.1 48.95,22.22 48.26,22.91 v4(48.26,23.5)
  BOTTOM w0.081: v5(125.01,40.41) 125.03,40.39 125.15,40.39 RC194.2
ESPI_IO2_R: length 24.5
  IN1 w0.064: v4(142.75,51.81) 141.92,49.46 v4(141.77,49.02)
  IN3 w0.064: v5(143.28,52.07) v4(142.75,51.81) ; v4(141.77,49.02) 141.27,48.07 141.27,45.11 140.31,44.16 138.79,44.16 137.68,43.99 137,43.73 136.99,43.74 136.94,43.72 136.82,43.67 135.36,43.12 133.52,43.12 133.33,42.93 130.47,42.93 129.33,41.8 129.2,41.74 126.84,41.74 v5(126.78,41.68)
  BOTTOM w0.081: RC194.1 126.25,41.03 v5(126.78,41.68)
ESPI_IO3: length 134.1
  TOP w0.081: v2(64.1,13.48) 64.15,13.48 v1(64.86,12.77)
  IN1 w0.064: v2(51.43,22.18) 51.25,22.37 50.19,22.37 49.97,22.59 v4(49.97,22.65) ; v2(42.25,5.49) 41.62,6.12 41.39,6.12 40.52,6.99 v4(40.52,7.7) ; v4(46.26,14.62) 46.44,14.8 46.98,14.8 47.39,15.2 51.7,15.2 52.84,16.35 54.36,16.35 55.22,17.22 59.23,17.22 59.42,17.02 60.71,17.02 61.58,16.15 61.58,15.94 62.03,15.5 62.03,14.51 62.48,14.05 63.52,14.05 v2(64.1,13.48) 64.26,13.48 64.68,13.9 65.15,13.9 66,13.05 71.37,13.05 72.65,11.77 74.24,11.77 74.3,11.84 74.32,11.84 74.46,11.98 74.8,11.98 74.81,11.99 83.26,11.99 83.4,11.85 83.98,11.85 83.99,11.84 85.91,11.84 85.95,11.88 86.25,11.88 86.78,11.36 90.68,11.36 92.62,13.3 92.62,14.54 93.65,15.58 98.52,15.58 98.88,15.94 105.03,15.94 107.47,18.37 107.47,19.39 108.54,20.46 111.93,20.46 112.68,20.46 112.84,20.46 113.75,21.37 113.75,24.09 114.71,25.05 114.71,28.68 114.91,28.89 114.91,32.05 114.83,32.13 114.83,33.54 114.64,33.74 114.64,33.74 114.19,34.19 114.19,35.81 114.97,36.59 v4(114.97,36.78)
  IN3 w0.064: v5(124.73,40.15) 124.71,40.15 124.48,40.38 124.16,40.38 123.91,40.63 120.91,40.63 120.46,40.18 119.89,40.18 119.03,39.32 119.03,39.32 117.79,38.08 117.09,38.08 116.69,37.67 116.28,37.67 115.38,36.78 v4(114.97,36.78) ; v4(49.97,22.65) 49.97,22.06 49.31,21.41 49.31,20.2 47.59,18.48 47.59,18.07 47.21,17.68 47.21,17.05 46.63,16.47 46.37,16.47 46.23,16.33 46.23,14.65 v4(46.26,14.62) 46.26,14.47 46.09,14.3 46.09,13.09 43.7,10.7 42.9,10.7 41.83,9.63 41.74,9.63 41.57,9.8 41.48,9.8 41.4,9.71 41.4,9.63 41.57,9.46 41.57,9.37 41.48,9.28 41.4,9.28 41.23,9.46 41.14,9.46 41.05,9.37 41.05,9.28 41.23,9.11 41.23,9.03 41.14,8.94 41.05,8.94 40.88,9.11 40.79,9.11 40.71,9.02 40.71,8.94 40.88,8.77 40.88,8.68 40.46,8.26 40.26,8.26 40.2,8.2 40.2,8.07 40.26,8.01 40.46,8.01 40.52,7.95 v4(40.52,7.7)
  BOTTOM w0.081: RC195.2 124.85,40.03 v5(124.73,40.15)
ESPI_IO3_R: length 25.3
  IN3 w0.064: v5(144.19,52.07) 144.02,52.06 143.96,51.99 142.94,50.79 142.37,49.71 141.98,48.61 141.5,48.02 141.5,45.08 140.39,43.97 139.08,43.97 137.24,43.58 137.14,43.58 137.11,43.57 137.09,43.55 137.02,43.54 137,43.53 136.99,43.53 135.56,42.93 133.6,42.93 132.76,42.08 129.99,42.08 129.46,41.55 127.81,41.55 v5(126.77,40.76)
  BOTTOM w0.081: v5(126.77,40.76) 126.77,40.57 126.24,40.03 RC195.1
ESPI_RESET#: length 134.3
  TOP w0.081: v2(50.77,18) 50.81,17.96 RE535.2 ; RC205.2 v2(142.02,52.3) ; v2(49.46,20.04) 49.46,20.06 49.48,20.09 UE1.B16
  IN1 w0.064: v2(142.02,52.3) 141.88,52.16 141.88,51.8 v4(141.92,51.76) ; v4(112.2,37.52) 112.2,37.4 111.21,36.41 111.21,35.32 112.21,34.32 112.21,33.51 114.15,31.57 114.15,29.2 113.94,29 113.94,26.2 113.1,25.36 113.1,24.76 112.2,23.87 112.2,21.62 111.81,21.22 108.16,21.22 106.71,19.76 106.71,18.82 104.58,16.7 98.56,16.7 98.21,16.34 93.34,16.34 91.86,14.86 91.86,13.61 90.36,12.12 87.1,12.12 86.57,12.64 85.64,12.64 85.59,12.6 84.3,12.6 84.29,12.61 83.72,12.61 83.57,12.76 75.44,12.76 74.37,13.82 67.67,13.82 67.66,13.82 66.44,13.82 65.87,14.38 65.87,14.84 65.09,15.62 62.98,15.62 62.4,16.2 62.4,16.41 61.02,17.78 59.74,17.78 59.54,17.98 54.48,17.98 54.36,18.1 53.4,18.1 53.09,17.8 50.97,17.8 v2(50.77,18) 50.73,18.03 50.73,18.33 50.41,18.66 50.07,18.66 49.76,18.98 48.94,18.98 48.68,19.24 48.68,19.45 49,19.78 49.39,19.78 49.46,19.84 v2(49.46,20.04)
  IN3 w0.064: v5(142.37,52.07) 142.22,52.07 v4(141.92,51.76) 141.88,51.73 141.63,51.73 139.46,49.55 139.31,49.55 139.08,49.33 139.08,49.22 138.92,49.06 138.92,48.65 139.03,48.54 139.03,47.87 137.68,46.52 136.72,46.52 136.47,46.78 135.99,46.78 135.94,46.83 134.18,46.83 134.04,46.96 133.57,46.96 133.44,46.83 129.08,46.83 128.44,46.19 123.3,46.19 122.5,45.39 119.52,45.39 119.15,45.02 117.72,45.02 116.15,43.45 116.15,41.59 115.61,41.05 114.04,41.05 113.55,40.56 113.55,40.12 113.64,40.03 113.64,38.99 112.2,37.55 v4(112.2,37.52)
FB_1.2V:
  vias: v1(193.99,65.94)
FB_1.05V: length 4
  BOTTOM w0.254: PUH01.13 126.36,19.14 125.65,19.14 PRH09.1 125.48,18.91 126.3,18.09 PRH06.1 126.32,17.29 PRH05.2
FB_1.8V: length 3
  TOP w0.254: PR1807.1 68.85,18.72 PR1806.2 PR1805.2 69.15,20.26 69.61,20.72 PU1801.10
FB_3V: length 2.9
  BOTTOM w0.254: PR308.1 PR307.2 PC315.1 13.55,18.06 PU301.10
FB_3V_R: length 0.8
  BOTTOM w0.254: PR306.1 PC315.2
FB_5V: length 2.9
  BOTTOM w0.254: PR508.2 13.56,21.36 PR507.2 14.08,21.45 14.15,21.52 PR509.1 14.35,21.55 14.35,21.93 14.21,22.06 PU501.13
FB_+1.35VGPU: length 4.1
  TOP w0.254: PRW16.1 64.29,55.93 PRW13.2 64.31,55.03 PCW24.2 v1(65.34,55.02) 65.6,55.02 66,54.62 66.48,54.62 PUW01.14
FB_+1.35VGPU_R: length 1.8
  TOP w0.081: PRW21.2 v1(61.62,54.99)
  TOP w0.254: PRW21.2 63.36,54.99 PCW24.1
FB_A_CLK0: length 20.5
  TOP w0.102: v6(90.64,67.36) 90.94,67.67 90.94,67.87 90.84,67.98 90.65,67.98 UV6.J12
  IN3 w0.089: v6(90.78,57.45) 90.78,57.84 90.89,57.96 90.89,58.61 91.43,59.15 91.43,59.41 92.02,60 92.02,60.39 92.51,60.87 94.01,60.87 94.39,61.25 94.39,61.74 94.18,61.94 94.18,62.06 94.37,62.26 94.37,62.57 93.81,63.12 93.81,63.64 92.49,64.96 91.12,64.96 90.71,65.38 90.71,65.49 90.9,65.68 90.9,65.97 90.48,66.39 90.19,66.39 90,66.2 89.88,66.2 89.62,66.46 89.62,67.02 89.88,67.27 90.21,67.27 90.3,67.36 v6(90.64,67.36)
  BOTTOM w0.102: v6(90.78,57.45) 90.72,57.51 UV1.D24 ; v6(90.64,67.36) 90.49,67.52 90.49,67.78 90.66,67.95 90.66,68.23 90.04,68.85 RV1.1
FB_A_CLK0_R: length 1
  BOTTOM w0.081: CV4.1 89.23,68.85 89.38,68.85 RV2.1 89.79,69.26 RV1.2
FB_A_CLK1: length 32.3
  TOP w0.102: UV8.J12 84.07,40.19 84.05,40.21 v6(84.05,40.22)
  IN1 w0.089: v6(84.05,40.22) 84.34,40.22 84.56,40.44 84.78,40.65 84.78,41.55 85.23,42.01 85.23,42.63 81.9,45.96 81.9,48.38 85.36,51.84 92.84,51.84 93.81,52.82 93.82,52.82 94.17,53.16 94.17,53.62 95.15,54.6 96.89,54.6 97.3,54.19 97.3,53.73 97.16,53.59 v6(97.16,53.31)
  BOTTOM w0.102: UV1.N22 v6(97.16,53.31) ; RV3.1 84.7,40.93 84.49,40.73 84.49,40.22 84.35,40.09 84.34,40.07 84.2,40.07 v6(84.05,40.22)
FB_A_CLK1_R: length 1.2
  BOTTOM w0.081: CV5.1 84.95,42.13 RV3.2 85.24,41.05 RV4.1
FB_A_CLK#0: length 19.9
  TOP w0.102: v6(90.03,67.95) 90.03,68.48 UV6.J11
  IN3 w0.089: v6(90.03,67.95) 90.07,67.95 90.25,67.77 90.25,67.6 90.13,67.48 89.79,67.48 89.42,67.1 89.42,66.38 89.8,66 90.09,66 90.27,66.19 90.39,66.19 90.69,65.89 90.69,65.77 90.51,65.58 90.51,65.29 91.04,64.76 92.41,64.76 93.61,63.56 93.61,63.04 94.17,62.48 94.17,62.34 93.97,62.15 93.97,61.86 94.18,61.65 94.18,61.33 93.93,61.08 92.42,61.08 91.82,60.47 91.82,60.08 91.23,59.49 91.23,59.24 90.69,58.7 90.69,58.04 90.51,57.86 90.38,57.86 90.25,57.99 v6(90.16,57.99)
  BOTTOM w0.102: v6(90.03,67.95) 90.37,67.95 90.45,68.04 90.45,68.15 89.91,68.69 RV2.2 ; UV1.D25 90.16,57.99 v6(90.16,57.99)
FB_A_CLK#1: length 32.4
  TOP w0.102: UV8.J11 84.5,40.05 84.5,39.76 v6(84.64,39.63)
  IN1 w0.089: v6(96.59,53.9) 96.59,53.7 96.7,53.59 96.86,53.59 97.1,53.82 97.1,54.1 96.8,54.4 95.23,54.4 94.37,53.53 94.37,53.07 93.91,52.61 93.9,52.61 92.93,51.64 85.45,51.64 82.11,48.3 82.11,46.04 85.43,42.71 85.43,41.92 84.98,41.47 84.98,40.57 84.4,39.99 84.4,39.75 84.53,39.63 v6(84.64,39.63)
  BOTTOM w0.102: RV4.2 84.85,40.8 84.7,40.64 84.7,40.13 84.5,39.94 84.5,39.76 v6(84.64,39.63) ; UV1.M22 v6(96.59,53.9)
FB_A_CMD0: length 15.4
  TOP w0.127: v6(91.75,68.46) 91.73,68.49 91.73,69.05 91.74,69.07
  BOTTOM w0.127: 88.46,56.88 88.38,56.96 87.72,56.96 87.08,57.6 87.08,60.53 92.15,65.6 92.15,65.92 v1(91.73,66.35) 91.73,68.44 v6(91.75,68.46)
FB_A_CMD1: length 19.1
  TOP w0.127: v6(89.65,70.04) 90.05,69.64 UV6.H10
  BOTTOM w0.127: v6(89.65,70.04) 89.65,70.02 90.34,69.33 90.34,69.27 91.05,68.55 91.23,68.55 91.6,68.92 91.9,68.92 92.25,68.56 92.48,68.56 v1(92.77,68.26) 92.77,67.67 92.23,67.13 92.23,66.62 92.67,66.19 92.67,65.54 87.49,60.37 87.49,58.41 88.45,57.44 UV1.C26
FB_A_CMD2: length 17.9
  TOP w0.127: 90.61,69.07 90.59,69.09 v6(90.59,69.67)
  BOTTOM w0.127: v6(90.59,69.67) 90.89,69.97 91.66,69.97 91.91,69.71 92.34,69.71 92.98,69.08 92.98,68.7 93.26,68.42 93.26,65.58 89.13,61.45 89.13,60.29 89.78,59.64 89.78,59.59 90.21,59.15 90.21,59.1 91.24,58.08 91.24,57.69 91.32,57.6 UV1.E24
FB_A_CMD3: length 21.3
  TOP w0.127: UV6.K11 89.48,68.5 89.05,68.93 87.98,68.93 84.2,65.15 84.2,63.75 87.38,60.57 87.38,59.01 v1(88.17,58.21) 89.43,56.95 91.06,56.95 91.51,57.4 91.86,57.4 v6(91.9,57.44)
  BOTTOM w0.127: UV1.F24 91.9,56.83 v6(91.9,57.44)
FB_A_CMD4: length 15.2
  TOP w0.127: UV6.K10 88.92,67.93 v6(88.95,67.9)
  BOTTOM w0.127: UV1.D27 88.85,56.49 87.61,56.49 86.68,57.42 86.68,60.8 87.64,61.76 87.64,62.6 v1(88.54,63.5) 89.4,64.36 89.4,67.04 88.95,67.49 v6(88.95,67.9)
FB_A_CMD5: length 11.7
  TOP w0.127: UV6.L12 89.48,66.26 90.89,64.85 90.89,64.09 90.47,63.68 90.47,63.32 88.79,61.64 v1(88.79,60.03) 88.79,59.43 89.57,58.65 v6(89.57,57.42)
  BOTTOM w0.127: v6(89.57,57.42) 89.57,56.9 89.59,56.88
FB_A_CMD6: length 26.7
  TOP w0.127: v6(88.2,55.08) 86.71,55.08 83.17,58.62 83.17,59.87 81.59,61.44 v1(81.59,64.84) 81.59,65.79 86.01,70.21 86.01,70.85 85.52,71.34 UV6.K4
  BOTTOM w0.127: v6(88.2,55.08) 89.52,55.08 90.02,55.58 90.3,55.58 90.64,55.24 90.93,55.24 91.36,55.67 UV1.F25
FB_A_CMD7: length 23.9
  TOP w0.127: v6(87.6,55.67) 86.8,55.67 83.82,58.65 83.82,60 82.1,61.71 v1(82.1,63.02) 82.1,65.76 86.44,70.1 86.44,70.98 UV6.K5
  BOTTOM w0.127: v6(87.6,55.67) 88.4,55.67 88.58,55.49 89.37,55.49 89.75,55.87 90.6,55.87 UV1.F26
FB_A_CMD8: length 30.3
  TOP w0.127: v6(93.08,57.37) 94.06,57.37 94.27,57.16 94.27,56.77 93.76,56.26 93.47,56.26 93.12,55.91 92.77,55.91 92.02,55.16 88.98,55.16 84.78,59.35 v1(84.78,60.06) 82.55,62.3 82.55,65.66 86.84,69.96 86.84,71.13 86.09,71.89 UV6.J4
  BOTTOM w0.127: UV1.F23 v6(93.08,57.37)
FB_A_CMD9: length 26.8
  TOP w0.127: 86.65,71.9 86.96,71.9 87.28,71.57 87.28,69.85 82.95,65.51 82.95,62.57 85.56,59.96 85.56,59.13 v1(89.14,55.55) 91.85,55.55 92.62,56.33 92.97,56.33 93.4,56.76 v6(93.66,56.76)
  BOTTOM w0.127: UV1.G22 93.65,56.77 v6(93.66,56.76)
FB_A_CMD10: length 25.4
  TOP w0.127: v6(92.49,56.81) 91.54,56.81 91.3,56.56 89.26,56.56 86.73,59.09 v1(86.73,59.45) 86.73,60.22 83.75,63.21 83.75,65.24 88.12,69.61 88.12,71.89 87.64,72.37 87.64,72.63 87.24,73.03 86.65,73.03
  BOTTOM w0.127: v6(92.49,56.81) UV1.G23
FB_A_CMD11: length 24.2
  TOP w0.127: v6(91.9,56.23) 91.82,56.15 89.09,56.15 86.28,58.96 86.28,59.99 v1(83.99,62.28) 83.34,62.93 83.34,65.37 87.72,69.75 87.72,71.72 87.22,72.22 UV6.H5
  BOTTOM w0.127: v6(91.9,56.23) 92.48,56.23 UV1.G24
FB_A_CMD12: length 24.6
  TOP w0.127: v6(87.2,74.16) 86.65,74.16 86.65,74.16
  BOTTOM w0.127: UV1.F27 90.16,55.11 89.64,54.59 87.96,54.59 86.29,56.26 86.29,61.82 85.51,62.6 v1(85.51,63.55) 85.51,68.12 86.04,68.65 86.04,73.54 86.66,74.16 v6(87.2,74.16)
FB_A_CMD13: length 30.1
  TOP w0.127: v6(84.39,73.62) 84.42,73.59 UV6.J2
  BOTTOM w0.127: v6(84.39,73.62) 84.39,73.12 83.09,71.82 83.02,71.82 RV2437.1 82.69,71.49 82.69,71.21 83.22,70.68 83.42,70.68 83.78,70.31 83.78,70.28 84.51,69.55 84.51,69.13 83.93,68.55 83.93,62.53 85.11,61.35 85.11,55.68 v1(87.57,53.23) 90.12,53.23 91.92,55.03 UV1.G25
FB_A_CMD14: length 25.6
  TOP w0.127: v6(84.97,73) 84.99,73.03 UV6.J3
  BOTTOM w0.127: UV1.G27 90.06,53.81 87.62,53.81 85.5,55.93 85.5,61.51 84.59,62.42 v1(84.59,68.57) 85.03,69 85.03,70.24 84.54,70.73 84.38,70.73 83.96,71.15 83.96,71.44 84.39,71.87 84.39,72.43 RV2439.1 v6(84.97,73)
FB_A_CMD15: length 23.6
  TOP w0.127: UV6.L3 84.42,71.87 v6(84.42,71.29)
  BOTTOM w0.127: v6(84.42,71.29) 84.55,71.29 85.63,70.21 85.63,69.02 85.08,68.47 v1(85.08,66.74) 85.08,62.48 85.89,61.67 85.89,56.1 87.79,54.2 89.89,54.2 90.64,54.95 91.2,54.95 UV1.G26
FB_A_CMD16: length 29.7
  TOP w0.127: v6(95.98,53.31) 95.98,53.31 95.98,53.49 95.83,53.63 95.83,54.14 95.1,54.87 94.44,54.87 94.09,55.23 92.68,55.23 92.24,54.79 92.13,54.79 89.63,52.29 84.48,52.29 v1(81.67,49.49) 81.67,46.52 84.98,43.21 84.98,42.2 84.91,42.13 84.91,42.13 84.33,41.56 84.33,41.56 83.52,40.75 UV8.L12
  BOTTOM w0.127: v6(95.98,53.31) 95.44,53.31 95.43,53.3
FB_A_CMD17: length 26.3
  TOP w0.127: v6(95.39,53.91) 94.86,54.45 94.46,54.45 93.97,54.94 93.37,54.94 93.27,54.84 92.86,54.84 89.92,51.9 v1(88.32,51.9) 84.67,51.9 82.13,49.37 82.13,46.63 85.37,43.39 85.37,42.04 UV8.K10
  BOTTOM w0.127: UV1.M23 95.95,53.91 v6(95.39,53.91)
FB_A_CMD18: length 24.8
  TOP w0.127: v6(93.67,54.51) 93.11,54.51 v1(91.56,52.96) 90.12,51.51 84.91,51.51 82.64,49.24 82.64,46.78 85.94,43.48 85.94,41.97 85.64,41.67 85.54,41.67 84.81,40.94 84.49,40.94 84.29,40.75 UV8.K11
  BOTTOM w0.127: UV1.K24 93.69,54.49 v6(93.67,54.51)
FB_A_CMD19: length 35
  TOP w0.127: v6(94.85,55.58) 95.05,55.78 95.58,55.78 95.84,56.05 96.37,56.05 96.63,55.79 96.63,55.2 97.91,53.91 97.91,53.1 98.18,52.84 98.18,52.52 97.93,52.27 97.93,52.24 97.65,51.96 97.65,50.59 95.9,48.83 95.9,43.39 96.48,42.8 96.48,39.94 v1(93.89,37.35) 91.27,37.35 87.63,41 86.29,41 85.99,40.71 85.78,40.71 85.41,40.33 85.41,39.82 UV8.H11
  BOTTOM w0.127: v6(94.85,55.58) 94.81,55.54 UV1.K23
FB_A_CMD20: length 16.9
  TOP w0.127: v6(86.37,40.42) 86.32,40.42 86.09,40.18 UV8.H10
  BOTTOM w0.127: v6(86.37,40.42) 87.73,40.42 89.26,41.95 90.43,41.95 91,42.52 91.54,42.52 91.98,42.96 92.22,42.96 92.5,43.24 92.5,44.04 93.42,44.96 v1(93.42,45.67) 93.42,50.45 93.73,50.76 UV1.M27
FB_A_CMD21: length 19.4
  TOP w0.127: UV8.G12 v6(85.21,39.02)
  BOTTOM w0.127: v6(85.21,39.02) 85.21,40.11 85.5,40.41 85.6,40.41 86.2,41 87.36,41 88.77,42.42 90.22,42.42 90.79,42.98 90.79,43 91.47,43.68 91.51,43.68 91.94,44.11 91.94,44.69 92.99,45.75 v1(92.99,48.81) 92.99,50.7 93.29,51 93.29,51.71 93.57,51.99 93.99,51.99 94.16,52.17 UV1.M26
FB_A_CMD22: length 19.6
  TOP w0.127: v6(89.15,44.08) 89.15,44.04 89.17,44.02 UV8.H4
  BOTTOM w0.127: v6(89.15,44.08) 89.14,44.08 88.44,43.39 88.44,43.1 88.66,42.88 89.21,42.88 91.27,44.95 91.27,45.25 91.7,45.68 92.14,45.68 92.53,46.07 92.53,46.47 92.39,46.6 92.15,46.6 92.02,46.74 92.02,47.01 92.15,47.14 v1(92.28,47.14) 92.39,47.14 92.53,47.28 92.53,47.55 92.39,47.68 91.97,47.68 91.84,47.81 91.84,48.08 91.97,48.22 92.39,48.22 92.53,48.35 92.53,48.62 92.39,48.76 91.97,48.76 91.84,48.89 91.84,49.16 91.97,49.3 92.39,49.3 92.53,49.43 92.53,49.7 92.39,49.83 91.97,49.83 91.84,49.97 91.84,50.24 91.97,50.37 92.39,50.37 92.53,50.51 92.53,50.87 92.9,51.25 92.9,51.88 93.4,52.38 93.87,52.38 94.05,52.57 94.7,52.57 UV1.M25
FB_A_CMD23: length 19.4
  TOP w0.127: v6(88.25,42.5) 88.6,42.86 UV8.H5
  BOTTOM w0.127: v6(88.25,42.5) 87.16,41.41 86.42,41.41 86.1,41.74 86.1,42.11 86.79,42.81 87.27,42.81 88.98,44.51 89.34,44.51 89.66,44.19 89.96,44.19 90.77,44.99 90.77,45.56 91.59,46.38 91.59,47.05 91.38,47.26 v1(91.38,49.77) 91.38,50.34 92.5,51.45 92.5,52.03 93.11,52.64 UV1.K26
FB_A_CMD24: length 32.4
  TOP w0.127: v6(96.18,55.62) 96.18,55.05 97.61,53.62 97.61,53.17 97.19,52.75 97.19,52.61 96.69,52.12 96.4,52.12 95.51,51.22 v1(95.51,45.87) 95.51,43.23 96.08,42.66 96.08,40.27 93.64,37.84 91.53,37.84 87.36,42 87.36,43.13 87.57,43.33 87.57,43.68 88.03,44.14 UV8.J4
  BOTTOM w0.127: UV1.K22 96.15,55.65 v6(96.18,55.62)
FB_A_CMD25: length 30.3
  TOP w0.127: UV8.J5 88.03,43.15 87.77,42.89 87.77,42.2 91.65,38.32 93.51,38.32 95.62,40.42 95.62,42.52 94.98,43.16 v1(94.98,47.7) 94.98,51.5 95.87,52.39 95.87,52.6 96.47,53.19 96.47,53.43 96.15,53.74 96.15,54.27 95.26,55.16 94.63,55.16 94.29,55.5 v6(94.29,56.18)
  BOTTOM w0.127: UV1.J23 94.24,56.13 v6(94.29,56.18)
FB_A_CMD26: length 21.3
  TOP w0.127: v6(93.11,53.91) 93.08,53.91 v1(90.29,51.12) 85.11,51.12 83.12,49.14 83.12,46.85 86.06,43.91 86.68,43.91 87.48,44.71 UV8.K4
  BOTTOM w0.127: UV1.J25 v6(93.11,53.91)
FB_A_CMD27: length 17.8
  TOP w0.127: UV8.K5 87.12,43.8 v6(87.12,43.72)
  BOTTOM w0.127: v6(87.12,43.72) 87.12,44.82 87.39,45.09 87.39,46.65 86.96,47.08 86.96,48.69 87.69,49.42 87.69,49.91 87.02,50.57 v1(87.02,51.13) 87.02,51.71 87.91,52.6 88.73,52.6 89.03,52.29 90.53,52.29 91.33,53.09 91.33,53.25 93.13,55.05 UV1.J24
FB_A_CMD28: length 18.8
  TOP w0.127: v6(89.14,46.44) 89.14,46.41 88.51,45.78 88.29,45.78 88.25,45.78 88.16,45.77 88.12,45.75 UV8.L3
  BOTTOM w0.127: UV1.K27 92.55,52.63 92.06,52.14 92.06,51.63 90.91,50.47 90.72,50.47 90.46,50.73 90.27,50.73 90.08,50.54 90.08,50.35 90.97,49.46 90.97,49.27 90.78,49.08 90.59,49.08 89.7,49.97 89.5,49.97 89.31,49.78 89.31,49.59 89.57,49.33 89.58,49.33 89.58,49.14 89.3,48.86 89.3,48.67 89.49,48.48 89.68,48.48 89.96,48.76 90.15,48.76 90.49,48.41 90.74,48.41 90.85,48.3 90.85,47.99 90.74,47.87 89.48,47.87 89.48,47.85 89.16,47.53 88.79,47.53 88.69,47.43 v1(88.69,47.26) 88.69,47.08 88.78,46.98 90.2,46.98 90.29,46.89 90.29,46.67 90.16,46.54 89.24,46.54 v6(89.14,46.44)
FB_A_CMD29: length 23.2
  TOP w0.127: UV8.J2 v6(90.33,45.27) 91.52,46.46 91.52,48.8 91.66,48.94 91.93,48.94 92.06,48.8 92.06,47.04 92.2,46.9 92.47,46.9 92.6,47.04 92.6,50.5 92.74,50.63 93,50.63 93.14,50.5 93.14,47.08 93.27,46.95 93.54,46.95 93.68,47.08 v1(93.68,49.52) 93.68,53.31 v6(93.7,53.33)
  BOTTOM w0.127: RV2438.1 90.26,45.71 90.26,45.34 v6(90.33,45.27) ; UV1.K25 93.7,53.9 v6(93.7,53.33)
FB_A_CMD30: length 17.1
  TOP w0.127: UV8.J3 v6(89.17,45.28)
  BOTTOM w0.127: UV1.J27 91.73,53.11 91.73,52.91 91.25,52.43 91.25,51.95 90.91,51.61 90.55,51.61 90.29,51.88 89.98,51.88 89.85,51.74 89.85,51.53 89.71,51.4 89.44,51.4 89.31,51.53 v1(89.31,51.74) 89.31,51.74 89.17,51.88 88.85,51.88 88.54,52.19 88.1,52.19 87.42,51.51 87.42,51.29 87.65,51.06 87.65,50.87 87.58,50.8 87.58,50.61 87.77,50.42 87.96,50.42 88.03,50.49 88.22,50.49 88.39,50.32 88.39,48.86 RV2440.1 87.82,48.29 87.82,47.96 87.69,47.83 87.5,47.83 87.37,47.69 87.37,47.42 87.5,47.29 87.69,47.29 87.82,47.15 87.82,45 87.92,44.89 88.16,44.89 88.41,45.15 89.03,45.15 v6(89.17,45.28)
FB_A_CMD31: length 17.6
  TOP w0.127: UV8.G3 90.3,44.15 v6(89.78,44.68)
  BOTTOM w0.127: UV1.J26 92.68,53.79 92.68,53.39 92.54,53.25 92.43,53.25 92.14,52.96 92.14,52.77 91.66,52.29 91.66,51.78 91.07,51.19 90.07,51.19 89.58,50.71 89.39,50.71 88.39,51.71 88.2,51.71 88.01,51.52 88.01,51.33 89.01,50.33 89.01,50.14 88.8,49.93 v1(88.8,49.47) 88.8,48.49 88.25,47.94 88.25,45.78 88.4,45.63 88.72,45.63 88.94,45.85 89.22,45.85 89.74,45.32 89.74,44.71 v6(89.78,44.68)
FB_A_D0: length 39
  TOP w0.127: UV6.A4 v2(90.98,77.35)
  IN1 w0.094: v6(94.81,60.42) 94.39,60.42 93.96,60.85 93.31,60.85 93.16,60.7 86.03,60.7 81.42,65.31 81.42,66.26 80.4,67.28 80.4,68.05 80.56,68.2 80.56,69.24 81.57,70.26 81.66,70.26 82.19,70.78 82.19,70.87 82.71,71.4 82.78,71.4 83.28,71.9 83.28,71.97 83.75,72.43 83.94,72.43 84.03,72.52 84.03,72.66 84.11,72.75 84.41,72.75 84.5,72.66 84.5,72.52 84.72,72.3 85.13,72.3 85.72,71.71 85.92,71.71 86.01,71.8 86.01,72.4 86.02,72.4 86.25,72.63 86.25,72.76 86.11,72.9 86.11,73.02 86.32,73.23 86.44,73.23 86.63,73.04 86.76,73.04 87.26,73.53 87.26,73.65 87.85,74.25 87.85,74.3 88.93,75.38 88.93,75.5 88.7,75.74 88.7,75.87 88.9,76.07 89.03,76.07 89.26,75.84 89.39,75.84 89.6,76.04 89.6,76.17 89.21,76.55 89.21,76.68 89.42,76.89 89.54,76.89 89.93,76.5 90.13,76.5 v2(90.98,77.35)
  BOTTOM w0.127: UV1.E18 v6(94.81,60.42)
FB_A_D1: length 39.8
  TOP w0.127: UV6.A2 v2(89.82,78.46)
  IN1 w0.094: v6(95.38,59.82) 95.38,60.54 94.93,61 94.48,61 94.25,61.22 94.25,61.6 93.86,62 93.41,62 92.51,61.1 86.2,61.1 81.93,65.37 81.93,67.44 81.17,68.2 81.17,68.63 82.11,69.57 82.11,69.77 83.04,70.69 85.49,70.69 87.26,72.46 87.26,72.59 87.13,72.72 87.13,72.85 87.34,73.05 87.47,73.05 87.6,72.92 87.79,72.92 88.13,73.27 90.67,75.81 90.67,76 90.5,76.18 90.5,76.3 90.7,76.51 91.31,76.51 91.4,76.6 91.4,78.37 91.31,78.46 v2(89.82,78.46)
  BOTTOM w0.127: UV1.F18 95.38,60.35 v6(95.38,59.82)
FB_A_D2: length 54.6
  TOP w0.127: UV6.B4 v2(90.05,77.04)
  IN1 w0.094: v2(90.05,77.04) 90.05,77.55 89.46,78.14 88.55,78.14 87.99,78.7 83.88,78.7 83.08,77.9 83.08,77.69 82.49,77.1 82.27,77.1 76.55,71.38 76.55,65.31 84.92,56.94 87.58,56.94 88.44,56.07 89.83,56.07 90.7,55.2 93.89,55.2 94.75,56.07 94.75,56.21 95.57,57.03 95.57,57.44 97.13,58.99 97.13,60.38 v6(96,61.51)
  BOTTOM w0.127: UV1.E16 v6(96,61.51)
FB_A_D3: length 48.7
  TOP w0.127: v2(88.36,77.62) 88.44,77.55 UV6.B2
  IN1 w0.094: v2(88.36,77.62) 88.36,77.76 87.82,78.3 84.05,78.3 83.48,77.74 83.48,77.53 82.66,76.7 82.44,76.7 76.95,71.21 76.95,65.48 85.09,57.33 87.74,57.33 88.55,56.53 89.94,56.53 90.87,55.6 92.77,55.6 93.36,56.2 93.72,56.2 94.32,56.8 94.32,57.1 94.73,57.51 95.08,57.51 96.62,59.05 v6(96.62,59.89)
  BOTTOM w0.127: v6(96.62,59.89) 96.62,60.34 UV1.F17
FB_A_D4: length 37.6
  TOP w0.127: v2(88.3,75.3) 88.35,75.25 UV6.E4
  IN1 w0.094: v2(88.3,75.3) 88.23,75.38 88.23,75.8 87.5,76.52 87.2,76.52 86.18,75.5 86.18,75.38 86.1,75.3 86.09,75.29 86.02,75.29 85.93,75.21 85.93,74.91 86.02,74.82 86.09,74.82 86.18,74.74 86.18,74.46 85.95,74.23 84.97,74.23 84.72,74.48 84.07,74.48 83.96,74.38 83.96,73.69 83.87,73.6 83.58,73.6 83.49,73.69 83.49,74.18 83.4,74.27 83.15,74.27 80.51,71.64 80.51,71.48 80.7,71.29 80.7,71.14 80.59,71.03 80.44,71.03 80.25,71.22 80.09,71.22 79.17,70.29 79.17,66.4 85.95,59.61 90.94,59.61 91.22,59.9 92.97,59.9 v6(93.11,59.76)
  BOTTOM w0.127: UV1.D20 93.04,60.33 93.04,59.82 v6(93.11,59.76)
FB_A_D5: length 37.3
  TOP w0.127: v2(87.35,76.2) 87.27,76.12 87.27,75.91 UV6.E2
  IN1 w0.094: v6(92.52,60.3) 91.04,60.3 90.79,60.05 90.59,60.05 90.42,60.22 90.01,60.22 89.84,60.05 89.51,60.05 89.34,60.22 89.05,60.22 88.88,60.05 88.6,60.05 88.4,60.25 88.1,60.25 87.91,60.05 87.68,60.05 87.51,60.22 87.32,60.22 87.15,60.05 86.94,60.05 86.77,60.22 86.53,60.22 86.36,60.05 86.11,60.05 80.31,65.85 80.31,65.98 80.66,66.33 80.66,66.46 80.45,66.67 80.33,66.67 79.97,66.31 79.85,66.31 79.59,66.57 79.59,66.69 79.68,66.78 79.83,66.78 79.92,66.87 79.92,67.16 79.83,67.25 79.68,67.25 79.59,67.34 79.59,67.63 79.68,67.72 79.89,67.72 79.98,67.81 79.98,68.1 79.89,68.19 79.68,68.19 79.57,68.3 79.57,69.44 79.74,69.6 79.86,69.6 80.04,69.43 80.16,69.43 80.37,69.64 80.37,69.76 80.19,69.94 80.19,70.07 82.22,72.1 82.35,72.1 82.55,71.9 82.67,71.9 82.88,72.11 82.88,72.24 82.74,72.38 82.74,72.66 83.09,73.01 83.48,73.01 83.68,73.21 84.56,73.21 84.8,73.44 85.12,73.44 85.4,73.17 85.69,73.17 86.11,73.59 86.11,73.78 86.59,74.26 86.72,74.26 87.12,74.65 87.12,74.81 86.66,75.27 86.66,75.39 86.87,75.6 87,75.6 87.47,75.13 87.59,75.13 87.76,75.29 87.76,75.48 87.35,75.88 v2(87.35,76.2)
  BOTTOM w0.127: v6(92.52,60.3) 92.42,60.2 92.42,59.85 UV1.D21
FB_A_D6: length 43.6
  TOP w0.127: v2(85.06,77.17) 85.2,77.03 85.61,77.03 86.27,76.37 86.27,76.24 87.78,74.73 UV6.F4
  IN1 w0.094: v6(94.83,59.21) 94.83,58.54 93.84,57.55 93.84,57.54 93.07,56.77 93.07,56.59 92.85,56.37 92.35,56.37 92.08,56.64 90.68,56.64 90.34,56.98 88.82,56.98 88.01,57.79 85.2,57.79 77.35,65.64 77.35,71.05 82.6,76.3 82.82,76.3 83.44,76.93 84.45,76.93 84.54,77.02 84.9,77.02 v2(85.06,77.17)
  BOTTOM w0.127: UV1.F20 v6(94.83,59.21)
FB_A_D7: length 37.9
  TOP w0.127: 86.65,75.29 86.09,75.29 84.85,76.53 v2(84.84,76.53)
  IN1 w0.094: v2(84.84,76.53) 84.73,76.53 84.66,76.47 84.47,76.47 83.9,75.91 82.77,75.91 77.74,70.88 77.74,65.81 85.36,58.19 88.17,58.19 88.75,57.61 89.18,57.61 89.41,57.84 89.74,57.84 90,57.57 90.31,57.57 90.65,57.91 90.89,57.91 91.35,57.46 91.35,57.42 91.73,57.04 92.14,57.04 92.53,57.43 v6(92.53,57.98)
  BOTTOM w0.127: v6(92.53,57.98) 93.06,58.51 UV1.E21
FB_A_D8: length 19.6
  TOP w0.127: UV6.A11 94.67,73.12 v6(94.67,73.59)
  IN3 w0.094: v6(94.67,73.59) 94.67,73.14 94.1,72.58 92.9,72.58 92.51,72.19 92.17,72.19 92.02,72.34 92.02,73.03 91.93,73.11 91.56,73.11 90.15,71.7 90.15,69.15 91.73,67.56 91.73,67.06 95.07,63.73 95.64,63.73 96.43,62.95 v5(96.43,62.59)
  BOTTOM w0.127: v5(96.43,62.59) 96.56,62.72 UV1.E15
FB_A_D9: length 14.3
  TOP w0.127: UV6.A13 v6(95.71,72.48)
  IN3 w0.094: v6(95.71,72.48) 96.13,72.05 96.32,72.05 98.96,69.41 98.96,63.63 98.49,63.15 98.11,63.15 97.92,62.96 97.65,62.96 97.45,63.17 v5(96.7,63.17)
  BOTTOM w0.127: v5(96.7,63.17) 96.58,63.29 UV1.D15
FB_A_D10: length 20.3
  TOP w0.127: v6(94.01,73.06) 94.07,73 94.07,72.84 94.05,72.81 94.02,72.73 94.01,72.64 94.01,72.62 94.01,72.48 94.01,72.46 UV6.B11
  IN3 w0.094: v6(94.01,73.06) 94,73.07 94,73.36 93.4,73.96 91.83,73.96 89.18,71.31 89.18,69.92 89.48,69.61 89.48,69.2 91.27,67.41 91.27,66.88 94.93,63.23 94.93,63.2 95.43,62.7 95.57,62.7 96.02,62.25 v5(97.01,62.25)
  BOTTOM w0.127: UV1.F15 v5(97.01,62.25)
FB_A_D11: length 11.3
  TOP w0.127: UV6.B13 95.4,71.33 95.44,71.37 v6(95.67,71.37)
  IN3 w0.094: v6(95.67,71.37) 95.69,71.37 97.34,69.72 97.98,69.72 98.1,69.6 98.1,69.1 97.98,68.99 97.3,68.99 97.11,68.8 97.11,68.38 97.93,67.56 97.93,65.74 98.34,65.33 v5(98.34,63.87)
  BOTTOM w0.127: UV1.F13 v5(98.34,63.87)
FB_A_D12: length 11.9
  TOP w0.127: UV6.E11 v6(92.31,71.29)
  IN3 w0.094: v5(96.62,65.63) 97.18,65.63 97.54,65.98 97.54,67.4 96.62,68.31 96.62,69.23 95.07,70.78 95.07,71.43 94.6,71.91 94.31,71.91 93.89,71.48 92.5,71.48 v6(92.31,71.29)
  BOTTOM w0.127: 96.62,65.04 v5(96.62,65.63)
FB_A_D13: length 9.1
  TOP w0.127: v6(93.44,69.05) 93.5,69.11 93.5,69.58 UV6.E13
  IN3 w0.094: v6(93.44,69.05) 93.44,69.83 93.96,70.34 94.37,70.34 95.97,68.74 95.97,68.33 97.11,67.19 97.11,66.7 96.64,66.22 v5(96.18,66.22)
  BOTTOM w0.127: v5(96.18,66.22) 96.05,66.1 UV1.B13
FB_A_D14: length 11.4
  TOP w0.127: UV6.F11 v6(92.32,70.2)
  IN3 w0.094: v5(97.75,63.91) 97.75,63.91 97.75,63.72 97.61,63.58 96.82,63.58 96.15,64.25 95.11,64.25 92.89,66.47 92.89,67.96 92.27,68.58 92.22,68.58 91.73,69.07 91.73,69.6 v6(92.32,70.2)
FB_A_D15: length 7.8
  TOP w0.127: 92.88,69.07 92.88,68.49 93.31,68.06 93.31,67.83 93.58,67.56 v6(94.42,67.56)
  IN3 w0.094: v6(94.42,67.56) 94.42,66.97 94.93,66.47 94.93,65.16 95.39,64.7 96.27,64.7 96.49,64.47 v5(96.57,64.47)
  BOTTOM w0.127: v5(96.57,64.47) UV1.D13
FB_A_D16: length 23.3
  TOP w0.127: UV6.U11 85.33,64.17 85.33,64.75 85.09,64.99 v2(84.95,64.99)
  IN1 w0.094: v2(84.95,64.99) 84.52,64.99 83.9,65.61 83.9,67.14 88.42,71.65 90.85,71.65 91.45,71.06 91.87,71.06 92.16,70.77 92.32,70.77 93.91,69.18 94.31,69.18 95.56,67.93 95.56,66.67 95.28,66.39 95.28,66.39 95.11,66.21 95.1,66.21 v6(94.5,65.61)
  BOTTOM w0.127: UV1.B15 94.79,64.49 94.79,65.32 v6(94.5,65.61)
FB_A_D17: length 20.6
  TOP w0.127: 86.65,62.84 v2(87.25,62.84)
  IN1 w0.094: v6(95.42,63.29) 95.42,63.84 93.5,65.76 93.5,66.42 92.54,67.37 92.17,67.37 89.95,69.59 89.48,69.59 89.04,70.04 88.49,70.04 85.71,67.26 85.71,66.09 86.23,65.57 86.23,64.83 87.25,63.8 v2(87.25,62.84)
  BOTTOM w0.127: UV1.C16 v6(95.42,63.29)
FB_A_D18: length 17.6
  TOP w0.127: v2(85.71,64.56) 86.07,64.56 86.09,64.54
  IN1 w0.094: v6(93.68,67.11) 93.01,67.77 93.01,67.99 92.47,68.53 92.29,68.53 91.73,69.09 91.73,69.43 91.01,70.15 90.1,70.15 89.76,70.49 88.38,70.49 84.9,67.01 84.9,66.34 85.71,65.53 v2(85.71,64.56)
  BOTTOM w0.127: UV1.A13 95.49,66.6 94.98,67.11 v6(93.68,67.11)
FB_A_D19: length 22.6
  TOP w0.127: UV6.T13 87.17,63.36 86.7,63.36 v2(86.65,63.41)
  IN1 w0.094: v6(94.38,66.42) 94.89,66.93 94.89,67.72 94.04,68.58 93.17,68.58 92.84,68.91 92.84,69.27 92.33,69.77 92.02,69.77 91.17,70.62 90.34,70.62 89.9,71.06 88.39,71.06 84.31,66.98 84.31,66.37 85.31,65.36 85.31,64.19 86.09,63.41 v2(86.65,63.41)
  BOTTOM w0.127: v6(94.38,66.42) 93.97,66.01 93.97,65.31 UV1.A15
FB_A_D20: length 9
  TOP w0.127: UV6.N11 87.88,66.34 87.88,66.75 v2(87.92,66.79)
  IN1 w0.094: v2(87.92,66.79) 88.35,66.79 88.73,66.41 89.14,66.41 89.36,66.64 89.62,66.64 90.35,65.9 91.44,65.9 91.82,65.53 91.82,65.11 91.54,64.84 91.54,64.61 91.73,64.42 92.03,64.42 92.35,64.1 v6(92.35,64.08)
  BOTTOM w0.127: UV1.B18 93.11,63.32 v6(92.35,64.08)
FB_A_D21: length 6.6
  TOP w0.127: UV6.N13 88.92,65.67 v2(88.91,65.68)
  IN1 w0.094: v2(88.91,65.68) 88.91,65.84 89.09,66.01 89.67,66.01 89.85,65.84 89.85,65.66 89.74,65.54 89.74,65.42 89.94,65.21 90.07,65.21 90.24,65.38 90.36,65.38 90.87,64.88 90.87,64.14 v6(91.69,63.31)
  BOTTOM w0.127: UV1.A18 91.78,63.23 v6(91.69,63.31)
FB_A_D22: length 7
  TOP w0.127: v2(88.35,66.33) UV6.M11
  IN1 w0.094: v2(88.35,66.33) 88.16,66.14 88.16,65.9 89.13,64.93 89.54,64.93 90.44,64.03 90.44,63.7 90.19,63.44 90.19,63.18 90.59,62.79 v6(91.24,62.79)
  BOTTOM w0.127: UV1.A19 91.93,62.71 91.31,62.71 v6(91.24,62.79)
FB_A_D23: length 6.8
  TOP w0.127: UV6.M13 89.48,65.08 89.88,64.68 89.88,64.23 v2(89.79,64.14)
  IN1 w0.094: v2(89.79,64.14) 89.79,63.02 90.42,62.39 91.48,62.39 v6(91.64,62.23)
  BOTTOM w0.127: v6(91.64,62.23) 91.64,62.23 91.79,62.09 92.01,62.09 92.4,61.7 92.8,61.7 92.97,61.53 UV1.C19
FB_A_D24: length 16.3
  TOP w0.127: v6(80.9,67.72) 80.96,67.65 81.28,67.65 UV6.U4
  IN3 w0.094: v5(89.24,59.3) 89.08,59.46 88.9,59.46 88.13,58.69 86.4,58.69 86.2,58.89 80.28,64.8 80.28,67.11 v6(80.9,67.72)
  BOTTOM w0.127: v5(89.24,59.3) 89.28,59.31 UV1.B24
FB_A_D25: length 19.3
  TOP w0.127: 80.43,69.07 v6(80.02,68.66)
  IN3 w0.094: v6(80.02,68.66) 79.86,68.49 79.86,64.66 86.31,58.21 88.56,58.21 89.26,58.91 89.55,58.91 90.09,59.45 90.58,59.45 v5(90.75,59.63)
  BOTTOM w0.127: v5(90.75,59.63) 90.76,59.63 90.76,59.18
FB_A_D26: length 13.8
  TOP w0.127: 82.13,68.5 82.19,68.43 82.19,68.25 82.12,68.17 82.12,67.88 81.42,67.19 v6(81.42,67)
  IN3 w0.094: v5(88.04,59.1) 88,59.14 86.52,59.14 86.48,59.18 81.81,63.85 81.81,66.61 v6(81.42,67)
  BOTTOM w0.127: v5(88.04,59.1) 88.08,59.14 UV1.A25
FB_A_D27: length 14.8
  TOP w0.127: v6(81,69.03) UV6.T2
  IN3 w0.094: v5(88.58,60) 88.43,59.84 86.39,59.84 82.22,64.01 82.22,67.14 81,68.37 v6(81,69.03)
  BOTTOM w0.127: UV1.A24 88.87,59.71 v5(88.58,60)
FB_A_D28: length 14.4
  TOP w0.127: v6(83.26,70.24) 83.79,70.24 UV6.N4
  IN3 w0.094: v5(90.04,61.79) 89.76,62.07 87.81,62.07 87.45,62.42 87.45,63.31 85.84,64.92 85.43,64.92 84.66,65.69 84.66,69.35 83.78,70.24 v6(83.26,70.24)
  BOTTOM w0.127: v5(90.04,61.79) 90.36,61.48 UV1.A21
FB_A_D29: length 17.3
  TOP w0.127: v6(83.27,71.32) 82.7,71.32 UV6.N2
  IN3 w0.094: v5(91.19,60.82) 91.08,60.72 90.33,60.72 89.53,61.52 86.97,61.52 86.73,61.76 86.73,62.83 86.14,63.41 85.83,63.41 85.52,63.72 85.52,64.05 84.19,65.38 84.19,68.33 84.12,68.39 84.12,68.41 83.23,69.3 83.23,69.68 82.79,70.12 82.79,70.84 v6(83.27,71.32)
  BOTTOM w0.127: UV1.B21 v5(91.19,60.82)
FB_A_D30: length 14.4
  TOP w0.127: v6(84.42,70.24) 84.42,70.73 UV6.M4
  IN3 w0.094: v5(91.24,61.43) 91.01,61.43 89.93,62.51 88.93,62.51 85.44,66 85.44,69.22 v6(84.42,70.24)
  BOTTOM w0.127: v5(91.24,61.43) 91.41,61.43 91.68,61.17 91.99,61.17 92.22,60.94 UV1.C20
FB_A_D31: length 17.4
  TOP w0.127: UV6.M2 83.22,71.93 83.22,72.5 v6(83.22,72.5)
  IN3 w0.094: v6(83.22,72.5) 83.22,72.5 83.22,71.94 84.01,71.15 84.01,71.12 84.25,70.89 84.28,70.89 84.45,70.71 85,70.71 86.32,69.39 86.32,66.79 86.67,66.45 86.67,66.27 87.38,65.55 87.38,65.51 87.84,65.04 87.84,64.23 89.17,62.91 90.26,62.91 91.33,61.83 91.4,61.83 91.48,61.75 91.5,61.75 91.8,61.45 91.8,60.91 v5(91.82,60.9)
  BOTTOM w0.127: UV1.C21 91.92,60.75 91.82,60.86 v5(91.82,60.9)
FB_A_D32: length 30.5
  TOP w0.127: UV8.U4 v2(84.07,49.26)
  IN1 w0.094: v6(98.34,53.27) 98.92,52.69 98.92,50.99 93.79,45.86 93.79,44.19 93.54,43.93 93.54,43.63 93,43.09 92.08,43.09 91.52,42.53 91.3,42.53 90.72,41.96 89.26,41.96 88.83,41.53 87.43,41.53 82.76,46.2 82.76,47.46 83.85,48.56 83.85,49.02 84.07,49.24 v2(84.07,49.26)
  BOTTOM w0.127: v6(98.34,53.27) 98.37,53.24 98.37,52.74 UV1.R22
FB_A_D33: length 24.3
  TOP w0.127: UV8.U2 v2(85.69,49.8)
  IN1 w0.094: v6(97.18,50.97) 97.18,50.96 97.18,50.38 92.86,46.05 92.86,45.59 91.97,44.7 91.21,44.7 89.56,43.06 87.04,43.06 83.83,46.27 83.83,46.67 84.35,47.2 84.35,48.33 84.25,48.43 84.25,48.85 85.2,49.8 v2(85.69,49.8)
  BOTTOM w0.127: UV1.R24 v6(97.18,50.97)
FB_A_D34: length 25.3
  TOP w0.127: UV8.T4 v2(84.04,48.1)
  IN1 w0.094: v6(98.35,52.09) 98.35,51.61 97.84,50.47 93.26,45.89 93.26,44.84 92.46,44.04 91.87,44.04 91.36,43.53 91.33,43.53 90.42,42.62 89.36,42.62 88.84,42.1 88.14,42.1 86.81,42.73 83.31,46.22 83.31,47.37 v2(84.04,48.1)
  BOTTOM w0.127: v6(98.35,52.09) 98.36,52.09 98.4,52.13 98.9,52.13 UV1.T22
FB_A_D35: length 22.4
  TOP w0.127: UV8.T2 v2(85.27,49.23)
  IN1 w0.094: v2(85.27,49.23) 85.3,49.21 85.3,48.74 84.77,48.21 84.77,46.82 87.06,44.53 87.99,44.53 88.87,43.65 89.58,43.65 91.09,45.15 91.22,45.15 92.18,46.11 92.35,46.11 96.61,50.38 96.61,51 97.72,52.11 v6(97.72,52.65)
  BOTTOM w0.127: v6(97.72,52.65) 97.75,52.63 UV1.R23
FB_A_D36: length 15
  TOP w0.127: UV8.N4 86.34,46.98 v2(86.89,47.54)
  IN1 w0.094: v6(94.82,52.14) 94.09,52.14 93.03,51.08 88.48,51.08 87.88,50.48 87.88,49.92 88.35,49.44 88.35,48.88 88.11,48.64 87.75,48.64 87.19,49.21 86.89,49.21 86.76,49.08 86.76,48.41 86.89,48.28 v2(86.89,47.54)
  BOTTOM w0.127: v6(94.82,52.14) 94.85,52.17 UV1.N25
FB_A_D37: length 13.1
  IN1 w0.094: v6(94.23,51.57) 93.18,50.52 91.85,50.52 91.79,50.59 91.37,50.59 91.25,50.47 90.68,50.47 90.58,50.57 90.35,50.57 90.2,50.42 90.2,50.29 90.36,50.13 90.36,50 90.18,49.82 90.05,49.82 89.47,50.4 89.34,50.4 89.13,50.19 89.13,50.07 89.69,49.51 89.69,49.34 89.53,49.17 89.4,49.17 89.05,49.52 88.92,49.52 88.75,49.35 88.75,49.22 89.1,48.87 89.1,48.75 88.39,48.03 88.23,48.03 88.01,48.25 87.73,48.25 87.67,48.18 87.67,47.63 87.57,47.54 v2(87.47,47.54)
  BOTTOM w0.127: v6(94.23,51.57) 94.26,51.6 UV1.N26
FB_A_D38: length 15.9
  TOP w0.127: UV8.M4 87.45,45.84 88.05,46.45 v2(88.1,46.45)
  IN1 w0.094: v6(96.59,52.72) 96.51,52.8 96.06,52.8 95.62,52.36 95.62,51.81 92.89,49.08 92.76,49.08 92.18,49.67 92.05,49.67 91.87,49.49 91.87,49.36 92.47,48.77 92.47,48.64 91.07,47.24 90.67,47.24 90.58,47.33 90.58,47.5 90.49,47.59 90.22,47.59 90.13,47.5 90.13,47.24 89.87,46.98 88.79,46.98 88.25,46.43 88.11,46.43 v2(88.1,46.45)
  BOTTOM w0.127: UV1.N23 96.56,52.74 v6(96.59,52.72)

# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_M1_D36: length 19.8
  IN3 w0.094: v5(141.67,68.24) 141.94,68.51 143.09,68.51 144.01,67.59 144.01,67.29 143.79,67.07 143.79,65.63 144.07,65.35 144.07,65.28 144.62,64.73 149.04,64.73 150.33,63.43 150.76,63.43 151.66,62.53 151.66,62.13 152.01,61.79 152.2,61.79 155.08,58.9 v5(155.08,58.31)
DDR_M1_D37: length 20.5
  IN3 w0.094: v5(155.08,57.66) 155.22,57.8 155.22,58.08 155.35,58.2 155.35,58.96 152.17,62.13 152.17,62.8 151.18,63.79 150.39,63.79 149.19,64.98 144.61,64.98 144.27,65.32 144.27,65.43 143.98,65.72 143.98,66.89 144.22,67.13 144.22,67.63 143.09,68.75 142.65,68.75 142.54,68.86 142.47,68.86 142.32,69 v5(142.32,69.04)
DDR_M1_D38: length 18.5
  IN3 w0.094: v5(153.78,57.66) 153.78,57.93 153.5,58.2 153.5,58.7 151.99,60.22 150.72,60.22 149.74,61.19 149.72,61.19 147.65,63.27 143.16,63.27 142.63,63.79 142.59,63.79 141.92,64.46 141.92,64.97 142.04,65.09 142.04,65.41 141.74,65.7 141.74,66.24 141.99,66.49 141.99,67.01 142.32,67.34 v5(142.32,67.44)
DDR_M1_D39: length 16.9
  IN3 w0.094: v5(153.78,58.31) 153.78,58.74 152.05,60.48 150.84,60.48 147.83,63.49 143.36,63.49 143.19,63.66 143.06,63.66 142.68,64.04 142.6,64.04 142.11,64.54 142.11,64.91 142.2,65 142.2,65.01 142.21,65.02 142.21,65.48 141.94,65.75 141.94,66.18 142.27,66.52 142.27,66.61 v5(142.29,66.64)
DDR_M1_D40: length 19.8
  IN3 w0.094: v5(139.72,67.44) 139.72,67.43 140.03,67.12 140.03,66.59 140.16,66.46 140.16,65.63 140.01,65.48 140.01,65.18 140.53,64.67 140.53,63.77 142.79,61.51 146.59,61.51 149.09,59.02 149.7,59.02 149.8,59.13 150.62,59.13 151.75,59.13 152.3,58.57 152.3,57.58 152.32,57.56 152.32,57.56 152.46,57.41 152.47,57.41 152.49,57.39 152.57,57.31 v5(152.57,57.01)
DDR_M1_D41: length 19.8
  IN3 w0.094: v5(152.57,56.36) 152.57,56.64 152.32,56.89 152.32,57.32 152.11,57.53 152.11,58.21 152.02,58.3 152.02,58.5 151.56,58.96 150.69,58.96 150.45,58.71 148.98,58.71 146.49,61.21 142.65,61.21 140.32,63.54 140.32,64.61 139.82,65.11 139.82,65.59 139.97,65.73 139.97,66.32 139.72,66.57 v5(139.72,66.64)
DDR_M1_D42: length 23.3
  IN3 w0.094: v5(139.72,69.04) 139.72,69.02 139.47,68.77 138.82,68.77 138.74,68.7 138.31,68.7 137.86,68.24 137.86,66.05 138.34,65.57 138.34,64.19 138.63,63.91 138.63,62.95 138.79,62.78 138.79,62.78 139.07,62.51 139.07,62.5 139.18,62.39 139.18,62.31 139.41,62.09 139.44,62.09 142.02,59.51 145.69,59.51 148.55,56.65 150.91,56.65 v5(151.27,57.01)
DDR_M1_D43: length 25
  IN3 w0.094: v5(140.37,69.04) 140.31,69.04 139.95,69.4 138.3,69.4 137.6,68.71 137.6,65.98 138.14,65.45 138.14,63.04 138.79,62.39 138.79,62.31 139.29,61.81 139.32,61.81 141.9,59.23 145.57,59.23 148.44,56.36 v5(151.27,56.36)
DDR_M1_D44: length 17.1
  IN3 w0.094: v5(140.37,66.64) 140.37,66.56 140.55,66.38 140.55,65.65 140.74,65.46 140.74,63.96 142.89,61.81 146.73,61.81 149.21,59.32 151.82,59.32 152.57,58.57 v5(152.57,58.31)
DDR_M1_D45: length 18.7
  IN3 w0.094: v5(140.37,67.44) 140.37,67.05 140.66,66.76 140.66,66.53 140.74,66.45 140.74,65.75 140.91,65.57 140.91,64.19 142.99,62.12 146.87,62.12 149.39,59.6 150.18,59.6 150.22,59.56 151.82,59.56 152.84,58.54 152.84,58.21 152.67,58.03 152.67,57.76 v5(152.57,57.66)
DDR_M1_D46: length 23.3
  IN3 w0.094: v5(151.27,57.66) 151.03,57.43 151.03,57.12 150.86,56.94 148.66,56.94 145.77,59.84 142.15,59.84 142.15,59.84 142.12,59.84 138.9,63.06 138.9,64.07 138.57,64.41 138.57,65.67 138.19,66.05 138.19,68.21 138.47,68.49 138.78,68.49 138.83,68.54 140.06,68.54 140.36,68.24 v5(140.37,68.24)
DDR_M1_D47: length 20.8
  IN3 w0.094: v5(139.72,68.24) 139.42,68.24 139.11,67.93 138.99,67.93 138.37,67.31 138.37,66.13 138.75,65.75 138.75,64.69 139.18,64.25 139.18,63.21 142.27,60.12 146.05,60.12 148.5,57.67 150.62,57.67 v5(151.27,58.31)
DDR_M1_D48: length 19.2
  IN1 w0.094: v6(155.56,54.94) 155.56,54.99 155.33,55.23 155.33,56.11 155.16,56.27 155.16,63.58 150.3,68.44 150.3,68.67 150.01,68.97 149.32,68.97 149.24,69.05 148.91,69.05 v6(148.5,68.64)
  BOTTOM w0.127: v6(148.5,68.64) 148.17,68.31 UD43.R9 ; UC1.BA32 155.18,55.32 v6(155.56,54.94)
DDR_M1_D49: length 18.4
  IN1 w0.094: v6(155.58,54.34) 155.16,54.77 155.16,55.82 154.88,56.1 154.88,63.44 150.18,68.14 149.69,68.14 149.21,68.62 v6(149.12,68.62)
  BOTTOM w0.127: v6(149.12,68.62) 148.82,68.33 UD43.T9 ; v6(155.58,54.34) 155.45,54.34 UC1.BA31
DDR_M1_D50: length 16.5
  IN1 w0.094: v6(149.12,67.04) 149.12,66.77 149.24,66.65 149.96,66.65 150.34,66.26 150.34,66.16 151.58,64.92 151.58,62.84 153.72,60.7 153.72,56.34 153.86,56.2 153.86,55.59 154.14,55.31 154.14,54.72 v6(153.76,54.34)
  BOTTOM w0.127: v6(149.12,67.04) 148.82,67.34 UD43.T10 ; UC1.BD31 153.44,54.67 v6(153.76,54.34)
DDR_M1_D51: length 16.2
  IN1 w0.094: v6(153.76,54.99) 153.58,55.17 153.58,56.05 153.44,56.19 153.44,60.58 151.28,62.74 151.28,64.73 150.77,65.24 150.64,65.24 150.14,64.74 150.01,64.74 149.89,64.86 149.89,64.99 150.39,65.49 150.39,65.62 150.28,65.72 149.63,65.72 v6(149.11,66.25)
  BOTTOM w0.127: UC1.BD32 153.44,55.32 v6(153.76,54.99) ; UD43.T11 148.82,66.54 v6(149.11,66.25)
DDR_M1_D52: length 20.2
  IN1 w0.094: v6(149.14,69.46) 149.45,69.15 150.08,69.15 155.45,63.79 155.45,56.42 155.52,56.34 155.52,55.54 155.94,55.13 155.94,54.05 v6(155.58,53.69)
  BOTTOM w0.127: UC1.BA30 155.26,54.02 v6(155.58,53.69) ; UD43.T8 148.82,69.14 v6(149.14,69.46)
DDR_M1_D53: length 22.6
  IN1 w0.094: v6(148.5,69.44) 148.51,69.44 148.93,69.86 150.23,69.86 150.51,69.59 150.51,69.14 155.73,63.91 155.73,56.61 155.75,56.6 155.75,56.05 155.7,56 155.7,55.65 156.15,55.2 156.15,53.61 v6(155.58,53.04)
  BOTTOM w0.127: v6(155.58,53.04) 155.26,53.37 UC1.BA29 ; v6(148.5,69.44) 148.17,69.11 UD43.R8
DDR_M1_D54: length 17.7
  IN1 w0.094: v6(148.5,67.04) 148.07,66.61 148.07,65.01 152.87,60.21 152.87,56.18 153.2,55.85 153.2,53.66 153.76,53.1 v6(153.76,53.04)
  BOTTOM w0.127: v6(148.5,67.04) 148.17,67.36 UD43.R10 ; v6(153.76,53.04) 153.43,53.37 UC1.BD29
DDR_M1_D55: length 17.7
  IN1 w0.094: v6(148.5,66.24) 148.85,65.89 148.85,64.63 149.56,63.92 149.68,63.92 149.95,64.19 150.08,64.19 150.2,64.07 150.2,63.94 149.93,63.67 149.93,63.55 150.06,63.42 150.18,63.42 150.45,63.69 150.58,63.69 150.7,63.57 150.7,63.45 150.42,63.18 150.42,63.06 153.15,60.33 153.15,56.17 153.4,55.92 153.4,54.05 v6(153.76,53.69)
  BOTTOM w0.127: UD43.R11 148.17,66.56 v6(148.5,66.24) ; v6(153.76,53.69) 153.44,54.02 UC1.BD30
DDR_M1_D56: length 17.8
  IN1 w0.094: v6(151.94,54.34) 151.94,54.17 151.82,54.06 151.57,54.06 151.47,54.15 151.47,55.72 150.78,56.41 150.78,59.33 146.64,63.47 145.57,64.54 145.56,64.54 145.56,65.74 145.69,65.87 145.69,66.55 145.81,66.66 146.05,66.66 146.42,67.04 v6(146.56,67.04)
  BOTTOM w0.127: UC1.BG31 151.61,54.67 v6(151.94,54.34) ; v6(146.56,67.04) 146.22,67.38 UD43.M10
DDR_M1_D57: length 17.8
  IN1 w0.094: v6(147.2,67.04) 147.2,66.95 146.89,66.64 146.44,66.64 146.08,66.28 146.08,65.72 145.9,65.54 145.9,64.61 146.25,64.26 146.36,64.26 146.56,64.45 146.68,64.45 146.81,64.33 146.81,64.2 146.62,64.01 146.62,63.89 146.75,63.76 146.87,63.76 147.06,63.95 147.19,63.95 147.31,63.82 147.31,63.7 147.12,63.5 147.12,63.45 151.09,59.48 151.09,56.41 151.94,55.56 v6(151.94,54.99)
  BOTTOM w0.127: UC1.BG32 151.61,55.32 v6(151.94,54.99) ; UD43.N10 146.87,67.36 v6(147.2,67.04)
DDR_M1_D58: length 20.5
  IN1 w0.094: v6(150.11,54.99) 150.11,55.42 149.28,56.26 149.28,57.62 143.38,63.52 143.38,65.4 143.21,65.57 143.21,67.42 144.04,68.25 144.93,68.25 145.61,68.92 146.26,68.92 v6(146.55,68.64)
  BOTTOM w0.127: UC1.BK32 149.79,55.32 v6(150.11,54.99) ; v6(146.55,68.64) 146.22,68.31 UD43.M9
DDR_M1_D59: length 21.9
  IN1 w0.094: v6(150.11,54.34) 150.47,54.7 150.47,55.5 149.64,56.33 149.64,57.73 143.71,63.66 143.71,65.47 143.47,65.71 143.47,67.09 144.36,67.98 145.3,67.98 145.54,68.23 147.43,68.23 v6(147.85,68.64)
  BOTTOM w0.127: v6(150.11,54.34) 149.79,54.67 UC1.BK31 ; v6(147.85,68.64) 147.52,68.31 UD43.P9
DDR_M1_D60: length 18.7
  IN1 w0.094: v6(151.94,53.04) 152.49,53.6 152.49,55.39 152.4,55.48 152.4,55.81 152.05,56.16 152.05,60 151.52,60.52 151.4,60.52 151.22,60.35 151.1,60.35 150.97,60.47 150.97,60.6 151.15,60.77 151.15,60.9 151.02,61.03 150.9,61.03 150.72,60.85 150.6,60.85 150.47,60.98 150.47,61.1 150.65,61.28 150.65,61.4 150.52,61.53 150.39,61.53 150.22,61.35 150.09,61.35 149.97,61.48 149.97,61.6 150.15,61.78 150.15,61.9 147.51,64.54 147.51,64.96 147.2,65.28 v6(147.2,66.24)
  BOTTOM w0.127: UC1.BG29 151.61,53.37 v6(151.94,53.04) ; UD43.N11 146.87,66.56 v6(147.2,66.24)
DDR_M1_D61: length 18.5
  IN1 w0.094: v6(146.6,66.23) 146.6,65.97 146.82,65.76 146.82,64.83 147.79,63.85 147.79,63.18 148.08,62.89 148.21,62.89 148.42,63.1 148.55,63.1 148.67,62.97 148.67,62.85 148.46,62.63 148.46,62.51 148.58,62.38 148.71,62.38 148.92,62.6 149.05,62.6 149.17,62.47 149.17,62.35 148.96,62.13 148.96,62.01 149.09,61.88 149.21,61.88 149.43,62.09 149.55,62.09 149.68,61.97 149.68,61.84 149.46,61.63 149.46,61.5 151.66,59.3 151.66,56.08 152.12,55.63 152.12,55.37 152.32,55.18 152.32,54.07 v6(151.94,53.69)
  BOTTOM w0.127: v6(151.94,53.69) 151.61,54.02 UC1.BG30 ; UD43.M11 146.6,66.26 v6(146.6,66.23)
DDR_M1_D62: length 23.1
  IN1 w0.094: v6(150.11,53.69) 149.76,54.05 149.76,55.38 148.94,56.19 148.94,57.52 143.05,63.41 143.05,65.37 142.46,65.96 142.46,67.67 143.89,69.1 146.19,69.1 v6(146.52,69.44)
  BOTTOM w0.127: UC1.BK30 149.79,54.02 v6(150.11,53.69) ; UD43.M8 146.22,69.14 v6(146.52,69.44)
DDR_M1_D63: length 26
  IN1 w0.094: v6(150.11,53.04) 150.11,53.1 149.55,53.66 149.55,55.12 148.6,56.07 148.6,57.32 142.1,63.82 142.1,67.7 144.22,69.81 146.75,69.81 146.88,69.68 146.88,68.95 147.2,68.64 v6(147.2,68.64)
  BOTTOM w0.127: UD43.N9 146.87,68.31 v6(147.2,68.64) ; v6(150.11,53.04) 149.79,53.37 UC1.BK29
DDR_M1_DQS0: length 14.5
  IN3 w0.076: 159.16,58.42 159.16,58.41 159.16,58.4 159.16,58.39 159.16,58.31 159.06,58.21 159.06,57.53 159.04,57.52 159.04,57.16 159.06,57.15 159.06,57.01 159.23,56.83 159.42,56.83 159.47,56.78 v5(159.47,56.69) ; 157.38,65.08 157.38,65.09 157.4,65.1 157.4,65.15 157.41,65.16 157.41,66.09 157.72,66.41 157.72,66.45 157.7,66.46 157.7,66.81 157.8,66.92 157.8,67.09 157.98,67.27 158.14,67.27 158.19,67.33 158.19,67.43 v5(158.19,67.44)
  IN3 w0.109: 157.38,65.08 157.38,64.89 157.82,64.45 158.17,64.45 158.92,63.69 158.92,63.12 159.14,62.9 159.33,62.9 159.44,62.79 159.44,62.49 159.33,62.39 159.14,62.39 158.92,62.17 158.92,60.92 159.12,60.72 159.42,60.72 159.61,60.53 159.61,60.28 159.51,60.18 159.31,60.18 159.09,59.96 159.09,59.59 159.31,59.37 159.51,59.37 159.61,59.27 159.61,59.06 159.51,58.96 159.31,58.96 159.09,58.74 159.09,58.48 159.16,58.42
DDR_M1_DQS1: length 16.1
  IN3 w0.076: v5(156.24,67.44) 156.17,67.44 156.1,67.36 156.1,66.98 156.17,66.9 156.27,66.9 156.51,67.15 156.51,67.6 156.39,67.72 154.89,67.72 154.87,67.74 154.69,67.55 154.69,67.02 154.38,66.71 154.38,66.7 154.34,66.66 154.34,66.64 154.33,66.63 ; 156.73,58.89 156.73,58.88 156.71,58.86 156.71,58.81 156.71,58.8 156.71,58.49 156.71,58.49 156.71,58.14 156.71,58.14 156.71,57.84 156.71,57.84 156.71,57.49 156.65,57.43 156.65,57.28 156.71,57.22 156.71,57.19 156.71,57.19 156.71,57.07 156.78,57 157,57 157.04,57.03 157.04,57.25 v5(156.95,57.34)
  IN3 w0.109: 154.33,66.63 154.16,66.46 154.16,64.67 154.43,64.4 154.43,64.36 154.44,64.35 154.44,63.2 155.59,62.05 155.59,60.7 156.73,59.56 156.73,58.89
DDR_M1_DQS2: length 18.7
  IN1 w0.109: v6(161.96,54.34) 162.34,54.73 162.34,55.38 162.55,55.58 162.55,57.16 162.61,57.23 162.61,61.55 165.67,64.61 165.67,67.24 165.22,67.69 164.91,67.69 164.54,68.06 163.92,68.06 163.53,67.67 163.24,67.67 v6(163.07,67.84)
  BOTTOM w0.127: v6(163.07,67.84) 162.74,67.51 UD44.P10 ; UC1.AL30 161.64,54.02 v6(161.96,54.34)
DDR_M1_DQS3: length 17.9
  IN1 w0.109: v6(158.32,54.34) 157.95,54.71 157.95,55.16 158.67,55.88 158.67,64.18 158.9,64.41 159.17,64.41 159.47,64.71 159.47,65.01 159.33,65.15 159.33,65.88 159.25,65.97 158.97,65.97 158.75,66.18 158.75,67.08 159.32,67.66 160.96,67.66 v6(161.12,67.82)
  BOTTOM w0.127: v6(161.12,67.82) 160.79,67.49 UD44.L10 ; v6(158.32,54.34) 158.19,54.34 UC1.AU30
DDR_M1_DQS4: length 21
  IN3 w0.076: v5(142.97,67.44) 142.84,67.31 142.61,67.31 142.42,67.11 142.42,66.88 142.54,66.75 142.54,66.4 142.48,66.33 ; v5(154.43,56.69) 154.43,56.77 154.39,56.81 154.18,56.81 154.02,56.97 154.02,57.11 154.01,57.13 154.01,57.53 154.08,57.61 154.08,57.73 154.01,57.8 154.01,58.2 154.02,58.21 154.02,58.41 154.01,58.43 154.01,58.85 152.04,60.82 151.44,60.82 151.43,60.81 151.42,60.81
  IN3 w0.109: 142.48,66.33 142.34,66.33 142.18,66.17 142.18,65.81 142.35,65.64 142.96,65.64 143.04,65.56 143.04,64.99 142.76,64.7 142.76,64.24 143.02,63.97 143.17,63.97 143.34,63.81 148.15,63.81 149.75,62.21 150.17,62.21 150.4,61.97 150.4,61.42 151.01,60.81 151.42,60.81
DDR_M1_DQS5: length 24.7
  IN3 w0.076: v5(141.01,67.44) 140.89,67.32 140.89,67.13 141.03,66.99 141.17,66.99 141.28,67.1 141.28,67.56 141.07,67.77 139.67,67.77 139.44,67.54 139.44,66.07 139.08,65.71 139.08,65.27 139.65,64.69 139.69,64.69 139.7,64.67 ; v5(151.92,57.34) 152.03,57.34 152.11,57.26 152.11,57.01 152.03,56.94 151.73,56.94 151.66,57.01 151.66,57.23 151.61,57.28 151.61,57.4 151.66,57.45 151.66,58.52 151.45,58.74 150.98,58.74 150.67,58.43 150.63,58.43 150.62,58.41
  IN3 w0.109: 150.62,58.41 150.48,58.28 148.83,58.28 146.32,60.79 142.49,60.79 139.97,63.31 139.97,64.41 139.7,64.67
DDR_M1_DQS6: length 22.4
  IN1 w0.109: v6(154.65,54.37) 154.98,54.7 154.98,55.67 154.47,56.17 154.47,63.27 153.85,63.9 153.51,63.9 152.61,63 152.47,63 152.25,63.22 152.25,63.36 153.13,64.24 153.13,64.55 150.05,67.63 149.54,67.63 149.48,67.69 149.48,67.99 149.26,68.21 148.73,68.21 148.53,68.01 148.53,67.77 148.42,67.66 148.03,67.66 v6(147.85,67.84)
  BOTTOM w0.127: UC1.BC30 154.29,54.02 v6(154.65,54.37)
  BOTTOM w0.132: v6(147.85,67.84) 147.85,67.76 UD43.P10
DDR_M1_DQS7: length 24.9
  IN1 w0.109: v6(145.9,67.84) 145.71,67.65 144.36,67.65 143.88,67.17 143.88,65.85 144,65.73 144,65.25 144.68,64.57 144.68,64.43 144.35,64.1 144.35,63.79 144.69,63.45 145,63.45 145.33,63.78 145.47,63.78 145.69,63.56 145.69,63.42 145.36,63.09 145.36,62.78 145.69,62.44 146.01,62.44 146.33,62.77 146.48,62.77 146.69,62.55 146.69,62.41 146.36,62.08 146.36,61.77 146.7,61.44 147.01,61.44 147.34,61.76 147.48,61.76 147.7,61.55 147.7,61.4 147.37,61.08 147.37,60.76 147.71,60.43 148.02,60.43 148.35,60.76 148.49,60.76 148.71,60.54 148.71,60.4 148.38,60.07 148.38,59.76 148.71,59.42 149.83,59.42 150.07,59.18 150.07,56.37 150.65,55.79 150.65,54.72 151.03,54.34 v6(151.03,54.34)
  BOTTOM w0.127: v6(151.03,54.34) 151.03,54.34 150.7,54.02 UC1.BH30
  BOTTOM w0.132: v6(145.9,67.84) 145.9,67.76 UD43.L10
DDR_M1_DQS#0: length 14.4
  IN3 w0.076: 157.59,65.08 157.59,65.18 157.58,65.19 157.58,66.02 157.89,66.34 157.89,66.52 157.87,66.53 157.87,66.74 157.97,66.85 157.97,67.02 158.05,67.09 158.1,67.09 158.16,67.04 158.16,66.67 v5(158.13,66.64) ; 159.3,58.56 159.31,58.55 159.31,58.53 159.34,58.49 159.34,58.34 159.33,58.32 159.33,58.24 159.23,58.14 159.23,57.46 159.21,57.45 159.21,57.23 159.23,57.22 159.23,57.08 159.3,57 159.42,57 159.47,57.05 v5(159.47,57.34)
  IN3 w0.109: 157.59,65.08 157.59,64.97 157.91,64.65 158.25,64.65 159.12,63.78 159.12,63.2 159.22,63.1 159.42,63.1 159.64,62.88 159.64,62.41 159.42,62.18 159.22,62.18 159.12,62.08 159.12,61 159.2,60.92 159.51,60.92 159.82,60.62 159.82,60.2 159.6,59.98 159.4,59.98 159.3,59.88 159.3,59.67 159.4,59.57 159.6,59.57 159.82,59.35 159.82,58.98 159.6,58.76 159.4,58.76 159.3,58.66 159.3,58.57 159.3,58.56
DDR_M1_DQS#1: length 16.2
  IN3 w0.076: 156.53,58.89 156.53,58.8 156.54,58.8 156.54,58.42 156.54,58.41 156.54,58.21 156.54,58.21 156.54,57.77 156.54,57.76 156.54,57.56 156.48,57.5 156.48,57.21 156.54,57.15 156.54,57.12 156.54,57.11 156.54,57 156.71,56.83 156.91,56.83 156.95,56.79 v5(156.95,56.69) ; 154.19,66.78 154.25,66.84 154.26,66.84 154.52,67.09 154.52,67.62 154.8,67.91 154.94,67.91 154.96,67.89 156.46,67.89 156.68,67.67 156.68,67.08 v5(156.24,66.64)
  IN3 w0.109: 154.19,66.78 153.96,66.54 153.96,64.58 154.23,64.31 154.23,64.27 154.23,64.27 154.23,63.12 155.38,61.97 155.38,60.62 156.53,59.48 156.53,58.89
DDR_M1_DQS#2: length 18.7
  IN1 w0.109: v6(163.07,67.04) 162.88,67.04 162.78,67.14 162.78,67.38 162.86,67.46 163.61,67.46 164,67.86 164.46,67.86 164.83,67.48 165.14,67.48 165.47,67.15 165.47,64.7 162.41,61.64 162.41,57.31 162.34,57.25 162.34,55.66 162.14,55.46 162.14,55.17 v6(161.96,54.99)
  BOTTOM w0.127: UC1.AL31 161.51,54.86 161.64,54.99 v6(161.96,54.99) ; UD44.P11 162.74,66.85 162.93,67.04 v6(163.07,67.04)
DDR_M1_DQS#3: length 17.9
  IN1 w0.109: v6(158.32,54.99) 158.32,55.24 158.87,55.79 158.87,64.1 158.98,64.21 159.25,64.21 159.67,64.63 159.67,65.1 159.53,65.24 159.53,65.97 159.33,66.17 159.05,66.17 158.95,66.27 158.95,67 159.4,67.45 161.32,67.45 161.41,67.36 161.41,67.1 161.35,67.04 v6(161.12,67.04)
  BOTTOM w0.127: v6(158.32,54.99) 158,54.99 157.86,54.85 UC1.AU31 ; v6(161.12,67.04) 160.89,67.04 160.72,66.87 160.72,66.71 UD44.L11
DDR_M1_DQS#4: length 21
  IN3 w0.076: v5(142.97,66.64) 142.95,66.67 142.95,67.04 142.85,67.14 142.68,67.14 142.59,67.04 142.59,66.95 142.71,66.82 142.71,66.33 142.66,66.28 142.66,66.26 142.55,66.15 142.5,66.15 142.49,66.13 142.48,66.13 ; 151.42,61.01 151.43,61.01 151.45,61 151.5,61 151.51,60.99 152.11,60.99 154.18,58.92 154.18,58.5 154.19,58.49 154.19,58.14 154.18,58.13 154.18,57.88 154.25,57.8 154.25,57.54 154.18,57.46 154.18,57.2 154.19,57.19 154.19,57.04 154.25,56.98 154.39,56.98 154.43,57.02 v5(154.43,57.34)
  IN3 w0.109: 142.48,66.13 142.43,66.13 142.38,66.09 142.38,65.89 142.44,65.84 143.05,65.84 143.24,65.65 143.24,64.9 142.96,64.62 142.96,64.32 143.1,64.18 143.26,64.18 143.42,64.01 148.23,64.01 149.84,62.41 150.26,62.41 150.61,62.06 150.61,61.51 151.1,61.01 151.42,61.01
DDR_M1_DQS#5: length 24.8
  IN3 w0.076: 150.76,58.27 150.77,58.28 150.77,58.32 151.04,58.58 151.39,58.58 151.51,58.46 151.51,57.51 151.46,57.46 151.46,57.22 151.51,57.17 151.51,56.94 151.67,56.78 151.82,56.78 v5(151.92,56.69) ; 139.56,64.53 139.55,64.54 139.55,64.58 138.93,65.2 138.93,65.77 139.29,66.14 139.29,67.61 139.6,67.92 141.13,67.92 141.43,67.62 141.43,67.04 141.23,66.83 141.06,66.83 141.01,66.79 v5(141.01,66.64)
  IN3 w0.109: 150.76,58.27 150.57,58.08 148.75,58.08 146.24,60.59 142.4,60.59 139.76,63.23 139.76,64.33 139.56,64.53
DDR_M1_DQS#6: length 22.4
  IN1 w0.109: v6(147.85,67.04) 147.62,67.04 147.56,67.1 147.56,67.36 147.65,67.45 148.5,67.45 148.73,67.68 148.73,67.93 148.82,68.01 149.18,68.01 149.28,67.91 149.28,67.61 149.46,67.43 149.96,67.43 152.93,64.46 152.93,64.32 152.05,63.44 152.05,63.13 152.39,62.8 152.7,62.8 153.59,63.69 153.76,63.69 154.27,63.19 154.27,56.09 154.77,55.58 154.77,55.15 v6(154.61,54.98)
  BOTTOM w0.127: v6(154.61,54.98) 154.34,54.98 154.22,54.86 UC1.BC31
  BOTTOM w0.132: v6(147.85,67.04) 147.85,66.74 147.74,66.64 UD43.P11
DDR_M1_DQS#7: length 24.9
  IN1 w0.109: v6(145.9,67.04) 146.11,67.04 146.2,67.13 146.2,67.36 146.11,67.45 144.44,67.45 144.08,67.08 144.08,65.94 144.2,65.82 144.2,65.33 144.88,64.65 144.88,64.34 144.55,64.01 144.55,63.87 144.77,63.65 144.91,63.65 145.24,63.98 145.55,63.98 145.89,63.65 145.89,63.33 145.56,63.01 145.56,62.86 145.78,62.65 145.92,62.65 146.25,62.97 146.56,62.97 146.9,62.64 146.9,62.33 146.57,62 146.57,61.86 146.78,61.64 146.93,61.64 147.26,61.97 147.57,61.97 147.9,61.63 147.9,61.32 147.57,60.99 147.57,60.85 147.79,60.63 147.93,60.63 148.26,60.96 148.58,60.96 148.91,60.62 148.91,60.31 148.58,59.98 148.58,59.84 148.8,59.62 149.91,59.62 150.27,59.26 150.27,56.46 150.86,55.88 150.86,55.16 151.03,54.99 v6(151.03,54.99)
  BOTTOM w0.127: v6(151.03,54.99) 151.03,54.99 150.7,54.67 UC1.BH31
  BOTTOM w0.132: v6(145.9,67.04) 145.9,66.68 145.78,66.56 145.65,66.56 UD43.L11
DDR_M1_ODT0: length 92.7
  IN1 w0.094: v6(159.25,69.5) 158.92,69.82 158.92,70.46 158.73,70.65 156.42,70.65 156.37,70.6 155.54,70.6 155.48,70.65 153.59,70.65 153.43,70.81 153.43,71.32 152.87,71.88 152.87,73.56 150.15,76.29 149.54,76.29 148.75,75.5 148.75,75.28 149.01,75.01 149.14,75.01 149.9,75.78 150.02,75.78 150.21,75.59 150.21,75.46 149.45,74.7 149.45,74.57 149.64,74.39 149.77,74.39 150.53,75.15 150.65,75.15 150.84,74.96 150.84,74.83 150.08,74.07 150.08,73.95 150.27,73.76 150.39,73.76 151.16,74.52 151.28,74.52 151.47,74.33 151.47,74.2 150.78,73.51 150.78,73.34 150.89,73.23 151.83,73.23 152.36,72.7 152.36,70.42 152.43,70.36 152.83,70.36 152.92,70.45 v6(152.92,70.93)
  IN3 w0.094: v5(161.33,57.66) 161.02,57.35 161.02,56.52 161.35,56.19 161.35,55.61 161.18,55.44 160.95,55.44 160.53,55.87 160.53,55.92 160.45,56 160.45,56.27 160.52,56.34 160.52,56.82 160.54,56.84 160.54,57.19 160.49,57.24 160.49,57.41 161.02,57.94 161.02,58.59 161.26,58.83 161.26,62.83 162.95,64.53 162.95,64.82 162.7,65.07 162.05,65.07 161.9,64.93 161.46,64.93 160.97,65.42 160.97,66.32 160.76,66.54 160.76,67.48 160.23,68.01 160.23,68.58 160.27,68.62 160.27,69.06 159.4,69.93 158.85,69.93 158.78,69.86 157.72,69.86 157.68,69.81 155.99,69.81 155.99,69.81 155.7,69.81 155.69,69.81 153.78,69.81 153.5,70.09 153.5,70.82 153.39,70.93 v6(152.92,70.93) 152.65,70.93 152.44,70.73 152.44,69.21 151.79,68.56 151.79,64.96 151.57,64.74 151.07,64.74 150.85,64.95 150.55,64.95 150.41,65.09 150.41,65.72 150.5,65.81 151.39,65.81 151.48,65.9 151.48,66.17 151.39,66.26 150.5,66.26 150.41,66.35 150.41,66.61 150.5,66.7 151.39,66.7 151.48,66.79 151.48,67.06 151.39,67.15 150.5,67.15 150.41,67.24 150.41,67.5 150.5,67.59 151.39,67.59 151.48,67.68 151.48,67.95 151.39,68.04 150.5,68.04 150.41,68.12 150.41,68.39 150.5,68.48 151.39,68.48 151.48,68.57 151.48,68.84 151.39,68.92 150.5,68.92 150.32,69.1 150.32,69.59 150.03,69.87 145.82,69.87 145.77,69.83 144.79,69.83 144.56,69.6 144.56,69.33 145.09,68.8 145.09,67.82 145,67.73 144.57,67.73 143.61,68.7 143.61,68.91 143.73,69.04 v5(144.27,69.04)
  BOTTOM w0.127: UD44.J8 159.49,69.25 v6(159.25,69.5) ; RD89.1 152.51,72.47 152.92,72.06 v6(152.92,70.93)
DDR_VTT_CNTL: length 11.7
  BOTTOM w0.081: RC523.1 UC2.2 v1(182.36,53.68) 182.36,54.04 180.85,55.55 178.52,55.55 178.49,55.51 177.88,55.51 177.56,55.83 177.56,56.61 UC1.C35
DEBUG_TX: length 3.2
  TOP w0.081: v1(37.68,7.46) 36.96,6.74 RE524.1 RE525.2 36.15,6.21 36.35,6.01 JDEG1.9
DG_GPIO8: length 2.8
  TOP w0.081: v2(27.82,52.07) 27.84,52.05 RT553.1 RT503.1
  IN1 w0.064: v2(27.82,52.07) 27.92,52.07 28.34,52.49 28.34,52.98 v4(28.34,52.99)
  IN3 w0.064: v5(28.66,52.89) 28.56,52.99 v4(28.34,52.99)
  BOTTOM w0.081: UT1.W6 28.79,52.89 v5(28.66,52.89)
DG_PA_USB2_MXCTL: length 3.7
  BOTTOM w0.081: UT1.R2 30.94,54.84 31.1,54.68 32.11,54.68 32.78,54.02 33.81,54.02 34.01,54.22 RT508.1
DG_PB_USB2_MXCTL: length 1.8
  BOTTOM w0.081: RT509.1 32.68,54.62 32.5,54.62 32.2,54.92 UT1.R1
DGPU_HOLD_RST#: length 42.1
  IN1 w0.064: v4(133.13,50.12) 132.51,50.12 132.51,50.12 127.12,50.12 126.83,50.41 126.83,50.41 126.79,50.45 126.5,50.45 124.07,52.88 122.72,52.88 121.15,54.45 121.12,54.45 119.76,55.81 119.76,59.85 119.49,60.12 119.49,60.12 119.16,60.45 119.16,60.83 119.16,60.83 119.16,61.15 119.16,61.7 119.42,61.96 119.42,63.15 119.6,63.33 119.6,66.76 119.6,66.77 119.6,67.77 119.6,67.78 119.6,68.94 119.53,69 119.53,69.34 118.77,70.1 118.09,70.1 117.61,70.58 117.61,71.44 v6(117.23,71.82)
  IN3 w0.089: v5(133.47,49.99) 133.34,50.12 v4(133.13,50.12)
  BOTTOM w0.081: RC107.1 v5(133.47,49.99) 133.47,49.66 134.25,48.87 UC1.CR22 ; v6(117.23,71.82) 116.32,70.91 v1(114.96,70.91) 114.96,71.23 115.2,71.46 115.79,71.46 116.03,71.71 116.03,72.24 115.85,72.42 UV12.2
DGPU_MAIN_EN: length 59.3
  TOP w0.081: v2(115.28,43.27) 115.15,43.4 115.15,43.62 RV103.1 116.14,43.17 116.7,43.17 DV5.1 117.04,43.52 DV4.2 117.42,45.66 117.45,45.66 117.67,45.89 RV105.1 117.64,45.93 117.64,46.01 RV90.1 116.71,46.93 DV11.2 117.47,48.44 118.54,48.44 118.81,48.71 118.81,49.05 118.33,49.52 UV2.3
  IN1 w0.064: v2(115.28,43.27) 112.21,43.27 112.19,43.29 112.19,43.29 111.1,44.38 111.1,45.89 111.1,45.89 111.1,45.93 111.72,46.55 111.72,47.16 111.7,47.19 111.7,51.39 111.34,51.74 111.34,55.16 111.29,55.21 111.29,56.38 112.15,57.24 112.74,57.24 v4(112.93,57.43) 113.12,57.24 114.35,57.24 116.73,54.87 v2(116.73,54.72)
  IN3 w0.064: v5(101.25,65.63) 101.36,65.75 102.39,65.75 103.66,67.02 106.52,67.02 106.96,67.46 110.9,67.46 114.5,63.86 114.5,60.73 114.67,60.56 114.67,59.04 114.5,58.87 114.5,58.82 113.11,57.43 v4(112.93,57.43)
  BOTTOM w0.081: UV1.F9 v5(101.25,65.63)
DGPU_MAIN_EN#: length 0.9
  TOP w0.081: RV5002.2 119.35,55.45 v1(119.35,56.17)
DGPU_PSI: length 89.2
  IN1 w0.064: v2(35.55,65.42) 35.55,65.01 37.32,63.24 v4(37.39,63.24)
  IN3 w0.064: v6(100.09,74.06) 99.59,74.55 99.59,75.72 97.88,77.43 97.88,77.94 97.31,78.51 81.88,78.51 81.37,78.01 81.37,74.83 76.66,70.12 76.66,67.76 75.89,66.99 75.29,66.99 74.47,66.17 74.06,66.17 72.66,64.76 72.66,64.5 72.65,64.5 72.65,63.51 71.31,62.16 71.31,60.53 69.68,58.9 68.44,58.9 68.4,58.87 56.67,58.87 55.44,60.1 53.37,60.1 52.86,59.59 52.86,59.08 52.4,58.63 49.52,58.63 49,58.11 45.59,58.11 44.83,58.87 44,58.87 43.49,59.37 43.15,59.37 41.75,60.77 41.31,60.77 38.84,63.24 v4(37.39,63.24)
  BOTTOM w0.081: RV91.1 100.09,74.76 v6(100.09,74.06) 100.55,73.6 100.55,71.66 UV1.A4
DGPU_PWR_EN: length 36.3
  TOP w0.081: v2(136.47,49.87) 136.49,49.89 RC114.2 ; v1(121.13,42.75) 121.49,43.1 UV25.2 121.49,44.74 121.66,44.91 121.66,45.83 v2(121.67,45.84)
  IN1 w0.064: v4(119.34,48.28) 119.34,48.18 121.67,45.85 v2(121.67,45.84) ; v4(114.03,44.3) 113.95,44.22 113.02,44.22 v2(112.91,44.33) ; v2(136.47,49.87) 136.22,50.13 v4(136.22,50.18)
  IN3 w0.064: v5(136.58,50.09) 136.49,50.18 v4(136.22,50.18) 135.77,50.18 135.26,49.67 134.59,49.67 133.93,49.67 133.7,49.44 132.71,49.44 132.11,48.84 127.2,48.84 126.95,48.59 123.75,48.59 123.07,49.27 119.12,49.27 118.97,49.12 118.97,48.43 119.12,48.28 v4(119.34,48.28) 119.01,47.95 117.59,47.95 117.21,47.58 116.78,47.58 115.74,46.53 114.72,46.53 114.06,45.88 114.06,44.33 v4(114.03,44.3)
DGPU_PWR_EN_R: length 7.3
  TOP w0.081: v2(121.45,46.66) 121.71,46.92 121.96,46.92 122.44,47.41 122.44,47.72 122.15,48.01 121.81,48.01 QV151.2 121.73,48.1 121.2,48.64 121.2,48.86 120.79,49.27 119.67,49.27 119.13,49.8 UV2.5
  IN1 w0.064: v2(121.45,46.66) 121.58,46.52 121.58,46.47 122.14,45.92 v2(122.14,45.85)
DGPU_PWROK: length 109.2
  TOP w0.081: RC68.2 138.49,51.81 138.48,51.79 v2(138.48,51.49) ; UV11.4 118.83,39.67 v2(118.83,39.48) ; UE1.A24 51.74,24.68 52.01,24.95 52.01,25 52.29,25.28 v2(52.29,25.44) ; v6(120.8,37.56) v3(120.8,36.71)
  IN1 w0.064: v2(52.29,25.44) 52.29,25.46 52.37,25.54 52.97,25.54 53.42,25.99 54.64,25.99 55.42,26.76 56.05,26.76 59.67,30.38 75.81,30.38 v4(76.04,30.15) ; v2(118.83,39.48) 118.83,39.15 120.42,37.56 v6(120.8,37.56) 121.05,37.56 v4(121.28,37.32) ; v4(138.07,51.49) v2(138.48,51.49)
  IN2 w0.066: v4(76.04,30.15) 76.28,29.91 80.84,29.91 81.06,30.13 100.07,30.13 100.25,29.95 109.36,29.95 109.8,29.5 113.56,29.5 121.28,37.23 v4(121.28,37.32) 121.28,38.36 123.66,40.73 123.66,43.55 127.69,47.58 129.65,47.58 133.34,51.26 134.28,51.26 135.42,52.41 135.96,52.41 135.96,52.41 136.26,52.41 136.27,52.41 136.33,52.41 136.59,52.15 136.59,51.99 137.09,51.49 v4(138.07,51.49)
  IN3 w0.064: v5(137.56,51.22) 137.83,51.49 v4(138.07,51.49)
  BOTTOM w0.081: v5(137.56,51.22) 137.75,50.96 UC1.CJ25
DGPU_VID: length 87.3
  TOP w0.081: PRV46.1 39.36,59.15 39.63,58.88 42.62,58.88 42.93,58.57 v2(43.01,58.57) 43.97,58.57 v1(44.54,58)
  IN1 w0.064: v2(43.01,58.57) 43.14,58.7 v4(43.14,59.01)
  IN3 w0.064: v4(43.14,59.01) 43.59,59.01 43.92,58.68 44.75,58.68 45.53,57.9 49.12,57.9 49.63,58.41 52.56,58.41 53.11,58.96 53.11,59.46 53.49,59.84 55.42,59.84 56.59,58.68 68.64,58.68 68.68,58.71 69.76,58.71 71.5,60.45 71.5,62.09 72.84,63.43 72.84,64.42 72.85,64.42 72.85,64.68 74.14,65.98 74.55,65.98 75.37,66.8 75.97,66.8 76.85,67.68 76.85,69.77 81.61,74.53 81.61,77.74 82.18,78.31 97.2,78.31 97.63,77.88 97.63,77.24 99.4,75.47 99.4,73.25 101.28,71.36 v5(101.28,69.11)
  BOTTOM w0.081: UV1.C6 v5(101.28,69.11)
DISP_ON: length 95.7
  TOP w0.081: D463.1 36.27,67.53 v2(36.31,67.49) ; v2(40.53,57.44) v1(40.53,58.06) ; v2(48.37,32.93) 48.73,32.93 49.17,33.37 R76.1
  IN1 w0.064: v2(48.37,32.93) 48.37,32.13 48.23,31.99 48.23,31.93 47.46,31.16 v4(47.23,31.16) ; v4(15.46,69.65) 15.06,69.26 v2(15.06,68.81) ; v4(40.06,33.78) 40.18,33.91 40.18,34.11 42.16,36.08 42.16,37.42 40.73,38.85 40.73,44.19 38.8,46.12 38.8,49.43 38.96,49.6 38.96,50.45 39.33,50.83 39.33,52.58 39.74,52.98 39.74,55.55 40.53,56.35 v2(40.53,57.44) 40.41,57.56 40.41,58.79 39.87,59.33 39.87,61.3 38.67,62.5 38.67,63.55 37.7,64.51 37.55,64.51 36.62,65.45 36.62,67.18 v2(36.31,67.49) 37.12,68.3 38.05,68.3 38.21,68.46 38.21,69.81 37.94,70.09 36.04,70.09 35.44,70.7 34.74,70.7 33.93,71.5 33.93,72.32 v4(33.85,72.4)
  IN2 w0.066: v4(31.93,75.47) 31.73,75.47 30.91,74.64 30.91,74.19 30.09,73.37 29.29,73.37 28.7,72.78 24.6,72.78 23.17,74.21 21.57,74.21 20.47,73.11 20.47,70.55 20.72,70.31 20.72,69.3 20.28,68.86 19.14,68.86 18.74,69.26 15.86,69.26 15.47,69.65 v4(15.46,69.65)
  IN3 w0.064: v4(47.23,31.16) 47.32,31.24 47.32,32.7 46.36,33.66 44,33.66 43.79,33.45 40.99,33.45 40.94,33.4 40.35,33.4 40.06,33.7 v4(40.06,33.78) ; v4(33.85,72.4) 33.85,72.58 34.16,72.9 v5(34.35,72.9) 34.35,72.76 34.53,72.58 35.17,72.58 35.73,73.14 35.73,74.22 34.48,75.47 v4(31.93,75.47)
  BOTTOM w0.081: JEDP1.17 v5(34.35,72.9)
DMIC_CLK0: length 136.6
  IN1 w0.064: v4(110.46,41.14) 110.1,41.5 109.85,41.5 109.72,41.63 108.79,41.63 108.66,41.49 108.62,41.45 108.2,41.45 108.16,41.49 104.89,41.49 101.14,37.74 101.14,37.32 98.47,34.65 98.47,34.3 96.87,32.7 91.25,32.7 91.12,32.57 90.42,32.57 90.11,32.27 87.1,32.27 86.32,33.05 83.67,33.05 79.92,36.79 78.74,36.79 78.46,37.08 70.74,37.08 70.54,37.27 60.65,37.27 59.7,38.22 53.68,38.22 48.55,43.34 48.55,46.69 47.96,47.28 47.96,52.02 49.24,53.3 49.24,57.82 49.43,58.01 49.43,59.72 48.83,60.31 48.83,63.9 46.53,66.2 45.76,66.2 42.91,69.05 41.93,69.05 v4(41.86,69.12)
  IN3 w0.064: v4(110.46,41.14) 111.44,42.13 111.44,42.74 113.02,44.32 113.02,44.91 113.3,45.19 113.3,46.02 114.45,47.17 115.47,47.17 116.51,48.21 116.95,48.21 117.19,48.46 117.19,48.82 117.63,49.25 117.77,49.25 118.94,50.43 120.61,50.43 120.71,50.33 123.28,50.33 124.38,49.23 126.25,49.23 126.6,49.58 127.79,49.58 128.11,49.27 v5(128.8,49.27) ; v4(41.86,69.12) 41.59,68.84 38.99,68.84 38.01,67.86 38.01,67.57 v5(37.52,67.08)
  BOTTOM w0.081: v5(128.8,49.27) 128.8,49.48 128.94,49.62 CC80.1 129.26,49.81 129.53,50.08 L16.1 ; v5(37.52,67.08) 37.52,66.53 37.03,66.04 35.29,66.04 34.96,66.37 34.96,66.44 R273.2
DMIC_CLK0_L: length 5.2
  BOTTOM w0.081: L16.2 131.43,50.08 v1(131.51,50.16) 131.64,50.29 133.63,50.29 134.05,49.87 134.82,49.87 135.12,50.17 UC1.CP24
DMIC_CLK_CODEC: length 273.3
  IN1 w0.064: v2(195.49,20.25) 201.98,20.25 206.65,15.58 206.65,10.34 206.65,10.18 206.65,10.18 206.65,10.02 206.66,9.65 206.65,9.65 206.65,7.07 205.59,6 174.64,6 173.97,6.67 170.83,6.67 170.24,7.27 165.67,7.27 165.12,6.72 164.14,6.72 159.42,11.43 153.11,11.43 150.15,14.39 147.28,14.39 146.81,14.85 146.81,16.54 145.93,17.43 143.26,17.43 142.49,16.66 141.02,16.66 140.49,17.19 140.19,17.19 140.13,17.24 139.14,17.24 138.57,17.81 125.44,17.81 123.63,16 120.44,16 117.57,13.13 116.68,13.13 116.09,12.54 110.78,12.54 110.2,11.96 110.2,10.42 109.56,9.78 108.4,8.62 108.28,8.62 108.15,8.49 105.69,8.49 104.39,9.79 97.59,9.79 94.9,7.09 89.6,7.09 88.75,7.95 82.85,7.95 82.3,8.5 78.22,8.5 78.03,8.69 76.47,8.69 76.17,8.39 71.36,8.39 70.64,9.11 61.41,9.11 60.35,8.05 55.12,8.05 51.26,11.91 49.5,11.91 49.12,12.29 43.62,12.29 43.12,12.79 42.56,12.79 41.08,14.28 40.32,14.28 39.12,15.48 39.12,18.57 39.29,18.75 40.99,18.75 42.53,20.29 42.53,21.4 45.96,24.82 45.96,26.88 45.09,27.75 44.84,27.75 44.68,27.9 44.68,27.91 44.15,28.44 44.15,29.81 43.96,30 42.86,30 41.68,31.18 41.68,31.33 41.49,31.52 41.49,33.02 41.88,33.41 41.88,34.4 42.98,35.5 42.98,37.76 42.2,38.54 42.2,40.27 41.61,40.86 41.61,44.77 39.75,46.63 39.75,49.22 39.79,49.26 39.79,50.11 40.25,50.58 40.25,51.58 40.93,52.25 40.93,52.51 40.56,52.88 40.56,53.3 40.37,53.5 40.37,55.14 41.14,55.91 41.14,57.19 41.33,57.38 41.33,58.92 40.7,59.56 40.7,61.25 39.11,62.83 39.11,63.73 37.89,64.96 37.73,64.96 37.5,65.19 v4(37.4,65.19)
  IN3 w0.064: v4(37.4,65.19) 37.03,65.19 v5(36.54,65.69)
  BOTTOM w0.081: R271.2 34.75,67.11 34.44,66.8 34.44,66.15 35.03,65.56 36.41,65.56 v5(36.54,65.69)
DMIC_CLK_EDP: length 7.2
  BOTTOM w0.081: R273.1 R271.1 35.48,67.18 35.08,67.58 34.81,67.58 34.6,67.79 ED4.3 34.6,69.62 34.34,69.88 v1(34.34,69.98) 35.19,70.83 35.37,70.83 35.78,71.23 35.78,71.85 35.55,72.07 JEDP1.14
DMIC_DATA0: length 147.6
  IN1 w0.064: v4(108.41,41.87) 108.34,41.94 104.7,41.94 99.92,37.15 99.92,36.95 98.02,35.06 98.02,34.48 96.68,33.14 91.07,33.14 90.94,33.01 90.23,33.01 89.93,32.71 87.28,32.71 86.5,33.49 83.86,33.49 80.11,37.24 79.12,37.24 78.8,37.56 74.96,37.56 74.26,38.26 70.18,38.26 69.8,38.64 63.46,38.64 62.64,39.46 59.2,39.46 59.04,39.62 52.92,39.62 49,43.55 49,46.88 48.41,47.47 48.41,50.98 48.51,51.09 48.51,51.95 50.2,53.64 50.2,55.11 51.72,56.63 51.72,59.31 50.19,60.84 50.19,63.17 46.71,66.65 45.94,66.65 42.97,69.62 41.62,69.62 v4(41.58,69.59)
  IN3 w0.064: v5(37.14,67.46) 37.14,67.62 38.81,69.28 41.13,69.28 41.43,69.59 v4(41.58,69.59) ; v5(130.96,50.5) 130.96,50.5 129.83,50.5 129.78,50.44 126.69,50.44 126.39,50.75 125.87,50.75 123.15,53.46 118.61,53.46 118.16,53.01 117.97,53.01 117.64,52.68 115.96,52.68 115.13,51.86 114.42,51.86 110.91,48.34 110.91,47.64 109.66,46.39 109.66,46.18 108.83,45.35 108.83,43.72 108.28,43.16 108.28,42 v4(108.41,41.87)
  BOTTOM w0.081: v5(37.14,67.46) 37.14,67.36 37.06,67.28 37.06,66.8 36.76,66.5 R272.2 ; v5(130.96,50.5) 130.81,50.65 130.11,50.65 129.88,50.88 CC79.1 129.97,51.08 130.77,51.08 131.22,50.63 133.15,50.63 133.88,51.37 134.19,51.37 134.7,50.85 134.7,50.66 134.88,50.48 135.45,50.48 135.84,50.09 UC1.CN24
DMIC_DATA_CODEC: length 278.3
  IN1 w0.064: v2(195.49,19.75) 201.86,19.75 206.21,15.39 206.21,10.15 206.21,9.99 206.21,9.84 206.21,7.25 205.4,6.45 189.84,6.45 189.29,6.99 189.29,7.15 189.29,7.3 189.29,7.31 189.29,7.81 188.86,8.24 181.78,8.24 180.66,7.12 180.32,7.12 180.32,7.12 171.08,7.12 170.49,7.71 163.77,7.71 159.61,11.88 153.29,11.88 149.89,15.28 149.89,15.41 149.36,15.93 148.05,15.93 146.11,17.87 142.89,17.87 142.55,17.54 141.46,17.54 141.37,17.63 140.37,17.63 140.32,17.69 139.33,17.69 138.76,18.26 125.25,18.26 123.44,16.45 120.26,16.45 117.38,13.57 116.5,13.57 115.91,12.98 110.41,12.98 109.75,12.33 109.75,10.6 109.11,9.95 108.22,9.06 108.1,9.06 107.96,8.93 105.87,8.93 104.57,10.23 104.57,10.23 104.55,10.25 96.28,10.25 95.81,9.78 95.81,9.39 95.81,9.39 95.81,8.94 94.41,7.54 89.79,7.54 88.93,8.39 83.03,8.39 82.48,8.95 78.41,8.95 78.22,9.14 76.29,9.14 75.98,8.84 71.55,8.84 70.83,9.55 61.84,9.55 59.3,12.09 59.3,12.56 57.48,14.38 54.81,14.38 52.79,12.35 49.69,12.35 49.31,12.74 43.8,12.74 43.3,13.24 42.74,13.24 41.25,14.73 40.49,14.73 39.53,15.69 v4(39.5,15.69) ; v4(35.88,66.54) 35.88,65.98 36.05,65.81 36.05,65.21 37.31,63.94 37.46,63.94 38.1,63.31 38.1,63 38.09,62.26 39.3,61.06 39.3,59.09 39.8,58.59 39.8,57.24 39.9,57.14 39.9,56.53 39.17,55.79 39.17,53.22 38.76,52.82 38.76,51.06 38.39,50.69 38.39,49.84 38.22,49.67 38.22,45.89 39.55,44.56 39.55,38.07 38.76,37.28 38.76,34.73 38.33,34.31 37.95,34.31 37.2,33.56 36.32,33.56 36.16,33.56 35.69,33.09 35.69,32.07 35.22,31.6 35.22,31.1 35.83,30.49 35.83,29.9 34.67,28.73 34.39,28.73 34.39,28.73 33.8,28.73 33.8,28.73 33.71,28.73 33.68,28.71 33.61,28.69 32.83,28.69 32.21,28.07 31.14,27 31.14,26.08 31.14,26.07 31.14,25.49 31.14,25.48 31.14,24.54 34.32,21.36 34.32,13.55 34.33,13.54 34.33,13.38 v4(34.04,13.1)
  IN3 w0.064: v4(35.88,66.54) 35.88,66.58 36.41,67.11 v5(36.67,67.11) ; v4(34.04,13.1) 34.07,13.07 35.01,13.07 37.64,15.69 v4(39.5,15.69)
DMIC_DATA_EDP: length 6.4
  BOTTOM w0.081: JEDP1.13 35.95,72.05 36.16,71.85 36.16,70.13 v1(36.09,70.07) 35.47,69.45 35.47,68.44 35.6,68.31 ED4.2 35.6,67.89 36.09,67.4 R270.1 R272.1
DRAM_RESET#: length 1.6
  TOP w0.081: RC576.2 v2(145.22,54.87)
  IN1 w0.064: v2(145.22,54.87) 144.72,54.87 v4(144.67,54.82)
  IN3 w0.064: v5(145.1,54.67) 144.96,54.82 v4(144.67,54.82)
DTH_CSCL: length 2.8
  TOP w0.081: UM1.48 22.91,38.03 22.43,37.55 RM14.1 22.25,37.39 22.12,37.26 22.12,36.49 22.27,36.34 RM11.2
DTH_CSDA: length 3
  TOP w0.081: RM12.2 21.61,36.34 21.46,36.49 21.46,37.23 21.62,37.39 RM15.1 21.85,37.39 22.51,38.05 UM1.47
DTH_PDB: length 7
  IN1 w0.064: v2(26.99,43.4) 22.5,43.4 22.17,43.73 v4(22.04,43.73)
  IN3 w0.064: v5(22.04,43.39) v4(22.04,43.73)
  BOTTOM w0.081: RM5.2 RM16.1 22.23,43.84 CM51.1 22.28,43.63 v5(22.04,43.39)
DTH_SPI_CK_OUT: length 2.6
  TOP w0.081: UM1.23 22.91,46.08 22.6,46.39 22.37,46.39 21.93,46.84 RM27.1 RM30.2
DTH_SPI_CK_OUT_R: length 9
  TOP w0.081: v2(20.8,54.04) 19.66,54.04 19.37,54.33 UM3.6 ; v2(21.46,47.88) 21.47,47.87 RM30.1
  IN1 w0.064: v2(21.46,47.88) 20.8,48.54 v2(20.8,54.04)
DTH_SPI_CS: length 12.3
  TOP w0.081: UM1.21 23.71,46 22.86,46.84 22.68,46.84 22.59,46.93 RM26.1 22.76,47.05 22.96,47.24 v2(22.96,47.99) ; UM3.1 16.83,48.49 v1(17.53,47.79) 19.32,47.79 19.74,47.36 20.16,47.36 v2(20.18,47.35)
  IN1 w0.064: v2(22.96,47.99) 22.88,48.08 22.23,48.08 22.03,47.88 22.03,47.14 21.35,46.46 20.4,46.46 20.18,46.68 v2(20.18,47.35)
DTH_SPI_D_IN: length 10.5
  TOP w0.081: v2(21.02,47.87) 21.17,47.72 21.17,46.83 21.28,46.72 21.73,46.72 22.51,45.93 UM1.24
  IN1 w0.064: v2(21.02,47.87) 20.51,48.38 20.51,54.71 v2(20.64,54.84)
DTH_SPI_D_OUT: length 8.3
  TOP w0.081: UM3.2 18.1,48.45 18.3,48.25 19.15,48.25 19.62,47.78 20.49,47.78 20.96,48.26 v1(21.95,48.26) 22.28,47.92 22.28,46.82 22.48,46.62 22.69,46.62 23.31,46 UM1.22
DTH_SPI_HOLD#: length 3.7
  TOP w0.081: RM23.1 16.41,53.88 17.73,53.88 18.1,54.24 UM3.7
DTH_SPI_WR_PROT: length 7.1
  TOP w0.081: v1(19.06,47.37) 19.46,46.98 20.36,46.98 v2(20.49,46.85) RM28.1 20.85,46.57 20.97,46.46 21.56,46.46 22.11,45.9 UM1.25 ; UM3.3 19.37,48.42 19.65,48.13 v2(20.21,48.13)
  IN1 w0.064: v2(20.21,48.13) 20.49,47.86 v2(20.49,46.85)
DTH_XTI: length 10.4
  TOP w0.081: v6(24.63,46.67) 25.56,46.67 26.11,46.12 UM1.15
  BOTTOM w0.081: YM1.1 18.06,46.61 19.13,46.61 CM29.1 19.9,46.36 20,46.26 24.48,46.26 24.64,46.43 24.64,46.65 v6(24.63,46.67)
DTH_XTO: length 4.9
  TOP w0.081: v6(24.02,46.67) 24.02,46.53 24.29,46.27 25.44,46.27 25.71,45.99 UM1.16
  BOTTOM w0.081: v6(24.02,46.67) 24.02,46.67 23.7,46.99 v1(22.85,46.99) RM61.1
DTH_XTO_R: length 2.9
  BOTTOM w0.081: YM1.3 18.81,47 CM30.1 19.39,46.99 v1(20.37,46.99) RM61.2
EC_D_INHIB: length 19.2
  TOP w0.081: v1(35.83,17.82) 35.12,17.11 DZ12.2 v2(35.67,16.72) ; QZ21.2 38.26,13.82 37.88,13.44 CZ218.1 RZ1413.1 RZ22.2 36.04,14.76 v2(35.77,15.03) ; RE513.2 42.33,17.33 v2(42.33,16.88)
  IN1 w0.064: v2(35.77,15.03) 35.77,15.3 35.79,15.33 v4(35.79,15.57) 35.79,15.95 35.67,16.07 v2(35.67,16.72) ; v2(42.33,16.88) 42.38,16.88 v4(42.65,16.61)
  IN2 w0.066: v4(42.65,16.61) 42.65,16.61 42.65,16.52 42.17,16.04 41.14,16.04 40.69,16.48 40.69,16.68 40.17,17.2 40.17,17.24 39.84,17.57 39.43,17.57 39.13,17.27 39.13,16.76 38.41,16.04 38,16.04 37.09,15.13 35.89,15.13 35.79,15.22 v4(35.79,15.57)
EC_D_INHIBIT: length 2.9
  TOP w0.081: UE1.A5 44.23,19.01 44.13,18.9 43.78,18.9 43.32,18.43 v1(43.1,18.43) 42.9,18.43 42.47,18 RE513.1
EC_MUTE#: length 177.1
  TOP w0.081: v1(38.8,16.85) 39.17,17.22 RE29.2 40.44,15.45 v2(40.52,15.37)
  IN1 w0.064: v2(40.52,15.37) 40.52,15.49 40.75,15.72 42,15.72 42.91,14.82 43.57,14.82 44.7,13.69 49.45,13.69 49.89,14.14 50.3,14.14 53.22,14.14 54.42,15.33 55.51,15.33 56.26,16.08 58.75,16.08 59.18,15.65 59.64,15.65 60.22,15.07 60.22,14.3 63.61,10.9 71.1,10.9 72.02,9.98 75.22,9.98 75.53,10.28 82.54,10.28 83.46,9.36 91.37,9.36 92.24,8.49 92.96,8.49 95.68,11.2 97.92,11.2 99.99,13.27 107.15,13.27 108.04,14.16 114.43,14.16 115.09,14.82 116.92,14.82 119.69,17.59 122.97,17.59 125.43,20.05 131.5,20.05 132.15,19.4 138.79,19.4 139.04,19.65 140.16,19.65 140.26,19.55 143.38,19.55 143.94,20.11 147.79,20.11 150.73,17.17 153.69,17.17 155.09,15.77 155.09,14.19 155.48,13.81 160.96,13.81 164.8,9.97 164.82,9.97 164.82,9.97 165.7,9.97 166.38,9.29 171.36,9.29 171.87,8.78 180.06,8.78 181.98,10.7 183.72,10.7 184.62,9.79 192.32,9.79 193,9.11 195.35,9.11 v2(195.49,9.25)
EC_RESET#: length 36.6
  TOP w0.081: UE5.2 63.62,19.72 63.24,19.35 v1(61.95,19.35) 61.43,19.35 60.87,18.79 57.85,18.79 57.66,18.97 57.66,20.11 v2(57.78,20.22) ; v2(39.29,23.54) 39.29,23.82 RE545.2 ; v2(42.05,23.58) 41.89,23.58 41.74,23.43 UE1.B63
  IN1 w0.064: v4(52.31,20.94) 52.4,21.03 53.53,21.03 53.85,21.35 54.24,21.35 54.86,20.73 57.27,20.73 v2(57.78,20.22) ; v2(42.05,23.58) 42.92,24.45 v4(42.92,24.6) 42.76,24.77 42.4,24.77 41.46,23.82 41.04,23.82 40.47,23.25 39.58,23.25 v2(39.29,23.54)
  IN2 w0.066: v4(42.92,24.6) 43,24.6 43.39,25 47.49,25 48.8,26.31 50.21,26.31 50.66,25.86 50.66,25.78 50.84,25.61 50.84,23.09 50.52,22.78 50.52,21.67 50.7,21.49 51.77,21.49 v4(52.31,20.94)
EDP_AUXN: length 217.1
  IN1 w0.079: v4(38.21,35.76) 38.03,35.95 37.7,35.95 37.48,36.16 37.48,37.08 38.78,38.38 38.78,44.25 37.46,45.57 37.46,49.99 37.62,50.15 37.62,51.01 37.99,51.38 37.99,53.13 38.4,53.54 38.4,58.01 36.6,59.8 36.6,61.93 35.58,62.96 35.58,63.51 35.33,63.76 35.33,64.22 34.8,64.75 34.8,69.28 32.15,71.93 30.63,71.93 30.12,72.43 28.12,72.43 27.88,72.19 27.88,71.77 v2(28.06,71.59)
  IN3 w0.079: v5(163.74,31.25) 163.74,31.15 163.63,31.04 163.63,30.19 164.14,29.68 164.27,29.26 164.27,29.25 164.29,29.19 164.59,28.29 164.59,23.55 164.59,23.55 164.59,20.72 164.58,20.72 164.58,14.75 164.58,14.58 159.99,9.98 159.95,9.97 158.72,9.4 157.39,8.85 156.27,8.85 154.61,8.16 150.65,4.2 108.8,4.2 108.73,4.13 108.19,4.13 107.63,4.69 85.37,4.69 79.96,10.1 71.57,10.1 65.84,15.83 65.1,15.83 62.35,18.58 62.35,19.43 61.6,20.18 61.6,22.13 60.82,22.91 60.82,24.25 57.59,27.48 57.59,28.92 55.67,30.84 54.66,30.84 53.91,31.59 53.62,31.59 53.62,31.6 53.33,31.6 51.58,33.35 49.4,33.35 46.92,35.83 43.9,35.83 43.75,35.98 41.8,35.98 41.63,35.8 39.36,35.8 39.19,35.97 38.42,35.97 v4(38.21,35.76)
  BOTTOM w0.076: UC1.AH4 163.29,37.07 163.29,36.5 162.91,36.11 162.91,34.93 162.74,34.76 162.74,34.73
  BOTTOM w0.091: 162.74,34.73 162.35,34.34 162.35,33.35 162.33,33.34 162.33,33.09 v7(162.7,32.72) 163.73,31.7 163.73,31.27 v5(163.74,31.25)
EDP_AUXN_C: length 4.5
  TOP w0.091: C17.2 27.88,72.35 v7(27.88,73.07) 27.88,73.93 27.85,73.95 27.85,74.16 v6(28.04,74.35)
  BOTTOM w0.091: JEDP1.33 27.95,72.67 27.85,72.77 27.85,74.16 v6(28.04,74.35)
EDP_AUXP: length 217.1
  IN1 w0.079: v4(38.21,36.3) 38.06,36.15 37.78,36.15 37.68,36.25 37.68,37 38.98,38.3 38.98,44.33 37.66,45.65 37.66,49.91 37.82,50.07 37.82,50.93 38.19,51.3 38.19,53.05 38.6,53.46 38.6,58.09 36.8,59.89 36.8,62.01 35.78,63.04 35.78,63.6 35.53,63.84 35.53,64.31 35.01,64.83 35.01,69.36 32.24,72.13 30.71,72.13 30.21,72.63 28.03,72.63 27.68,72.27 27.68,71.77 v2(27.5,71.59)
  IN3 w0.079: v5(163.36,31.25) 163.42,31.18 163.42,31.14 163.43,31.14 163.43,30.11 163.96,29.58 164.08,29.2 164.08,29.19 164.1,29.13 164.39,28.26 164.39,23.64 164.39,23.63 164.39,20.81 164.38,20.8 164.38,14.83 164.38,14.83 164.38,14.66 159.88,10.16 159.87,10.16 159.85,10.15 158.64,9.58 157.35,9.05 156.23,9.05 154.5,8.33 150.56,4.4 108.71,4.4 108.65,4.33 108.27,4.33 107.71,4.89 85.45,4.89 80.04,10.3 71.66,10.3 65.93,16.03 65.18,16.03 62.55,18.66 62.55,19.52 61.8,20.26 61.8,22.21 61.02,22.99 61.02,24.34 57.79,27.57 57.79,29 55.76,31.04 54.75,31.04 53.99,31.79 53.62,31.79 53.62,31.8 53.41,31.8 51.66,33.55 49.49,33.55 47,36.03 43.99,36.03 43.84,36.18 41.72,36.18 41.66,36.12 41.66,36.12 41.54,36 39.44,36 39.27,36.17 38.34,36.17 v4(38.21,36.3)
  BOTTOM w0.076: 162.59,34.88 162.61,34.89 162.63,34.89 162.74,35 162.74,36.18 162.81,36.25 162.81,36.9 162.9,36.99 163,36.99 163.05,36.94 UC1.AH3
  BOTTOM w0.091: 162.59,34.88 162.13,34.41 v7(162.13,33.87) 162.13,33.01 162.33,32.8 162.33,32.79 162.77,32.35 162.79,32.35 163.52,31.61 163.52,31.48 163.36,31.31 v5(163.36,31.25)
EDP_AUXP_C: length 4.5
  TOP w0.091: C19.2 27.68,72.35 27.68,72.78 27.66,72.79 27.66,73.34 27.68,73.35 27.68,73.84 27.65,73.87 27.65,74.16 v6(27.46,74.35)
  BOTTOM w0.091: JEDP1.34 27.55,72.65 27.65,72.75 27.65,74.16 v6(27.46,74.35)
EDP_BKLT_CTRL: length 120.6
  TOP w0.081: D2.2 57.84,34.87 57.32,35.4 v2(57.32,36.09) v1(56.76,36.09)
  IN1 w0.064: v2(57.32,36.09) v4(57.32,36.42)
  IN2 w0.066: v4(57.32,36.42) 58.14,36.42 65.41,29.14 65.41,22.49 67.64,20.26 67.86,20.26 72.77,15.35 80.56,15.35 81.48,16.27 88.48,16.27 89.32,15.42 92.41,15.42 92.64,15.65 110.72,15.65 111.87,16.8 113.2,16.8 114.75,15.26 118.3,15.26 121.67,18.63 122.72,18.63 123.93,19.84 123.93,22.42 127.69,26.18 129.43,26.18 131.73,28.49 131.73,32.9 132.72,33.89 132.72,37.59 132.23,38.08 132.23,39.28 132.68,39.72 132.68,40.84 134.28,42.45 135.41,42.45 135.7,42.73 135.71,42.73 136.39,43.41 137.84,43.41 138.16,43.09 138.16,42.81 v4(138.33,42.64)
  IN3 w0.064: v4(138.33,42.64) 138.33,41.84 v5(138.54,41.63)
EDP_COMP: length 3.3
  IN1 w0.127: v4(160,39.19) 159.97,39.17 159.97,37.91 159.66,37.6 v2(159.12,37.6)
  IN3 w0.127: v4(160,39.19) 160.24,39.44 v5(160.24,39.51)
  BOTTOM w0.127: UC1.AM6 160.43,39.25 160.43,39.27 160.27,39.42 160.27,39.48 v5(160.24,39.51)
EDP_HPD: length 2.3
  TOP w0.081: UE1.A47 42.73,30.76 42.58,30.91 41.72,30.91 41.44,31.19 RE543.1
EDP_HPD_R: length 197.4
  TOP w0.081: v2(45.89,38.63) 46.18,38.63 46.46,38.35 46.46,38.08 46.27,37.89 45.63,37.89 v1(44.35,36.6) 43.85,36.11 43.48,36.11 42.28,34.91 41.43,34.91 41.08,34.56 41.08,33.16 41.13,33.11 41.13,32.69 41.44,32.38 RE543.2
  IN1 w0.064: v4(45.45,38.81) 45.72,38.81 v2(45.89,38.63)
  IN2 w0.066: v4(34.96,69.93) 35.12,69.93 35.17,69.98 36.63,69.98 36.8,69.81 36.8,65.48 34.4,63.07 34.4,61.4 34.22,61.22 34.03,61.22 33.86,61.05 33.86,60.81 33.49,60.44 33.49,54.73 33.16,54.4 33.16,53.93 33.31,53.77 33.64,53.77 33.73,53.87 33.98,53.87 34.36,53.49 34.36,52.28 34.72,51.92 34.72,51.01 35.3,50.42 35.3,48.34 39.75,43.89 39.75,41.51 42.45,38.81 v4(45.45,38.81) 45.84,38.42 47.67,38.42 47.91,38.66 49.76,38.66 51.66,36.76 55.5,36.76 62.94,29.33 62.94,25.76 63.39,25.31 63.39,25.18 63.84,24.73 63.84,22.12 66.03,19.93 66.03,18.7 71.45,13.28 74.29,13.28 76.06,11.5 80.58,11.5 82.09,9.99 94.56,9.99 96.08,11.52 97.14,11.52 99.61,13.98 110.88,13.98 111.32,13.55 119.37,13.55 121.9,16.08 123.57,16.08 123.85,15.79 125.55,15.79 127.76,18 131.79,18 132.99,19.2 138.6,19.2 139.34,19.95 139.34,25.94 137.17,28.11 137.17,35.67 136.55,36.29 136.55,37.82 135.93,38.44 v4(135.93,39.18)
  IN3 w0.064: v5(136.26,39.44) 136.18,39.44 v4(135.93,39.18) ; v5(34.01,69.69) 34.2,69.87 34.91,69.87 v4(34.96,69.93)
  BOTTOM w0.081: JEDP1.24 31.55,72.07 31.29,71.81 31.29,71.31 31.38,71.22 32.76,71.22 34.01,69.97 v5(34.01,69.69) 34.01,69.32 34.11,69.22 34.11,67.77 34.01,67.66 R77.1
EDP_TXN0: length 231.2
  IN1 w0.079: v2(21.6,72.07) 21.51,71.98 21.38,71.98 21.09,71.68 21.09,71.15 21.35,70.89 21.35,69.03 22.05,68.33 22.05,67.36 25.57,63.84 25.57,62.62 26.09,62.09 28.31,62.09 28.85,62.63 28.85,62.63 29.27,63.06 33.61,63.06 34.38,62.29 34.38,61.79 34.4,61.76 34.4,61.38 35.01,60.77 35.01,59.74 37.23,57.52 37.23,55.23 36.84,54.85 36.84,53.64 36.76,53.55 36.76,51.8 36.45,51.49 36.45,50.64 36.29,50.47 36.29,45.08 37.61,43.76 37.61,40.91 37.09,40.38 37.09,38.36 35.93,37.2 35.93,35.81 35.59,35.46 35.59,34.44 35.85,34.18 v4(36.41,34.18)
  IN3 w0.079: v5(165.37,31.54) 165.37,31.51 165.31,31.45 165.31,30.41 165.86,29.85 165.86,14.21 160.53,8.88 160.53,5.42 160.53,5.41 160.53,5.37 160.53,5.25 158.24,2.95 107.31,2.95 107.14,3.11 100.32,3.11 100.08,3.11 85.17,3.11 79.4,8.89 70.28,8.89 61.04,18.13 61.04,18.96 60.34,19.66 60.34,21.61 59.65,22.3 59.65,23.77 56.02,27.4 53.81,27.4 52.23,28.98 52.23,29.43 51.15,30.51 50.77,30.51 50.51,30.25 49.87,30.25 49.43,30.7 49.43,31.14 48.57,32 48.57,32.53 46.43,34.66 43.93,34.66 43.51,34.25 43.03,34.25 42.64,34.63 39.46,34.63 39.38,34.56 39.08,34.56 38.58,34.06 36.89,34.06 36.77,34.18 v4(36.41,34.18)
  BOTTOM w0.076: 164.06,35.05 164.06,35.07 164.04,35.09 164.04,35.3 164.13,35.39 164.13,35.77 164.05,35.84 164.01,35.95 164.01,36.13 164.04,36.16 164.04,36.53 163.98,36.59 163.98,36.73 164.03,36.78 164.03,37.22 UC1.AG4
  BOTTOM w0.091: v5(165.37,31.54) 165.27,31.64 165.27,31.96 164.06,33.17 v7(164.06,33.56) 164.06,35.04 164.06,35.04 164.06,35.05 164.06,35.05
EDP_TXN0_C: length 6.7
  TOP w0.091: C12.2 22.36,71.88 24.47,71.88 24.49,71.89 25.19,71.89 25.21,71.88 25.73,71.88 v7(26.07,72.22) 26.57,72.71 26.57,72.96 v6(26.26,73.27)
  BOTTOM w0.091: v6(26.26,73.27) 26.28,73.27 26.55,73 26.55,72.82 26.35,72.62 JEDP1.37
EDP_TXN1: length 227.4
  IN1 w0.079: v2(21.6,73.67) 21.78,73.5 22.19,73.5 23.84,71.85 26.28,71.85 26.9,71.22 28.95,71.22 29.27,71.54 32,71.54 34.42,69.12 34.42,63.36 35.23,62.55 35.23,61.7 36.22,60.7 36.22,59.65 38.02,57.85 38.02,53.7 37.54,53.23 37.54,51.47 37.24,51.17 37.24,50.31 37.07,50.15 37.07,45.41 38.4,44.09 38.4,38.56 36.77,36.93 36.77,35.46 36.89,35.34 36.98,35.34 v4(37.14,35.5)
  IN3 w0.079: v4(37.14,35.5) 37.36,35.5 37.43,35.43 37.43,35.22 37.48,35.17 37.62,35.17 37.79,35.34 39.06,35.34 39.13,35.41 42.42,35.41 42.53,35.52 43.57,35.52 43.65,35.45 46.76,35.45 49.63,32.57 49.63,32.24 50.21,31.66 51.12,31.66 51.44,31.97 52.37,31.97 53.19,31.16 53.72,31.16 54.44,30.44 55.08,30.44 55.48,30.04 55.48,29.86 56.81,28.53 56.81,27.72 60.44,24.1 60.44,22.65 61.14,21.95 61.14,20.1 61.94,19.3 61.94,18.36 70.59,9.71 79.78,9.71 85.19,4.31 107.19,4.31 107.65,3.85 107.93,3.85 108.03,3.75 108.89,3.75 108.95,3.81 150.8,3.81 151.66,4.66 152.39,4.66 153.27,3.78 157.93,3.78 159.54,5.39 159.54,8.99 165.08,14.54 165.08,22.47 165.08,22.47 165.08,28.32 164.65,29.68 164.23,31.03 164.23,31.42 v5(164.16,31.5)
  BOTTOM w0.076: UC1.AG2 163.62,36.27 163.51,36.16 163.36,36.16 163.17,35.98 163.17,34.64 163.16,34.62 163.16,34.6
  BOTTOM w0.091: v5(164.16,31.5) 164.16,31.51 164.25,31.6 164.25,31.78 v7(163.9,32.13) 163.01,33.02 163.01,34.3 163.16,34.45 163.16,34.6
EDP_TXN1_C: length 5.4
  TOP w0.091: v6(25.09,73.3) 25.1,73.3 25.4,73 25.4,72.88 25.28,72.77 24.82,72.77 24.09,73.5 23.55,73.5 23.54,73.51 23,73.51 22.98,73.5 22.35,73.5 C14.2
  BOTTOM w0.091: JEDP1.40 25.15,72.59 25.35,72.79 25.35,73.03 v6(25.09,73.3)
EDP_TXP0: length 231.1
  IN1 w0.079: v4(36.41,34.71) 36.25,34.71 36.16,34.62 36.16,34.47 36.07,34.38 35.94,34.38 35.79,34.52 35.79,35.38 36.13,35.72 36.13,37.12 37.29,38.28 37.29,40.3 37.81,40.82 37.81,43.84 36.49,45.17 36.49,50.39 36.65,50.56 36.65,51.41 36.96,51.72 36.96,53.47 37.04,53.55 37.04,54.76 37.43,55.15 37.43,57.61 35.21,59.83 35.21,60.85 34.6,61.46 34.6,61.85 34.58,61.87 34.58,62.37 33.69,63.26 29.19,63.26 28.65,62.72 28.65,62.71 28.23,62.29 26.18,62.29 25.77,62.7 25.77,63.92 22.25,67.44 22.25,68.42 21.55,69.12 21.55,70.97 21.29,71.24 21.29,71.6 21.47,71.78 21.64,71.78 21.74,71.68 21.74,71.56 21.69,71.51 v2(21.6,71.51)
  IN3 w0.079: v5(164.99,31.54) 165.08,31.45 165.08,31.42 165.1,31.39 165.1,30.33 165.66,29.77 165.66,14.29 160.33,8.96 160.33,5.33 158.16,3.15 107.39,3.15 107.23,3.32 100.4,3.32 100.08,3.32 85.26,3.32 79.48,9.09 70.36,9.09 61.24,18.21 61.24,19.04 60.54,19.74 60.54,21.69 59.85,22.38 59.85,23.85 56.11,27.6 53.89,27.6 52.43,29.06 52.43,29.52 51.23,30.71 50.68,30.71 50.42,30.45 49.96,30.45 49.63,30.78 49.63,31.23 48.77,32.09 48.77,32.61 46.52,34.86 43.84,34.86 43.43,34.45 43.11,34.45 42.73,34.83 39.37,34.83 39.3,34.76 38.99,34.76 38.5,34.26 36.98,34.26 36.86,34.38 36.86,34.64 36.79,34.71 v4(36.41,34.71)
  BOTTOM w0.076: UC1.AG3 163.53,37.07 163.53,37.2 163.61,37.28 163.74,37.28 163.86,37.15 163.86,36.85 163.81,36.8 163.81,36.52 163.88,36.46 163.88,36.23 163.84,36.19 163.84,35.92 163.91,35.75 163.96,35.7 163.96,35.46 163.88,35.37 163.88,35.09 163.86,35.07 163.86,35.05
  BOTTOM w0.091: 163.86,35.05 163.86,33.94 163.85,33.93 163.85,33.29 163.86,33.27 163.86,33.09 165.07,31.87 165.07,31.64 164.99,31.55 v5(164.99,31.54)

# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_SLP_S4#: length 219.7
  TOP w0.081: RC11.2 144.89,51.36 145.01,51.49 v2(145.01,51.64) 145.01,51.7 v1(144.74,51.97) ; v2(187.16,33.39) 187.16,32.07 185.56,30.47 DZ7.1 185.71,27.73 RZ9.1 ; v2(133.14,70.62) 132.92,70.62 132.79,70.74 RZ1416.1 132.49,71.12 131.95,71.67 JAPS1.5
  IN1 w0.064: v4(196.56,34.54) 196.05,34.03 196.05,32.62 195.66,32.22 195.66,31.19 194.36,29.89 193.63,29.89 193.05,29.31 190.64,29.31 189.45,30.49 189.44,30.5 189,30.94 188.99,30.95 188.07,31.88 188.07,32.49 v2(187.16,33.39) ; v2(145.01,51.64) 144.96,51.64 v4(144.69,51.91) 144.69,52.19 144.63,52.25 144.63,52.53 145.16,53.07 145.16,53.35 145.63,53.81 146.01,53.81 146.18,53.65 146.79,53.65 147.68,54.54 147.68,56.93 140.88,63.74 139.9,63.74 136.87,66.77 136.87,68.73 134.98,70.62 v2(133.14,70.62) v4(133.14,71.31)
  IN2 w0.066: v4(144.69,51.91) 144.88,51.91 145.45,51.34 145.45,50.97 145.11,50.62 144.78,50.62 144.68,50.52 144.68,50.45 144.46,50.23 144.46,49.72 144.7,49.48 145.07,49.48 145.28,49.27 145.28,47.99 145.03,47.73 145.03,46.11 143.09,44.18 143.09,42.83 142.43,42.17 141.69,42.17 140.34,40.83 139.59,40.83 139.41,40.65 138.57,40.65 138.18,40.26 138.11,40.26 137.42,39.56 137.42,38.3 138.4,37.32 138.4,34.92 137.68,34.21 137.68,32.36 138.26,31.78 v6(139.79,31.78) ; v4(196.56,34.54) 202.43,34.54 203.74,35.85 203.74,37.64 204.46,38.36 205.27,38.36 206.46,39.55 206.46,40.77 206,41.23 206,42.18 205.63,42.54 205.63,43.36 203.85,45.14 201.63,45.14 199.72,47.05 198.75,47.05 198.13,47.67 198.13,59.49 195.98,61.64 193.59,61.64 192.41,62.82 192.41,64.31 191.25,65.47 191.25,65.62 190.78,66.09 190.63,66.09 189.51,67.21 189.51,77.92 188.54,78.89 188.23,78.89 188.02,78.68 186.67,78.68 186.24,78.25 184.93,78.25 184.27,77.59 168.31,77.59 167.19,78.71 165.97,78.71 165.56,78.3 150.33,78.3 148.23,80.41 141.17,80.41 138.84,78.07 135.72,78.07 134.58,79.21 134.14,79.21 133.14,78.21 v4(133.14,71.31)
  IN3 w0.064: v4(144.69,51.91) 144.85,52.07 v5(145.1,52.07)
  BOTTOM w0.081: RZ1418.1 141.51,30.26 141.06,29.81 141.06,29.34 DZ5.1 140.61,29.43 139.79,30.25 v6(139.79,31.78)
SIO_SLP_S4#_UZ8: length 3.3
  TOP w0.081: UZ8.3 135.04,71.43 134.42,70.8 v1(134.23,70.8) 133.69,70.8 RZ1416.2 CZ220.1
SIO_SLP_S5#: length 33.3
  TOP w0.081: RC514.2 145.52,53.36 v2(145.55,53.33) 146.16,53.33 v1(146.33,53.49)
  IN1 w0.064: v2(145.55,53.33) 145.55,53.11 v4(145.65,53.01) 145.87,53.01 146.04,52.84 146.74,52.84 146.93,53.02 146.93,53.52 147.89,54.48 147.89,54.78 147.89,54.78 147.89,55.08 147.89,55.77 147.89,56.99 140.96,63.93 140.06,63.93 137.62,66.37 137.62,70.21 135.11,72.72 135.11,73.45 134.79,73.77 133.39,73.77 v2(132.44,72.83)
  IN3 w0.064: v4(145.65,53.01) 145.67,53.01 146.01,53.36 v5(146.01,53.37)
SIO_SLP_SUS#: length 122.3
  TOP w0.081: RC553.2 143.85,52.61 v2(144.13,52.88) ; PR1813.2 68.93,16.01 67.78,14.86 67.78,12.66 67.59,12.47 67.18,12.47 66.21,13.44 66.21,23.99 66.68,24.45 66.68,27.76 67.61,28.69 67.61,29 v1(69.35,30.75) 69.46,30.85 72.16,30.85 v6(72.64,31.33)
  IN1 w0.064: v4(144.67,53.09) 144.64,53.11 144.19,53.11 144.13,53.05 v2(144.13,52.88)
  IN2 w0.066: v6(72.64,31.33) 72.64,31.24 73.18,30.71 76.9,30.71 77.31,30.3 80.68,30.3 81.46,31.08 100.03,31.08 100.67,30.45 109.91,30.45 109.96,30.5 112.62,30.5 112.72,30.4 113.91,30.4 119.84,36.33 119.84,37.48 123.24,40.88 123.24,43.93 v4(124.05,44.74) 127.27,47.96 129.49,47.96 133.18,51.65 134.12,51.65 135.32,52.85 138.02,52.85 138.17,52.69 139.34,52.69 139.54,52.49 140.62,52.49 141.77,53.64 143.88,53.64 144.42,53.09 v4(144.67,53.09)
  IN3 w0.064: v4(144.67,53.09) 144.67,53.1 144.83,53.1 v5(145.1,53.37) ; v4(124.05,44.74) 124.05,44.75 124.07,44.77 124.07,44.77 v5(124.31,45.01)
  BOTTOM w0.081: RZ1419.1 123.08,49.34 124.57,47.85 124.57,47.4 124.48,47.31 124.48,45.18 v5(124.31,45.01)
SKTOCC#: length 6.5
  BOTTOM w0.089: UC1.E1 177.05,35.07 178.14,33.98 180.36,33.98 180.64,33.69 RC547.2
SLP_S0#_CPU: length 6.7
  BOTTOM w0.203: PRZ07.2 162.79,17.56 162.56,17.56 162.41,17.71 162,17.71 161.41,18.3 160.85,18.3 160.58,18.57 160.58,19.41 v1(160.4,19.59) 160.13,19.85 160.13,20.67 159.93,20.88 PUZ01.35
  BOTTOM w0.254: PRZ07.2 163.53,17.39 PRZ04.2
SM_RCOMP0: length 2.7
  TOP w0.081: v2(148.33,52.96) v1(148.78,52.96)
  TOP w0.381: RC17.1 148.33,52.88 148.33,52.88 v2(148.33,52.96)
  IN1 w0.381: v4(148.3,52.4) 148.33,52.43 v2(148.33,52.96)
  IN3 w0.381: v4(148.3,52.4) 147.98,52.72 v5(147.84,52.72)
SM_RCOMP1: length 1.8
  TOP w0.381: RC18.1 147.43,51.87 v2(147.3,52)
  IN1 w0.381: v2(147.3,52) 147.51,52 v4(147.76,51.74)
  IN3 w0.381: v4(147.76,51.74) 147.76,52 v5(147.84,52.07)
SM_RCOMP2: length 2.5
  TOP w0.127: v2(147.71,53.11) 147.71,53.26 147.98,53.53 v1(147.98,54.09)
  IN1 w0.381: v2(147.71,53.11) 147.71,53.24 v4(148.23,53.76)
  IN3 w0.381: v4(148.23,53.76) v5(147.84,53.37)
SML0_SMBCLK: length 2.1
  TOP w0.081: v2(138.1,43.09) 137.99,43.2 RC33.1
  IN1 w0.064: v4(137.79,42.94) 137.95,42.94 v2(138.1,43.09)
  IN3 w0.064: v5(138.25,43.14) 138.13,43.02 137.85,43.02 137.79,42.96 v4(137.79,42.94)
  BOTTOM w0.081: v5(138.25,43.14) 138.54,43.43 UC1.CH14
SML0_SMBDATA: length 1.9
  TOP w0.081: RC34.1 140.79,44.86 v2(140.97,44.86)
  IN1 w0.064: v2(140.97,44.86) 140.83,44.86 140.78,44.91 v4(140.55,44.91)
  IN3 w0.064: v4(140.55,44.91) v5(140.21,44.91)
  BOTTOM w0.081: v5(140.21,44.91) 140.21,44.86 140.06,44.71 UC1.CF15
SN_1.2V:
  vias: v1(197.76,72.95)
SN_1.05V: length 1.2
  TOP w0.081: PCH11.1 136.75,21.3 v1(137.11,20.94)
SN_1.8V: length 2
  TOP w0.081: v1(70.9,30.27) 70.9,29.96 71.38,29.49 PR1808.2
SN_3V: length 1.1
  TOP w0.081: v1(18.94,15.74) 19.11,15.56 PC309.1
SN_5V: length 1.2
  TOP w0.081: PC516.1 v1(18,25.07)
SN_GPU1: length 1.4
  TOP w0.081: PCV15.1 61.4,76.3 v1(62.05,76.95)
SN_GPU2: length 0.7
  TOP w0.081: 62.37,64.1 v1(62.37,63.43)
SN_GT: length 2.3
  BOTTOM w0.081: v1(192.81,45.43) 193.89,45.43 194.65,46.19 194.84,46.19
SN_IA1: length 2.3
  TOP w0.081: v1(172.49,19.01) 172.19,19.32 170.35,19.32
SN_IA2:
  vias: v3(174.59,19.2)
SN_IA3: length 1.1
  TOP w0.081: PCI36.1 v1(187.97,21.62)
SN_SA: length 2.5
  TOP w0.081: v1(146.75,22.8) 146.25,23.3 PCA10.1
  TOP w0.508: PCA10.1 146.23,23.9 PRA02.2
SNUB1_CHG: length 1.7
  BOTTOM w0.081: PCB36.1 195.23,15.75 v1(194.82,15.75)
SOLC: length 59.8
  IN1 w0.064: v4(40.54,52.38) 40.43,52.38 39.81,51.76 39.81,50.76 39.34,50.3 39.34,49.44 39.31,49.41 39.31,46.44 41.17,44.58 41.17,40.63 41.62,40.18 v2(41.62,39.98) 41.62,38.49 42.54,37.58 42.54,35.69 41.43,34.58 41.43,33.59 41.05,33.21 41.05,31.33 41.24,31.14 41.24,30.99 42.7,29.53 v2(42.98,29.53)
  IN2 w0.066: v4(31.35,73.66) 31.18,73.66 31.04,73.52 31.04,72.87 31.19,72.72 31.9,72.72 32.15,72.47 33.06,72.47 33.98,71.56 34.72,71.56 34.98,71.82 38.17,71.82 38.55,71.43 38.8,71.43 40.27,69.96 40.27,69.03 41.44,67.85 41.44,65.09 43.3,63.24 43.3,62.35 43.25,62.3 43.25,61.09 41.74,59.59 41.74,55.93 40.18,54.37 40.18,52.74 v4(40.54,52.38)
  IN3 w0.064: v4(31.35,73.66) 30.99,73.31 v5(30.99,72.93)
  BOTTOM w0.081: v5(30.99,72.93) 31.15,72.77 JEDP1.25
SPI_CLK_ROM: length 3.3
  TOP w0.081: v3(39.6,13.91) 39.69,14 40.64,14 RC40.2 UC3.6 42.25,13.43 U27.6
SPI_D0_ROM: length 3.4
  TOP w0.081: U27.5 42.25,14.7 UC3.5 RC42.2 41.21,14.85 40.99,15.07 40.2,15.07 v3(39.7,15.57)
SPI_D1_ROM: length 3.9
  TOP w0.081: U27.2 50.23,12.16 UC3.2 51.31,12.16 RC43.2 51.61,12.13 51.71,12.03 v3(51.71,10)
SPI_D2_ROM: length 1.4
  TOP w0.081: U27.3 50.23,13.43 UC3.3 RC39.2
SPI_D3_ROM: length 1.4
  TOP w0.081: U27.7 42.61,12.16 UC3.7 41.28,12.16 RC41.2
SPKR: length 102.8
  TOP w0.081: v2(139.97,57.49) 139.97,57.79 v1(140.29,58.11) 140.62,58.44 RC57.2
  IN1 w0.064: v2(139.97,57.49) 140.08,57.59 140.76,57.59 v4(140.91,57.44) ; v4(189.11,19.29) 189.11,17.14 190.32,15.93 191.9,15.93 194.67,13.16 195.6,13.16 195.64,13.12 195.64,13.12 195.86,12.9 195.86,12.9 195.97,12.79 195.97,11.97 195.75,11.75 v2(195.49,11.75)
  IN2 w0.066: v4(140.91,57.44) 141.06,57.29 143.34,57.29 145.1,55.53 145.1,55.13 145.36,54.87 145.9,54.87 146.09,55.05 146.71,55.05 146.85,54.91 147.39,54.91 148.24,55.77 148.24,60.24 148.55,60.55 149.81,60.55 150.32,60.05 154.12,60.05 156.32,57.85 174.89,57.85 180.87,51.87 180.87,40.25 180.9,40.23 180.9,39.9 180.87,39.88 180.87,36.89 v6(181.9,35.87)
  IN3 w0.064: v4(140.91,57.44) 140.91,57.39 140.4,56.89 v5(140.37,56.89) ; v4(189.11,19.29) 188.74,19.66 188.74,20.04 187.98,20.8 187.98,21.12 188.74,21.88 188.74,26.17 183.1,31.81 183.1,34.67 v6(181.9,35.87)
  BOTTOM w0.081: v5(140.37,56.89) 140.11,56.89 UC1.CF35
SSD_DEVSLP: length 45.6
  IN2 w0.066: v4(118.45,21.68) 118.65,21.48 121.21,21.48 121.37,21.65 121.37,22.43 122.56,23.61 122.56,30.31 130.37,38.12 130.37,40.12 131.13,40.88 v4(131.53,40.88)
  IN3 w0.064: v4(118.45,21.68) 118.28,21.68 116.81,20.21 115.99,20.21 115.28,20.92 115.28,20.92 114.96,20.92 114.67,21.21 114.67,21.62 114.33,21.96 114.33,22.22 114.55,22.44 114.88,22.44 115.47,23.03 115.47,24.66 114.26,25.87 113.12,25.87 v5(112.92,26.08) ; v4(131.53,40.88) 132.82,40.88 v5(133.69,40.01)
  BOTTOM w0.081: UC1.CR8 134.56,40.01 v5(133.69,40.01) ; v5(112.92,26.08) 112.43,25.59 111.06,25.59 110.88,25.77 JSSD1.38
SSD_SCP#: length 92.1
  IN1 w0.064: v2(41.38,22.93) 41.17,22.72 v4(40.87,22.72) 39,22.72 v2(38.87,22.85) ; v4(40.61,17.49) 40.61,17.42 40.75,17.28 40.86,17.28 41.76,16.39 42.15,16.39 43.08,15.46 43.88,15.46 44.17,15.17 44.86,15.17 45.16,14.86 45.16,14.57 45.47,14.26 49.21,14.26 49.69,14.75 51.86,14.75 52.27,15.16 52.27,15.51 52.92,16.16 54.44,16.16 55.3,17.03 59.15,17.03 59.34,16.83 60.63,16.83 61.24,16.22 61.24,16.01 61.84,15.42 61.84,14.09 64.08,11.85 71.49,11.85 72.41,10.93 74.83,10.93 75.13,11.23 82.94,11.23 83.09,11.09 83.66,11.09 84.15,10.59 91.16,10.59 93.38,12.81 93.38,14.23 93.97,14.82 98.84,14.82 99.2,15.17 105.66,15.17 108.48,18 110.54,18 v4(110.57,17.97)
  IN3 w0.064: v4(40.87,22.72) 41.05,22.54 41.05,19.81 40.68,19.45 40.68,17.9 40.61,17.83 v4(40.61,17.49) ; v5(108.69,18.28) 110.26,18.28 v4(110.57,17.97)
  BOTTOM w0.081: JSSD1.8 v5(108.69,18.28)
STRAP0: length 6.1
  TOP w0.081: v6(105.37,74.32) 105.12,74.32 104.62,73.83 RV384.2 RV383.1
  BOTTOM w0.081: UV1.D1 104.75,72.04 104.75,73.95 105.12,74.32 v6(105.37,74.32)
STRAP1: length 6.2
  TOP w0.081: RV390.1 RV51.2 104.58,75.07 v6(104.59,75.06)
  BOTTOM w0.081: UV1.D2 103.59,71.44 104.47,72.32 104.47,74.69 104.59,74.81 v6(104.59,75.06)
STRAP2: length 9.1
  TOP w0.081: RV388.1 RV382.2 99.79,75.74 v6(100.23,75.3)
  BOTTOM w0.081: v6(100.23,75.3) 100.29,75.3 100.94,74.65 100.94,71.83 103.06,69.71 UV1.E4
STRAP3: length 7.4
  BOTTOM w0.081: UV1.E3 103.63,70.39 105.09,71.85 105.09,73.27 RV387.1 RV389.2 106.22,73.73 v1(107.37,72.58)
STRAP4: length 7.4
  BOTTOM w0.081: UV1.D3 103.03,70.86 102.07,71.82 102.07,72.18 102.32,72.43 102.32,75.11 RV385.1 RV61.2
STRAP5: length 4.6
  BOTTOM w0.081: RV398.2 RV399.1 103.85,75.2 103.85,74.25 104.16,73.94 104.16,72.58 UV1.C1
STRAPREF0: length 1.2
  TOP w0.081: RV44.1 102.87,66.77 v6(102.46,66.77)
  BOTTOM w0.081: UV1.F6 v6(102.46,66.77)
SUSCLK: length 145.8
  TOP w0.081: RC79.1 146.56,55.68 v2(146.23,55.36)
  IN1 w0.064: v4(110.97,32.67) 110.97,32.21 110.59,31.82 110.59,31.47 110.58,31.47 110.58,31.26 109.52,30.2 109.52,28.96 110.13,28.36 110.13,23.96 109.08,22.91 108.07,22.91 108.07,22.91 107.38,22.91 104.31,19.84 98.35,19.84 96.54,18.03 92.64,18.03 90.32,15.71 88.2,15.71 86.82,14.33 84.94,14.33 84.92,14.31 84.4,14.31 84.27,14.45 82.76,14.45 82.6,14.61 78.92,14.61 78.11,15.42 68.32,15.42 67.87,15.87 66.96,15.87 65.55,17.28 63.65,17.28 62.19,18.74 54.91,18.74 54.41,19.24 52.2,19.24 51.97,19.01 51.22,19.01 50.63,19.6 50.32,19.6 50.08,19.83 50.08,20.05 49.68,20.45 48.52,20.45 48.24,20.73 46.85,20.73 46.66,20.92 45.27,20.92 44.03,19.67 44.03,19.5 43.13,18.61 43.03,18.61 42.68,18.26 41.89,18.26 41.65,18.01 40.95,18.01 40.7,18.26 39.66,18.26 v4(39.56,18.37) ; v2(146.23,55.36) 146.14,55.27 v4(145.66,55.27) ; v4(38.32,21.6) 38.39,21.67 38.63,21.67 v2(38.8,21.5)
  IN3 w0.064: v4(38.32,21.6) 38.32,19.6 v4(39.56,18.37) ; v4(110.97,32.67) 111.04,32.73 111.04,34.03 110.86,34.2 110.86,35.96 111.87,36.97 112.43,36.97 114.21,38.75 114.21,39.69 114.51,39.99 115.11,39.99 115.12,39.98 115.54,39.98 116.73,41.17 116.73,43.21 117.96,44.45 119.39,44.45 119.43,44.49 120.79,44.49 121.02,44.26 122.48,44.26 123.84,45.62 131.17,45.62 131.81,46.26 133.67,46.26 134.07,46.66 135.87,46.66 135.9,46.62 136.33,46.62 136.64,46.32 139.34,46.32 140.08,47.05 140.08,47.98 140.24,48.14 140.24,49.99 141.39,51.14 142.72,51.14 143.58,52 143.58,52.18 143.94,52.54 143.94,53.41 144.04,53.51 144.04,53.93 144.47,54.35 145.4,54.35 145.63,54.58 145.63,55.25 v4(145.66,55.27) 145.96,55.27 v5(146.01,55.32)
SUSCLK_WLAN: length 21.4
  TOP w0.081: v2(146.56,56.97) 146.56,56.16 RC79.2
  IN1 w0.064: v4(132.6,65.65) 136.63,65.65 139.31,62.97 140.56,62.97 143.79,59.74 143.79,59.32 144.49,58.62 144.6,58.62 144.77,58.46 144.77,58.11 145.71,57.17 146.36,57.17 v2(146.56,56.97)
  IN3 w0.064: v5(131.8,65.75) 131.8,65.75 132.5,65.75 v4(132.6,65.65)
  BOTTOM w0.081: WL1.27 133.55,65.75 132.3,65.75 132.29,65.75 v5(131.8,65.75)
SUSCLK_WWAN: length 3.1
  TOP w0.081: v2(48.9,49.37) 48.88,49.37 48.73,49.52 48.73,50.18 48.44,50.47 RN193.2
  IN1 w0.064: v2(48.9,49.37) 48.9,49.36 48.93,49.32 48.93,48.87 v4(48.96,48.84)
  IN3 w0.064: v4(48.96,48.84) 48.75,48.84 48.51,49.08 v5(48.51,49.53)
SW_USB20_1_N3: length 6.5
  TOP w0.091: UM4.2 17.92,70.67 17.82,70.57 v7(17.82,69.83) 17.82,67.75 17.84,67.74 17.84,67.19 17.82,67.18 17.82,65.75 17.61,65.54 RU6.1
SW_USB20_1_N3_R: length 8.9
  TOP w0.091: RU6.2 16.02,65.79 15.15,65.79 15,65.64 DT40.1 DT40.9 12.85,65.64 12.84,65.63 12.23,65.63 12.22,65.64 11.55,65.64 11.07,66.12 11.07,66.44 11.2,66.57 v6(11.2,66.85)
  BOTTOM w0.091: JUSBC1.A7 9.7,66.38 9.85,66.22 11.01,66.22 11.34,66.54 11.34,66.72 v6(11.2,66.85)
SW_USB20_1_P3: length 6.5
  TOP w0.091: UM4.1 17.52,70.68 17.62,70.59 17.62,70.11 17.61,70.1 17.61,69.55 17.62,69.54 v7(17.62,67.46) 17.62,65.84 17.53,65.75 17.32,65.75 17.23,65.84 17.23,66.12 17.12,66.23 RU5.1
SW_USB20_1_P3_R: length 8.8
  TOP w0.091: v6(11.75,66.35) 11.57,66.53 11.45,66.53 11.28,66.36 11.28,66.21 11.64,65.85 v7(12.53,65.85) 13.36,65.85 13.65,66.14 DT40.8 DT40.2 14.98,66.14 15.12,65.99 16.04,65.99 RU5.2
  BOTTOM w0.091: JUSBC1.A6 9.67,65.88 9.81,66.02 11.1,66.02 11.43,66.35 v6(11.75,66.35)
SW_USB20_2_N3: length 8.9
  TOP w0.091: RU8.1 17.79,63.56 v7(18.31,64.08) 18.72,64.49 18.72,68.32 18.74,68.33 18.74,68.88 18.72,68.89 UM4.4
SW_USB20_2_N3_R: length 9.9
  TOP w0.091: RU8.2 16.13,63.69 16.13,63.73 16.13,63.73 15.15,63.73 14.98,63.57 DT39.4 DT39.7 13.66,63.57 13.5,63.72 12.57,63.72 12.07,64.22 12.07,64.24 10.51,65.8 8.75,65.8 v6(8.55,65.6)
  BOTTOM w0.091: JUSBC1.B7 7.99,65.62 8.14,65.78 8.33,65.78 8.51,65.6 v6(8.55,65.6)
SW_USB20_2_P3: length 8.9
  TOP w0.091: LU4.2 17.19,64.07 17.28,63.97 17.28,63.85 17.38,63.76 17.71,63.76 17.97,64.02 17.97,64.04 18.35,64.42 18.37,64.42 18.52,64.57 v7(18.52,68.61) 18.52,70.51 18.32,70.7 UM4.3
SW_USB20_2_P3_R: length 9.8
  TOP w0.091: v6(8.55,66.18) 8.73,66 10.59,66 v7(12.41,64.18) 12.67,63.92 13.51,63.92 13.65,64.07 DT39.6 DT39.5 15.02,64.07 15.15,63.94 16.13,63.94 LU4.1
  BOTTOM w0.091: v6(8.55,66.18) 8.35,65.98 8.13,65.98 7.99,66.13 JUSBC1.B6
SX9310_CS0: length 1
  TOP w0.081: RS9.2 71.8,75.17 U16.A3
SX9310_CS1: length 1.3
  TOP w0.081: U16.B4 72.72,73.76 TP78.1
SYNC: length 98.2
  IN1 w0.203: v4(159.22,21.72) 159.98,21.72 162.71,19 164.01,19 165.04,17.96 165.04,16.88 166.03,15.9 166.57,15.9 169.78,12.69 169.78,12.46 v4(169.85,12.39)
  IN2 w0.203: v4(159.22,21.72) 159.2,21.72 158.73,21.24 156.01,21.24 153.87,19.1 148.48,19.1 147.88,19.7 145.37,19.7 144.96,19.29 v4(144.96,18.98)
  IN3 w0.203: 177.6,9.15 177.28,8.83 171.05,8.83 169.85,10.03 v4(169.85,12.39) 169.85,12.39 169.75,12.39 169.71,12.34 169.47,12.34 169.01,11.88 v5(167.14,11.88) ; 177.6,9.15 176.74,10 176.74,10.64 175.62,11.75 175.62,11.85 v5(175.59,11.88) ; 177.6,9.15 178.2,8.54 181.1,8.54 182.62,10.06 182.62,11.59 182.91,11.88 v5(183.38,11.88) 183.58,11.88 184.05,12.35 184.05,12.69 189.04,17.68 190.5,17.68 191,18.17 191,22.66 191.76,23.43 192.34,23.43 193.09,24.17 193.09,25.87 195.83,28.61 196.26,28.61 198.05,30.4 198.69,30.4 199.45,31.16 200.64,31.16 202.53,33.05 v5(202.53,35.87) ; v5(159.22,21.26) 159.22,21.72 v4(159.22,21.72) ; v4(144.96,18.98) 144.96,18.88 144.6,18.52 142.48,18.52 142.26,18.74 141.49,18.74 v5(141.31,18.57)
  BOTTOM w0.203: PUG01.10 202.34,36.06 v5(202.53,35.87) ; PUA01.10 141.43,18.69 v5(141.31,18.57) ; PUI01.10 v5(167.14,11.88)
SYS_PWROK: length 157.4
  TOP w0.081: v2(130.88,11.72) 131.01,11.86 131.01,13.38 131.8,14.17 132.27,14.17 133.85,15.75 133.85,18.23 133.18,18.89 v3(132.23,18.89) 131.86,18.89 131.8,18.82 130.66,18.82 130.58,18.9 130.58,22.43 130,23.01 130,25.86 132.3,28.15 132.3,31.9 130.04,34.16 130.04,34.54 130.71,35.21 131.66,35.21 132.58,34.29 v2(132.58,34.25)
  IN1 w0.064: v2(130.88,11.72) 130.88,6.64 130.43,6.19 124.16,6.19 123.41,6.94 120.37,6.94 119.75,6.33 119.75,4.95 119.23,4.42 115.21,4.42 114.31,3.52 106.71,3.52 106.6,3.62 106.6,3.62 106.36,3.86 103.45,3.86 103.45,3.86 102.71,3.86 102.05,3.2 50.83,3.2 49.14,4.89 40.36,4.89 37.94,7.31 v4(37.78,7.31) ; v2(40.98,15.43) 42.02,15.43 42.3,15.15 42.3,14.54 v4(42.34,14.5) ; v2(132.58,34.25) 133.15,34.83 v4(134.01,34.83)
  IN2 w0.066: v4(132.99,39.21) 133.57,38.63 133.57,36.16 134.01,35.71 v4(134.01,34.83)
  IN3 w0.064: v4(37.78,7.31) 37.65,7.31 37.24,7.72 37.24,8.59 37.73,9.08 37.73,10.85 39.66,12.78 40,12.78 41.56,14.33 41.99,14.33 42.16,14.5 v4(42.34,14.5) ; v5(134.55,40.94) 134.55,40.39 133.38,39.21 v4(132.99,39.21)
  BOTTOM w0.089: UC1.CR10 134.64,41.02 v5(134.55,40.94)
SYS_RESET#: length 67.8
  TOP w0.081: v2(135.24,37.89) 135.24,39.14 v1(135.96,39.86) 136.61,40.52 136.61,41.26 136.74,41.39 v2(136.74,41.52) 136.77,41.52 136.82,41.46 136.94,41.46 136.96,41.44 CC75.2 137.27,41.54 136.94,41.87 RC100.2 ; v2(130.95,37.4) 130.8,37.56 130.8,40.93 129.01,42.73 129.01,44.2 127.47,45.74 v2(127.47,47.46)
  IN1 w0.064: v4(136.33,41.5) 136.39,41.5 136.42,41.52 v2(136.74,41.52) ; v2(130.95,37.4) 131.08,37.28 134.18,37.28 134.8,37.89 v2(135.24,37.89) ; v2(127.47,47.46) 126.16,47.46 124.31,49.32 124.31,49.51 123.08,50.73 122.7,50.73 122.54,50.89 122.54,50.91 121.56,51.88 121.56,51.94 121.3,52.2 118.29,55.21 118.29,55.88 117.55,56.62 117.55,59.06 117.59,59.1 117.59,59.11 117.69,59.22 117.69,62.15 117.06,62.78 117.06,63.43 117.44,63.81 117.44,66.7 117.12,67.01 117.12,67.02 117.06,67.08 117.06,68.94 115.18,70.82 115.18,72.15 116.12,73.09 119.04,73.09 119.98,72.15 125.65,72.15 126.77,73.27 127.5,73.27 v2(127.95,72.83)
  IN3 w0.064: v4(136.33,41.5) 136.31,41.48 136.1,41.48 v5(135.96,41.34)
SYSPWR_PRES: length 7.7
  TOP w0.081: UE1.B68 41.52,20.8 41.52,19.82 40.19,18.49 RE32.1 40.19,18.19 39.7,17.69 39.12,17.69 RE30.2 39.13,17.97 39.13,18.53 RE546.2 38.82,18.52 38.82,18.37 38.68,18.23 v1(37.3,18.23)
T_CRIT#: length 198.5
  TOP w0.081: v2(115.15,45.05) 115.04,45.16 114.75,45.16 114.51,45.4 114.51,45.71 115.04,46.23 115.04,46.45 DV12.1 ; v2(133.21,37.74) 133.12,37.84 133.12,41.34 131.01,43.45 131.01,46.3 130.6,46.7 130.51,46.7 v2(130.01,47.2) 130.01,49.11 131.11,50.21 R55.2 131.69,49.92 131.83,49.77 U3.4 ; v6(44.54,4.15) 44.82,4.43 44.82,5.97 44.19,6.6 43.04,6.6 42.93,6.7 42.93,7.36 43.48,7.9 45.48,7.9 PR524.1
  IN1 w0.064: v2(133.21,37.74) 130.65,37.74 129.82,38.57 126.98,38.57 126.71,38.3 123.23,38.3 121.56,39.97 120.46,39.97 117.76,42.67 117.66,42.67 115.37,44.95 115.25,44.95 v2(115.15,45.05) 115.07,44.97 115.07,44.75 116.53,43.29 116.53,42.75 116.53,42.75 116.53,42.18 116.53,42.18 116.53,42.08 118.54,40.08 118.54,37.04 118.28,36.78 118.28,36.78 117.98,36.49 116.14,36.49 116.09,36.54 115.25,36.54 114.38,35.67 114.38,34.27 115.02,33.63 115.02,32.2 115.1,32.13 115.1,28.81 114.9,28.6 114.9,24.97 113.94,24.01 113.94,20.87 113.32,20.25 108.6,20.25 107.66,19.31 107.66,18.29 105.11,15.75 98.96,15.75 98.6,15.39 93.73,15.39 92.81,14.46 92.81,13.22 90.76,11.17 86.46,11.17 v4(86.1,11.52) ; v2(130.01,47.2) 129.87,47.33 127.75,47.33 127.35,46.93 126.06,46.93 123.86,49.14 123.86,49.25 122.83,50.29 122.52,50.29 122.09,50.71 122.09,50.73 121.12,51.7 121.12,51.75 120.39,52.48 120.1,52.48 119.75,52.13 118.66,52.13 117.11,53.68 117.11,59.25 117.14,59.29 117.14,59.3 117.25,59.4 117.25,61.32 116.17,62.4 116.17,63.98 116.48,64.3 116.48,66.19 116.1,66.58 116.1,67.99 114.13,69.96 114.13,71.88 113.76,72.25 v6(112.82,72.25)
  IN3 w0.064: v5(85.07,11.94) 85.39,11.94 85.61,11.72 85.9,11.72 v4(86.1,11.52)
  BOTTOM w0.081: v6(44.54,4.15) 45.48,5.09 46.02,5.09 46.53,5.61 53.19,5.61 v1(53.3,5.49) 55.02,3.77 80.08,3.77 84.86,8.56 84.86,11.73 v5(85.07,11.94) ; QV147.3 v6(112.82,72.25)
T_CRIT#_D: length 6.7
  TOP w0.081: QV150.3 112.13,47.13 112.41,47.13 113.34,48.07 114.25,48.07 DV12.2 114.75,48.57 115.2,48.57 DV11.1 114.94,49.46 RV4996.2 114.41,49.8 114.74,50.13 v1(114.74,50.24)
TABLE_MODE#: length 137.2
  IN1 w0.064: v2(46.73,30.38) 46.73,29.84 46.51,29.62 46.51,28.07 48.01,26.57 48.72,26.57 48.97,26.32 51.35,26.32 51.95,25.72 52.22,25.72 52.4,25.89 52.4,26.12 52.62,26.34 53.16,26.34 53.8,26.99 55.95,26.99 56.07,27.11 56.08,27.11 59.54,30.57 69.8,30.57 70,30.76 75.95,30.76 79.39,27.32 79.39,25.44 79.97,24.86 80.33,24.86 80.36,24.85 82.77,22.44 86.19,22.44 91.61,27.86 98.92,27.86 102.58,31.52 102.58,33.06 103.45,33.93 103.45,34.32 v4(103.46,34.32)
  IN2 w0.066: v4(103.46,34.32) 103.46,34.75 103.61,34.91 103.61,34.91 103.83,35.13 103.83,35.13 103.95,35.25 103.95,40.54 110.22,46.81 110.22,48.38 120.5,58.65 120.5,62.31 122.71,64.52 127.89,64.52 129.2,63.2 129.2,61.7 129.56,61.34 131.69,61.34 131.82,61.47 132.32,61.47 132.48,61.31 133.63,61.31 134.43,62.1 136.05,62.1 v4(136.33,61.83)
  IN3 w0.064: v4(136.33,61.83) 136.32,61.82 136.32,61.36 v5(136.33,61.36)
  BOTTOM w0.081: UC1.CA35 142.5,57.08 142.18,57.4 142.18,58.18 141.67,58.69 140.65,58.69 140.34,59.01 140.34,59.36 139.76,59.94 138.91,59.94 138.58,60.27 137.49,60.27 137.34,60.42 137.34,60.83 137.2,60.97 137.2,61.19 137.04,61.36 RC213.1 v5(136.33,61.36)
TACH_FAN1: length 236.7
  TOP w0.081: v2(42.79,28.19) 42.79,28.17 42.43,27.81 42.43,27.19 42.25,27.01 41.97,27.01 41.78,27.2 41.78,27.34 41.7,27.43 UE1.B55 ; v2(40.94,29.72) 40.94,29.84 40.61,30.18 39.59,30.18 RE16.1
  IN1 w0.064: v4(43.01,13.81) 43.1,13.89 43.19,13.89 43.96,13.12 49.68,13.12 49.99,13.42 53.32,13.42 54.66,14.76 55.75,14.76 56.49,15.5 58.52,15.5 58.94,15.08 59.4,15.08 59.65,14.83 59.65,12.81 60.54,11.91 60.54,11.46 62.06,9.93 70.99,9.93 71.7,9.22 75.57,9.22 75.87,9.52 82.23,9.52 83.16,8.58 89.01,8.58 89.87,7.73 94.33,7.73 95.62,9.02 95.62,9.86 96.2,10.44 104.67,10.44 105.99,9.12 107.88,9.12 108.02,9.25 108.14,9.25 108.92,10.03 108.92,10.03 109.55,10.66 109.55,12.4 110.33,13.17 115.83,13.17 116.42,13.76 117.21,13.76 120.08,16.64 123.36,16.64 125.17,18.45 139.03,18.45 139.27,18.45 139.4,18.58 140.68,18.58 141.19,18.07 146.18,18.07 148.12,16.14 148.66,16.14 148.66,16.14 149.42,16.14 150.11,15.45 150.11,15.32 153.37,12.07 159.68,12.07 163.85,7.9 170.57,7.9 171.16,7.31 180.58,7.31 181.7,8.43 188.94,8.43 189.49,7.89 189.49,7.23 189.48,7.23 189.48,7.07 189.92,6.64 205.33,6.64 206.02,7.33 206.02,9.92 206.02,14.69 203.73,16.98 198.71,16.98 197.48,15.75 v2(195.49,15.75) ; v2(40.94,29.72) 41.05,29.72 41.33,29.45 41.33,29.18 41.89,28.62 42.35,28.62 42.78,28.19 v2(42.79,28.19) 42.79,28.01 44.64,26.17 44.64,24.4 41.9,21.66 41.9,20.87 41.48,20.45 40.99,20.45 39.92,19.38 39.03,19.38 38.24,18.59 38.24,17.14 37.73,16.64 37.73,15.27 38.88,14.12 38.88,12.21 v4(40.24,10.84)
  IN3 w0.064: v4(40.24,10.84) 41.46,12.06 41.85,12.06 42.69,12.9 42.69,13.55 42.95,13.81 v4(43.01,13.81)
TBT_A_SBU1: length 29.7
  TOP w0.091: v2(12.56,62.52) 12.7,62.39 13.35,62.39 13.53,62.57 DT39.8 DT39.2 15.07,62.57 15.24,62.4 15.44,62.4 v2(15.54,62.49)
  IN1 w0.079: v6(10.16,66.84) 10.16,66.34 9.71,65.88 9.71,65.21 9.5,65 9.5,63.15 10.63,62.02 11.8,62.02 12.16,62.37 12.33,62.37 12.41,62.37 v2(12.56,62.52) ; v2(15.54,62.49) 15.63,62.41 arc(15.65,62.39) 15.68,62.39 15.74,62.39 arc(15.77,62.39) 15.79,62.41 15.8,62.41 16.08,62.69 arc(16.2,62.77) 16.34,62.8 21.72,62.8 arc(21.82,62.78) 21.92,62.72 23.07,61.56 arc(23.14,61.52) 23.21,61.51 28.12,61.51 arc(28.23,61.49) 28.32,61.43 28.64,61.1 arc(28.7,61.01) 28.72,60.9 28.72,60.58 arc(28.73,60.55) 28.75,60.52 29.39,59.88 arc(29.46,59.77) 29.49,59.64 29.49,58.56 arc(29.5,58.53) 29.51,58.5 29.64,58.37 29.71,58.37 v6(29.92,58.57)
  BOTTOM w0.091: JUSBC1.A8 10.11,66.88 10.15,66.84 v6(10.16,66.84) ; UT1.H4 v6(29.92,58.57)
TBT_A_SBU2: length 28.6
  TOP w0.091: v2(15.54,62.11) 15.46,62.19 15.22,62.19 15.09,62.07 DT39.1 DT39.9 13.54,62.07 13.42,62.19 12.75,62.19 v2(12.61,62.04)
  IN1 w0.079: v2(12.61,62.04) 12.47,62.17 12.24,62.17 11.89,61.82 11.72,61.82 10.54,61.82 9.3,63.06 9.3,63.23 9.3,64.92 9.22,64.99 v6(8.43,64.99) ; v6(29.93,57.94) 29.72,58.15 arc(29.69,58.16) 29.67,58.17 29.56,58.17 29.5,58.23 29.5,58.23 29.37,58.36 arc(29.31,58.45) 29.29,58.56 29.29,59.64 arc(29.28,59.69) 29.24,59.74 28.6,60.38 arc(28.54,60.47) 28.52,60.58 28.52,60.9 arc(28.52,60.93) 28.5,60.96 28.17,61.28 arc(28.15,61.3) 28.12,61.31 23.24,61.31 23.22,61.31 arc(23.06,61.33) 22.93,61.42 21.77,62.58 arc(21.75,62.59) 21.72,62.6 16.34,62.6 arc(16.28,62.59) 16.22,62.55 15.94,62.27 arc(15.85,62.21) 15.74,62.19 15.64,62.19 arc(15.62,62.18) 15.59,62.16 v2(15.54,62.11)
  BOTTOM w0.091: v6(29.93,57.94) 30.19,57.68 30.19,57.65 UT1.J4 ; JUSBC1.B8 8.29,65.13 v6(8.43,64.99)
TBT_A_TRX_DTX_N1: length 18.2
  IN3 w0.079: v5(8.51,64.07) arc(8.65,63.98) 8.81,63.94 10.88,63.94 arc(11,63.93) 11.11,63.89 arc(11.14,63.87) 11.17,63.85 arc(11.21,63.82) 11.24,63.79 11.95,63.08 arc(12.03,63.03) 12.12,63.01 12.18,63.01 arc(12.29,63.03) v5(12.39,63.1)
  BOTTOM w0.091: UT1.A21 22.29,61.36 arc(22.36,61.39) 22.39,61.45 22.39,61.73 arc(22.38,61.76) 22.36,61.8 22.24,61.91 arc(22.19,61.99) 22.18,62.08 22.18,62.16 arc(22.15,62.36) 22.08,62.54 arc(22.02,62.63) 21.95,62.71 21.34,63.31 21.35,63.31 arc(21.09,63.48) 20.8,63.54 17.43,63.54 arc(17.39,63.55) 17.35,63.57 16.49,64.43 arc(16.39,64.5) 16.28,64.52 14.4,64.52 arc(14.26,64.49) 14.15,64.42 13.78,64.04 arc(13.7,63.93) 13.68,63.8 13.68,63.5 arc(13.66,63.39) 13.59,63.3 13.34,63.05 arc(13.29,63.01) 13.23,63 13.14,63 arc(13.11,63.01) 13.08,63.03 DT14.1 12.76,63.03 arc(12.73,63.01) 12.69,63.01 12.52,63.01 arc(12.48,63.01) 12.45,63.03 v5(12.39,63.1) ; v5(8.51,64.07) 8.45,64 arc(8.42,63.98) 8.39,63.98 8.19,63.98 arc(8.15,63.98) 8.12,64 8.03,64.1 arc(8,64.12) 7.96,64.13 JUSBC1.B10
TBT_A_TRX_DTX_N2: length 21.5
  IN3 w0.079: v5(25.04,62.73) 24.99,62.78 24.99,62.85 arc(25,62.88) 25.02,62.91 25.07,62.97 arc(25.1,62.99) 25.13,62.99 25.23,62.99 arc(25.26,63) 25.28,63.02 25.31,63.04 arc(25.33,63.08) 25.34,63.12 arc(25.32,63.18) 25.3,63.23 arc(25.28,63.27) 25.25,63.3 arc(25.17,63.39) 25.08,63.48 20.27,68.29 20.27,68.29 arc(20.26,68.3) 20.25,68.3 arc(19.72,68.65) 19.1,68.78 arc(19.09,68.78) 19.09,68.78 13.88,68.78 arc(13.65,68.73) v5(13.45,68.6)
  BOTTOM w0.091: v5(13.45,68.6) 13.44,68.61 arc(13.37,68.66) 13.28,68.67 13.17,68.67 arc(13.08,68.66) 13.01,68.61 DT9.1 arc(12.7,68.66) 12.45,68.7 12.06,68.7 arc(11.81,68.65) 11.59,68.51 11.32,68.24 arc(11.08,68.08) 10.8,68.02 10.01,68.02 arc(9.94,68.01) 9.87,67.96 9.83,67.92 arc(9.78,67.89) 9.71,67.88 JUSBC1.A10 ; v5(25.04,62.73) 25.07,62.7 arc(25.13,62.61) 25.17,62.5 arc(25.17,62.48) 25.17,62.46 25.17,62.45 arc(25.16,62.42) 25.15,62.39 25.06,62.3 arc(24.95,62.15) 24.92,61.97 24.92,61.79 arc(24.91,61.73) 24.88,61.67 arc(24.87,61.66) 24.86,61.65 24.81,61.6 arc(24.76,61.53) 24.74,61.44 24.74,61.24 arc(24.77,61.13) 24.83,61.03 UT1.B15
TBT_A_TRX_DTX_P1: length 18.2
  IN3 w0.079: v5(12.39,62.71) arc(12.29,62.78) 12.17,62.81 12.12,62.81 arc(11.96,62.84) 11.82,62.93 11.1,63.65 arc(11.08,63.66) 11.06,63.68 arc(11.06,63.68) 11.05,63.68 arc(11.03,63.7) 11.01,63.71 arc(10.95,63.74) 10.88,63.74 8.65,63.74 arc(8.58,63.73) v5(8.51,63.69)
  BOTTOM w0.091: v5(12.39,62.71) 12.45,62.78 arc(12.48,62.8) 12.52,62.8 12.68,62.8 arc(12.72,62.8) 12.75,62.78 DT13.1 13.08,62.77 arc(13.11,62.79) 13.14,62.8 13.23,62.8 arc(13.37,62.83) 13.49,62.9 13.74,63.15 arc(13.84,63.31) 13.88,63.5 13.88,63.8 arc(13.89,63.85) 13.92,63.9 14.3,64.27 arc(14.34,64.3) 14.4,64.31 16.28,64.31 arc(16.31,64.31) 16.34,64.29 17.2,63.43 arc(17.31,63.36) 17.43,63.33 20.8,63.33 arc(21.01,63.29) 21.2,63.17 21.8,62.57 arc(21.85,62.51) 21.9,62.44 21.9,62.44 arc(21.95,62.31) 21.97,62.16 21.97,61.35 arc(22.01,61.15) 22.12,60.98 UT1.B21 ; JUSBC1.B11 7.97,63.62 arc(8.01,63.63) 8.04,63.65 8.13,63.75 arc(8.16,63.77) 8.2,63.77 8.39,63.77 arc(8.42,63.77) 8.45,63.75 v5(8.51,63.69)
TBT_A_TRX_DTX_P2: length 21.5
  IN3 w0.079: v5(13.45,68.98) 19.09,68.98 arc(19.09,68.98) 19.1,68.98 arc(19.1,68.98) 19.1,68.98 arc(19.8,68.84) 20.4,68.45 20.4,68.45 25.22,63.62 arc(25.31,63.53) 25.4,63.43 arc(25.44,63.38) 25.48,63.33 arc(25.51,63.24) 25.54,63.16 arc(25.54,63.11) 25.55,63.06 v5(25.55,62.73)
  BOTTOM w0.091: v5(13.45,68.98) 13.44,68.97 arc(13.39,68.94) 13.32,68.92 13.16,68.92 arc(13.09,68.94) 13.04,68.97 DT10.1 arc(12.7,68.96) 12.46,68.91 12.06,68.91 arc(11.73,68.84) 11.45,68.65 11.17,68.38 arc(11,68.27) 10.8,68.23 10,68.23 arc(9.94,68.24) 9.89,68.27 9.86,68.3 arc(9.78,68.36) 9.68,68.38 JUSBC1.A11 ; v5(25.55,62.73) 25.41,62.6 arc(25.4,62.58) 25.39,62.56 25.38,62.53 25.38,62.44 arc(25.36,62.35) 25.31,62.27 25.2,62.16 arc(25.14,62.07) 25.12,61.97 25.12,61.66 arc(25.13,61.61) 25.16,61.57 25.17,61.56 arc(25.2,61.52) 25.21,61.46 25.21,61.29 arc(25.08,61.16) 24.96,61.29 24.96,61.35 UT1.A15
TBT_A_TTX_C_DRX_N1: length 7.7
  BOTTOM w0.091: JUSBC1.A3 9.7,64.38 arc(9.74,64.37) 9.77,64.35 9.86,64.25 arc(9.89,64.23) 9.93,64.23 10.75,64.23 arc(11,64.27) 11.2,64.41 11.55,64.76 arc(11.79,64.92) 12.07,64.98 12.67,64.98 arc(12.67,64.98) 12.67,64.98 arc(12.74,65) 12.8,65.05 DT6.1 13.07,65.01 arc(13.13,64.96) 13.21,64.95 13.47,64.95 arc(13.5,64.95) 13.53,64.97 14.15,65.59 arc(14.24,65.65) 14.36,65.67 15.92,65.67 arc(16.01,65.69) 16.08,65.74 CT98.2
TBT_A_TTX_C_DRX_N2: length 13.4
  IN3 w0.079: v5(8.46,67.68) arc(8.57,67.76) 8.7,67.78 8.94,67.78 arc(9.19,67.83) 9.4,67.97 arc(9.45,68.01) 9.52,68.02 11.31,68.02 arc(11.44,68) 11.56,67.92 arc(11.65,67.78) 11.68,67.62 11.68,67.13 arc(11.71,67) 11.78,66.89 11.81,66.86 arc(11.94,66.77) 12.1,66.74 12.11,66.74 arc(12.23,66.72) v5(12.33,66.65)
  BOTTOM w0.091: JUSBC1.B3 7.91,67.62 arc(7.98,67.64) 8.03,67.67 8.1,67.75 arc(8.13,67.77) 8.16,67.77 8.34,67.77 arc(8.37,67.77) 8.39,67.75 v5(8.46,67.68) ; CT96.2 19.09,65.48 arc(19.06,65.5) 19.02,65.5 18.89,65.5 arc(18.68,65.55) 18.5,65.67 17.88,66.29 arc(17.69,66.41) 17.48,66.45 14.2,66.45 arc(14.02,66.49) 13.87,66.59 13.78,66.68 arc(13.7,66.73) 13.61,66.75 13.21,66.75 arc(13.2,66.75) 13.19,66.75 arc(13.13,66.74) 13.08,66.71 DT18.1 12.8,66.66 arc(12.72,66.72) 12.62,66.74 12.48,66.74 arc(12.42,66.72) 12.38,66.69 v5(12.33,66.65)
TBT_A_TTX_C_DRX_P1: length 7.7
  BOTTOM w0.091: JUSBC1.A2 9.69,63.88 arc(9.72,63.88) 9.75,63.9 9.85,64 arc(9.88,64.02) 9.91,64.02 10.75,64.02 arc(11.07,64.09) 11.35,64.27 11.69,64.61 arc(11.87,64.73) 12.07,64.77 12.67,64.77 arc(12.71,64.76) 12.75,64.74 DT5.1 13.05,64.72 arc(13.08,64.74) 13.12,64.74 13.47,64.74 arc(13.58,64.77) 13.68,64.83 14.29,65.44 arc(14.32,65.46) 14.36,65.47 15.98,65.47 arc(16.01,65.46) 16.04,65.44 CT97.2
TBT_A_TTX_C_DRX_P2: length 13.3
  IN3 w0.079: v5(12.33,67.03) arc(12.24,66.97) 12.12,66.94 12.1,66.94 arc(12.02,66.96) 11.95,67.01 11.93,67.03 arc(11.9,67.08) 11.88,67.13 11.88,67.62 arc(11.84,67.86) 11.7,68.06 arc(11.52,68.18) 11.31,68.22 9.52,68.22 arc(9.38,68.2) 9.26,68.11 arc(9.11,68.02) 8.94,67.98 8.65,67.98 arc(8.55,68) v5(8.46,68.06)
  BOTTOM w0.091: v5(12.33,67.03) 12.39,66.97 arc(12.43,66.95) 12.47,66.94 12.65,66.94 arc(12.72,66.95) 12.78,66.99 DT17.1 13,67.05 arc(13.1,66.98) 13.21,66.96 13.61,66.96 arc(13.78,66.92) 13.93,66.82 14.02,66.73 arc(14.1,66.68) 14.2,66.66 17.48,66.66 arc(17.77,66.6) 18.02,66.43 18.64,65.81 arc(18.76,65.73) 18.89,65.71 18.93,65.71 arc(19.03,65.73) 19.12,65.78 CT95.2 ; v5(8.46,68.06) 8.39,68 arc(8.37,67.98) 8.34,67.97 8.19,67.97 arc(8.14,67.98) 8.11,68.01 8.03,68.09 arc(7.98,68.12) 7.93,68.13 JUSBC1.B2
TBT_A_TTX_DRX_N1: length 10.6
  IN3 w0.079: v5(23.4,62.04) arc(23.34,62.13) 23.32,62.24 23.32,62.29 23.32,62.35 23.31,62.36 23.31,62.37 arc(23.25,62.69) 23.07,62.96 22.73,63.3 arc(22.55,63.42) 22.34,63.46 18.59,63.46 arc(18.42,63.5) 18.28,63.59 17.82,64.05 arc(17.74,64.17) 17.71,64.31 17.71,64.31 17.71,64.56 arc(17.74,64.7) v5(17.82,64.82)
  BOTTOM w0.091: CT98.1 17.32,65.85 arc(17.43,65.83) 17.52,65.77 17.71,65.58 arc(17.79,65.46) 17.82,65.33 v5(17.82,64.82) ; v5(23.4,62.04) 23.4,61.82 23.36,61.57 23.36,61.28 arc(23.32,61.09) 23.21,60.93 23.18,60.9 UT1.B19
TBT_A_TTX_DRX_N2: length 7.3
  BOTTOM w0.091: CT96.1 19.96,65.48 arc(19.99,65.5) 20.03,65.51 20.41,65.51 20.41,65.51 20.78,65.51 arc(21.11,65.44) 21.38,65.26 23.87,62.77 arc(24.03,62.54) 24.08,62.26 24.08,61.82 arc(24.06,61.77) 24.03,61.73 23.89,61.59 arc(23.84,61.52) 23.83,61.43 23.83,61.26 arc(23.85,61.13) 23.93,61.02 UT1.B17
TBT_A_TTX_DRX_P1: length 10.6
  IN3 w0.079: v5(17.44,64.82) arc(17.49,64.74) 17.51,64.64 17.51,64.33 arc(17.51,64.32) 17.51,64.31 arc(17.55,64.09) 17.68,63.91 18.14,63.45 arc(18.34,63.31) 18.59,63.26 22.34,63.26 arc(22.47,63.24) 22.59,63.16 22.93,62.82 arc(23.07,62.61) 23.11,62.37 23.11,62.26 arc(23.09,62.14) v5(23.02,62.04)
  BOTTOM w0.091: UT1.A19 23.04,61.28 arc(23.02,61.26) 22.99,61.26 22.96,61.26 arc(22.94,61.26) 22.91,61.28 arc(22.89,61.31) 22.88,61.35 22.88,61.49 arc(22.89,61.56) 22.93,61.61 22.96,61.64 arc(22.99,61.66) 23.02,61.66 23.07,61.66 23.18,61.75 23.18,61.75 23.19,61.8 arc(23.19,61.85) 23.16,61.9 v5(23.02,62.04) ; CT97.1 16.83,65.24 16.92,65.24 arc(16.95,65.24) 16.98,65.26 17.07,65.35 arc(17.08,65.36) 17.09,65.38 arc(17.12,65.43) 17.13,65.5 17.13,65.52 arc(17.13,65.56) 17.16,65.59 17.18,65.61 arc(17.22,65.64) 17.27,65.65 17.32,65.65 arc(17.36,65.65) 17.39,65.64 arc(17.42,65.62) 17.45,65.6 17.54,65.51 arc(17.6,65.42) 17.62,65.33 17.62,65.19 arc(17.58,65.01) 17.48,64.86 v5(17.44,64.82)
TBT_A_TTX_DRX_P2: length 7.3
  BOTTOM w0.091: UT1.A17 24.11,61.29 arc(24.13,61.28) 24.16,61.27 24.17,61.27 arc(24.21,61.28) 24.24,61.31 24.25,61.32 arc(24.28,61.35) 24.29,61.4 24.29,62.26 arc(24.22,62.62) 24.02,62.92 21.53,65.4 arc(21.19,65.63) 20.78,65.71 20.04,65.71 arc(20,65.72) 19.97,65.74 CT95.1
TBT_CIO_PLUG_EVENT#: length 134.4
  IN2 w0.066: v4(136.11,52.04) 135.42,52.04 134.68,51.31 134.68,50.9 134.15,50.37 133.51,50.37 133.34,50.55 132.9,50.55 129.73,47.38 127.91,47.38 123.89,43.36 123.89,40.64 121.66,38.41 121.66,37.18 113.72,29.24 109.68,29.24 109.16,29.76 100.17,29.76 99.99,29.94 81.14,29.94 80.88,29.68 72.76,29.68 66.92,35.52 66.92,36.39 60.41,42.9 58.8,42.9 57.24,44.47 53.48,44.47 53.11,44.09 49.95,44.09 48.6,45.45 48.6,46.11 44.93,49.78 44.93,53.01 44.35,53.6 43.62,53.6 43.57,53.55 v4(43.51,53.55)
  IN3 w0.064: v4(43.51,53.55) 43.48,53.51 43.25,53.51 43.13,53.63 41.14,53.63 41.14,53.63 38.92,53.63 38.71,53.84 36.05,53.84 35.13,52.92 35.13,52.6 34.95,52.41 34.52,52.41 34.26,52.14 31.92,52.14 v5(31.72,51.95)
  IN3 w0.089: v5(136.6,52.04) v4(136.11,52.04)
  BOTTOM w0.081: v5(136.6,52.04) UC1.CM27 ; RT391.1 32.84,50.47 32.38,50.93 32.38,51.18 31.78,51.78 31.78,51.9 v5(31.72,51.95) 31.72,51.96 31.53,52.16 UT1.AA1
TBT_DP1_AUXN: length 21.2
  IN1 w0.061: v6(29.29,55.3) 29.29,55.29 29.48,55.1 29.48,54.92 29.83,54.56 29.83,50.89 29.82,50.88 29.82,50.37 29.73,50.28 29.73,46.4 27.98,44.65 27.98,40.12 27.65,39.79 27.65,39.24 27.65,39.24 27.65,39.2 25.73,37.28 25.73,36.72 v2(25.56,36.55)
  BOTTOM w0.066: UT1.N5 29.29,55.34 v6(29.29,55.3)
TBT_DP1_AUXN_C: length 1.5
  TOP w0.066: CM24.2 25.74,37.31 25.74,37.61 25.81,37.68 25.81,37.99 25.71,38.08 UM1.55
TBT_DP1_AUXP: length 21.3
  IN1 w0.061: v6(29.93,55.33) 29.68,55.09 29.68,55 30.04,54.65 30.04,50.8 30.02,50.79 30.02,50.28 29.93,50.19 29.93,46.32 28.18,44.57 28.18,40.04 27.85,39.7 27.85,39.32 27.85,39.32 27.85,39.11 25.93,37.2 25.93,36.74 v2(26.12,36.55)
  BOTTOM w0.066: UT1.N4 v6(29.93,55.33)
TBT_DP1_AUXP_C: length 1.5
  TOP w0.066: UM1.56 26.11,38.09 26.01,37.99 26.01,37.59 25.94,37.52 25.94,37.32 CM23.2
TBT_DP1_N0: length 12.3
  TOP w0.066: CM16.1 28.94,48.09 arc(28.92,48.12) 28.92,48.14 28.92,48.35 arc(28.92,48.38) 28.94,48.4 28.98,48.44 arc(29,48.49) 28.98,48.54 28.37,49.15 arc(28.35,49.16) 28.32,49.17 27.95,49.17 arc(27.85,49.19) 27.76,49.25 26.74,50.27 26.25,50.76 25.97,51.04 arc(25.94,51.05) 25.92,51.06 23.32,51.06 arc(23.29,51.05) 23.27,51.04 22.12,49.89 arc(22.1,49.87) 22.1,49.84 22.1,49.67 arc(22.1,49.64) 22.12,49.62 v6(22.3,49.44)
  BOTTOM w0.066: UT1.AC21 22.2,51.38 arc(22.21,51.41) 22.22,51.43 22.24,51.45 arc(22.26,51.46) 22.29,51.47 22.33,51.47 arc(22.36,51.46) 22.38,51.45 22.41,51.42 arc(22.43,51.39) 22.44,51.37 22.44,51.1 arc(22.43,51.07) 22.41,51.05 22.33,50.97 arc(22.31,50.95) 22.28,50.95 22.2,50.95 22.16,50.91 22.16,50.35 22.02,50.21 22.02,49.74 arc(22.03,49.71) 22.05,49.69 v6(22.3,49.44)
TBT_DP1_N0_C: length 10.4
  TOP w0.066: RM53.1 29.06,40.82 29.42,40.47 29.78,40.47 arc(29.8,40.47) 29.83,40.49 29.91,40.57 arc(29.93,40.59) 29.93,40.62 29.93,41.06 arc(29.95,41.16) 30.01,41.25 31.36,42.6 arc(31.38,42.63) 31.39,42.65 31.39,43.56 arc(31.41,43.67) 31.46,43.76 31.84,44.13 arc(31.86,44.15) 31.86,44.18 31.86,45.3 arc(31.86,45.32) 31.84,45.35 31.57,45.61 31.31,45.87 arc(31.29,45.89) 31.26,45.89 31.17,45.89 arc(31.14,45.9) 31.12,45.92 30.97,46.06 arc(30.96,46.08) 30.95,46.11 30.95,46.21 arc(30.95,46.23) 30.93,46.26 30.79,46.4 30.79,46.72 arc(30.78,46.74) 30.77,46.77 30.42,47.11 arc(30.4,47.13) 30.37,47.13 30.24,47.13 arc(30.21,47.14) 30.19,47.15 30.11,47.23 arc(30.1,47.26) 30.09,47.28 30.09,47.42 arc(30.09,47.44) 30.07,47.46 30.02,47.52 arc(30,47.53) 29.97,47.54 29.52,47.54 arc(29.5,47.54) 29.47,47.56 29.44,47.59
TBT_DP1_N0_R: length 1.6
  TOP w0.066: RM53.2 28.24,40.65 27.94,40.65 27.8,40.51 27.59,40.51 27.49,40.6 UM1.4
TBT_DP1_N1: length 9.9
  TOP w0.066: CM18.1 27.55,48.57 arc(27.55,48.6) 27.53,48.62 25.7,50.46 arc(25.67,50.47) 25.65,50.48 23.61,50.48 arc(23.59,50.47) 23.57,50.46 23.02,49.91 arc(23.01,49.89) 23,49.86 23,49.08 arc(23.01,49.05) 23.02,49.03 v6(23.16,48.89)
  BOTTOM w0.066: UT1.AB19 23.31,51.52 arc(23.32,51.49) 23.33,51.47 23.33,51.17 arc(23.31,51.06) 23.25,50.98 23.15,50.88 23.15,50.81 arc(23.13,50.7) 23.07,50.61 23,50.55 23,49.08 arc(23.01,49.05) 23.02,49.03 v6(23.16,48.89)
TBT_DP1_N1_C: length 8.9
  TOP w0.066: RM54.1 29.06,41.94 29.33,41.67 arc(29.35,41.66) 29.38,41.65 29.43,41.65 arc(29.46,41.66) 29.48,41.67 30.65,42.85 arc(30.67,42.87) 30.68,42.9 30.68,45.45 arc(30.67,45.48) 30.65,45.5 30.6,45.55 arc(30.58,45.57) 30.55,45.58 30.45,45.58 arc(30.42,45.58) 30.4,45.6 30.31,45.69 arc(30.29,45.71) 30.29,45.74 30.29,45.84 arc(30.28,45.87) 30.27,45.89 30.14,46.02 arc(30.12,46.04) 30.1,46.04 arc(30.09,46.04) 30.09,46.04 29.96,46.04 arc(29.94,46.05) 29.92,46.06 29.82,46.16 arc(29.8,46.18) 29.8,46.21 29.8,46.33 arc(29.79,46.36) 29.77,46.38 29.63,46.53 arc(29.61,46.54) 29.58,46.55 29.43,46.55 arc(29.4,46.55) 29.38,46.57 29.29,46.66 arc(29.28,46.68) 29.27,46.71 29.27,46.86 arc(29.27,46.89) 29.25,46.91 28.25,47.91 arc(28.23,47.92) 28.2,47.93 CM18.2
TBT_DP1_N1_R: length 1.6
  TOP w0.066: UM1.7 27.46,41.8 27.56,41.71 27.75,41.71 27.82,41.77 28.24,41.77 RM54.2
TBT_DP1_N2: length 9
  TOP w0.066: v6(23.98,49.48) 23.93,49.48 23.74,49.68 arc(23.72,49.7) 23.72,49.73 23.72,49.79 23.79,49.86 arc(23.81,49.88) 23.83,49.88 25.42,49.88 arc(25.45,49.88) 25.47,49.86 26.2,49.13 arc(26.22,49.11) 26.22,49.08 26.22,48.97 arc(26.24,48.86) 26.3,48.77 27.79,47.28 arc(27.81,47.26) 27.81,47.24 27.81,46.94 arc(27.82,46.91) 27.83,46.89 CM20.1
  BOTTOM w0.066: UT1.AC17 24.04,51.37 arc(24.05,51.4) 24.06,51.42 24.09,51.45 arc(24.11,51.47) 24.14,51.47 24.19,51.47 arc(24.22,51.47) 24.24,51.45 24.28,51.41 arc(24.3,51.39) 24.3,51.36 24.3,51.08 arc(24.3,51.05) 24.28,51.03 24.2,50.94 arc(24.19,50.93) 24.18,50.93 23.99,50.83 23.99,50.65 arc(23.97,50.54) 23.92,50.45 23.68,50.22 arc(23.67,50.2) 23.66,50.17 23.66,49.83 arc(23.67,49.8) 23.68,49.78 v6(23.98,49.48)
TBT_DP1_N2_C: length 5.8
  TOP w0.066: CM20.2 28.38,46.34 arc(28.41,46.32) 28.43,46.32 28.77,46.32 arc(28.79,46.31) 28.81,46.3 28.88,46.24 arc(28.89,46.21) 28.9,46.19 28.9,46.03 arc(28.9,46) 28.92,45.98 28.97,45.93 arc(28.99,45.91) 29.02,45.91 29.18,45.91 arc(29.21,45.9) 29.23,45.89 29.35,45.76 arc(29.37,45.74) 29.37,45.71 29.37,45.61 arc(29.38,45.58) 29.39,45.56 29.53,45.42 arc(29.55,45.4) 29.58,45.4 29.69,45.4 arc(29.71,45.39) 29.73,45.38 29.94,45.17 arc(29.96,45.15) 29.96,45.12 29.96,43.08 arc(29.96,43.05) 29.94,43.03 29.63,42.72 arc(29.61,42.71) 29.58,42.7 29.46,42.7 arc(29.43,42.71) 29.41,42.72 29.31,42.82 arc(29.29,42.85) 29.29,42.87 29.29,42.92 arc(29.28,42.95) 29.27,42.97 29.2,43.04 arc(29.18,43.05) 29.15,43.06 RM56.1
TBT_DP1_N2_R: length 1.5
  TOP w0.066: UM1.10 27.45,43 27.57,42.89 28.25,42.89 RM56.2
TBT_DP1_N3: length 6.7
  TOP w0.066: CM22.1 26.4,47.48 arc(26.39,47.5) 26.38,47.52 25.57,48.33 arc(25.51,48.42) 25.49,48.53 25.49,48.89 arc(25.48,48.91) 25.47,48.94 25.13,49.27 arc(25.11,49.29) 25.08,49.29 24.72,49.29 arc(24.69,49.29) 24.67,49.27 24.6,49.2 24.6,49.1 arc(24.61,49.07) 24.62,49.05 v6(24.78,48.9)
  BOTTOM w0.066: UT1.AB15 25.09,51.57 arc(25.16,51.46) 25.19,51.34 25.19,50.5 arc(25.17,50.39) 25.11,50.3 24.65,49.85 arc(24.63,49.82) 24.63,49.8 24.63,49.08 arc(24.63,49.05) 24.65,49.03 v6(24.78,48.9)
TBT_DP1_N3_C: length 4.9
  TOP w0.066: CM22.2 27.03,46.81 arc(27.06,46.8) 27.08,46.79 27.18,46.69 arc(27.19,46.67) 27.2,46.65 27.2,46.52 arc(27.2,46.49) 27.22,46.47 27.32,46.37 arc(27.34,46.35) 27.37,46.35 27.49,46.35 arc(27.52,46.34) 27.54,46.33 27.61,46.26 arc(27.63,46.24) 27.63,46.21 27.63,46.06 arc(27.64,46.03) 27.65,46.01 27.74,45.92 arc(27.77,45.9) 27.79,45.9 27.94,45.9 arc(27.97,45.89) 27.99,45.88 28.09,45.78 arc(28.1,45.76) 28.11,45.73 28.11,45.56 arc(28.11,45.53) 28.13,45.51 28.24,45.4 arc(28.26,45.38) 28.29,45.38 28.46,45.38 arc(28.49,45.37) 28.51,45.36 28.58,45.29 arc(28.6,45.27) 28.6,45.24 28.6,45.05 arc(28.61,45.02) 28.62,45 28.74,44.88 arc(28.76,44.87) 28.79,44.86 28.98,44.86 arc(29.01,44.86) 29.03,44.84 29.34,44.53 arc(29.36,44.5) 29.36,44.48 29.36,44.1 arc(29.36,44.08) 29.34,44.06 29.3,44.01 29.19,44.01 arc(29.17,44.01) 29.14,44.03 RM58.1
TBT_DP1_N3_R: length 1.6
  TOP w0.066: UM1.13 27.46,44.2 27.56,44.1 27.85,44.1 27.96,44 28.23,44 RM58.2
TBT_DP1_P0: length 12.2
  TOP w0.066: CM15.1 29.4,48.4 28.51,49.29 arc(28.42,49.35) 28.32,49.37 27.95,49.37 arc(27.93,49.38) 27.9,49.39 27.41,49.89 26.11,51.18 arc(26.02,51.24) 25.92,51.26 23.32,51.26 arc(23.21,51.24) 23.13,51.18 21.97,50.03 arc(21.92,49.94) 21.89,49.84 21.89,49.65 arc(21.89,49.62) 21.87,49.6 v6(21.71,49.44)
  BOTTOM w0.066: v6(21.71,49.44) 21.8,49.52 arc(21.82,49.55) 21.82,49.57 21.82,50.3 21.96,50.43 21.96,51.42 arc(21.96,51.45) 21.98,51.47 UT1.AB21
TBT_DP1_P0_C: length 10.4
  TOP w0.066: RM52.1 29.33,40.26 29.33,40.26 29.78,40.26 arc(29.88,40.28) 29.97,40.34 30.05,40.43 arc(30.11,40.52) 30.13,40.62 30.13,41.06 arc(30.14,41.08) 30.15,41.11 31.51,42.46 arc(31.57,42.55) 31.59,42.65 31.59,43.56 arc(31.59,43.59) 31.61,43.61 31.98,43.99 arc(32.04,44.08) 32.06,44.18 32.06,45.3 arc(32.04,45.4) 31.98,45.49 31.72,45.76 30.99,46.48 30.99,46.72 arc(30.97,46.82) 30.91,46.91 29.83,47.99
TBT_DP1_P0_R: length 1.6
  TOP w0.066: UM1.3 27.45,40.2 27.55,40.3 27.88,40.3 28.03,40.45 28.23,40.45 RM52.2
TBT_DP1_P1: length 9.9
  TOP w0.066: CM17.1 27.73,48.74 arc(27.71,48.74) 27.68,48.76 25.84,50.6 arc(25.75,50.66) 25.65,50.68 23.61,50.68 arc(23.51,50.66) 23.42,50.6 22.88,50.06 arc(22.82,49.97) 22.8,49.86 22.8,49.14 arc(22.79,49.12) 22.78,49.1 v6(22.58,48.89)
  BOTTOM w0.066: UT1.AC19 23.12,51.17 arc(23.12,51.14) 23.1,51.12 22.95,50.96 22.95,50.81 arc(22.94,50.78) 22.93,50.76 22.8,50.63 22.8,49.14 arc(22.79,49.12) 22.78,49.1 v6(22.58,48.89)
TBT_DP1_P1_C: length 9
  TOP w0.066: RM55.1 29.13,41.38 arc(29.15,41.39) 29.18,41.4 29.2,41.43 arc(29.23,41.45) 29.25,41.45 29.43,41.45 arc(29.54,41.47) 29.63,41.53 30.8,42.7 arc(30.86,42.79) 30.88,42.9 30.88,45.46 arc(30.86,45.56) 30.8,45.65 30.12,46.32 28.38,48.06 arc(28.37,48.09) 28.36,48.11 28.36,48.32
TBT_DP1_P1_R: length 1.6
  TOP w0.066: UM1.6 27.43,41.4 27.53,41.5 27.84,41.5 27.9,41.57 28.23,41.57 RM55.2
TBT_DP1_P2: length 9
  TOP w0.066: v6(23.39,49.48) 23.49,49.59 arc(23.51,49.61) 23.52,49.64 23.52,49.88 23.64,50 arc(23.73,50.06) 23.83,50.08 25.42,50.08 arc(25.53,50.06) 25.62,50 26.35,49.27 arc(26.41,49.19) 26.43,49.08 26.43,48.97 arc(26.43,48.94) 26.45,48.92 27.98,47.39 arc(28,47.37) 28.02,47.37 28.12,47.37 arc(28.15,47.36) 28.17,47.35 CM19.1
  BOTTOM w0.066: v6(23.39,49.48) 23.44,49.53 arc(23.45,49.56) 23.46,49.58 23.46,50.17 arc(23.48,50.28) 23.54,50.37 23.77,50.6 arc(23.79,50.62) 23.79,50.65 23.79,50.92 23.84,50.96 23.84,51.47 arc(23.85,51.49) 23.86,51.52 UT1.AB17
TBT_DP1_P2_C: length 5.8
  TOP w0.066: RM57.1 29.59,42.5 arc(29.69,42.52) 29.78,42.58 30.09,42.89 arc(30.14,42.98) 30.16,43.08 30.16,45.12 arc(30.14,45.23) 30.09,45.32 28.7,46.7 arc(28.69,46.72) 28.68,46.75 CM19.2
TBT_DP1_P2_R: length 1.5
  TOP w0.066: UM1.9 27.46,42.6 27.55,42.69 28.22,42.69 RM57.2
TBT_DP1_P3: length 6.6
  TOP w0.066: CM21.1 26.6,47.62 arc(26.57,47.62) 26.55,47.64 25.71,48.48 arc(25.7,48.5) 25.69,48.53 25.69,48.89 arc(25.67,48.99) 25.61,49.08 25.28,49.41 arc(25.19,49.47) 25.08,49.49 24.72,49.49 arc(24.61,49.47) 24.53,49.41 24.4,49.29 24.4,49.13 arc(24.39,49.1) 24.38,49.08 v6(24.19,48.9)
  BOTTOM w0.066: UT1.AC15 24.98,51.22 24.98,50.5 arc(24.98,50.47) 24.96,50.45 24.5,49.99 arc(24.45,49.9) 24.43,49.8 24.43,49.16 arc(24.42,49.13) 24.4,49.11 v6(24.19,48.9)
TBT_DP1_P3_C: length 4.9
  TOP w0.066: RM59.1 29.16,43.78 arc(29.18,43.8) 29.21,43.8 29.38,43.8 29.49,43.91 arc(29.55,44) 29.57,44.1 29.57,44.48 arc(29.55,44.58) 29.49,44.67 28.92,45.24 27.23,46.93 arc(27.21,46.95) 27.2,46.98 CM21.2
TBT_DP1_P3_R: length 1.6
  TOP w0.066: UM1.12 27.47,43.8 27.57,43.9 27.77,43.9 27.87,43.79 28.23,43.79 RM59.2
TBT_FORCE_PWR: length 240.8
  TOP w0.081: RT27.1 RT592.1 29.6,51.73 v2(29.53,51.81)
  IN1 w0.064: v4(26.4,51.64) 26.48,51.64 26.75,51.37 27.18,51.37 27.44,51.11 28.75,51.11 29.44,51.81 v2(29.53,51.81)
  IN2 w0.066: v4(21.39,61.82) 19.21,59.64 19.21,56.12 21.3,54.03 22.77,54.03 23.49,53.31 24.33,53.31 24.51,53.5 25.6,53.5 26.4,52.69 v4(26.4,51.64) 26.4,50.59 28.76,48.22 28.76,41.6 30.82,39.54 30.82,37.45 30.46,37.09 24.74,37.09 23.83,36.17 20.56,36.17 20.5,36.11 19.34,36.11 v4(18.78,36.68) ; v4(139.27,51.32) 138.87,51.32 137.91,50.36 137.79,50.36 137.06,49.62 137.06,49.3 136.68,48.92 135.82,48.92 134.08,47.18 133.89,47.18 128.99,42.28 127.84,42.28 125.31,39.76 125.31,36.59 123.06,34.34 121.4,34.34 114.76,27.7 114.76,26.2 111.43,22.87 94.18,22.87 93.53,22.23 92.07,22.23 91.07,23.23 89.69,23.23 89.16,22.7 89.1,22.7 89.1,22.71 82.06,22.71 76.37,28.4 76.28,28.4 76.28,28.4 72.25,28.4 65.44,35.21 65.44,35.23 63.48,37.2 62.42,37.2 59.19,40.43 59.19,40.9 56.75,43.33 55.7,43.33 55.57,43.21 52.77,43.21 52.53,43.45 47.59,43.45 46.88,44.16 46.88,45.66 42.28,50.26 39.96,50.26 39.22,51 39.22,53.08 39.33,53.19 39.33,56.01 39.91,56.59 39.91,58.66 42.14,60.89 42.14,62.03 42.23,62.12 42.23,64.03 41.25,65.01 41.25,67.77 40.08,68.95 40.08,69.88 38.72,71.23 38.47,71.23 38.35,71.36 36.57,71.36 36.31,71.62 35.06,71.62 34.8,71.36 32.17,71.36 31.44,72.09 30.8,72.09 30.31,72.58 29.59,72.58 28.11,71.1 28.11,70.88 v4(28.36,70.63)
  IN3 w0.064: v4(139.27,51.32) 139.25,51.32 139.19,51.25 v5(139.19,50.94) ; v4(28.36,70.63) 27.07,71.16 24.86,71.16 22.85,69.15 22.85,66.91 24.6,65.16 24.61,65.16 26.28,63.49 26.28,62.19 24.96,60.87 22.34,60.87 v4(21.39,61.82) ; v5(30.24,53.7) 29.9,53.35 29.55,53.35 29.41,53.21 28.61,53.21 28.49,53.33 27.75,53.33 27.3,52.87 27.3,52.37 26.57,51.64 v4(26.4,51.64) ; v5(18.41,36.68) v4(18.78,36.68)
  BOTTOM w0.081: RPD130.1 v5(18.41,36.68)
TBT_I2C_SCL: length 51.6
  IN2 w0.066: v4(15.37,30.61) 17.75,30.61 19.61,32.46 19.61,35.08 19.91,35.38 20.5,35.38 20.83,35.05 23.79,35.05 25.06,36.31 31.18,36.31 32.48,37.61 32.48,38.98 29.54,41.92 29.54,49.03 27.77,50.8 v4(27.77,51.51)
  IN3 w0.064: v5(15.74,30.57) 15.69,30.61 v4(15.37,30.61) ; v5(34.84,52.65) 34.81,52.63 34.38,52.63 34.05,52.29 31.68,52.29 31.14,51.75 30.04,51.75 29.83,51.53 29.28,51.53 29.04,51.29 28.04,51.29 27.85,51.48 27.81,51.48 v4(27.77,51.51)
  BOTTOM w0.081: UT1.V2 30.94,53.44 31.07,53.31 31.6,53.31 31.82,53.09 31.97,53.09 32.72,52.34 32.72,52.23 32.87,52.07 34.22,52.07 34.37,52.22 RT609.1 34.47,52.49 34.73,52.49 34.84,52.6 v5(34.84,52.65) ; RPD21.2 16.11,30.26 15.8,30.57 v5(15.74,30.57)
TBT_I2C_SDA: length 46.1
  IN2 w0.066: v4(15.64,31.47) 15.64,31.27 16.07,30.84 17.51,30.84 19.38,32.71 19.38,35.46 19.49,35.57 20.64,35.57 20.96,35.25 23.72,35.25 24.98,36.51 31.1,36.51 32.2,37.61 32.2,38.99 29.34,41.84 29.34,48.66 27.34,50.66 27.34,51.85 v4(27.37,51.88)
  IN3 w0.064: v5(31.99,53.34) 31.99,53.29 31.93,53.23 31.17,53.23 30.61,52.68 30.18,52.68 29.84,52.34 29.84,52.26 29.53,51.95 29.22,51.95 29.12,52.05 28.29,52.05 28.28,52.04 27.53,52.04 v4(27.37,51.88) ; v4(15.64,31.47) 15.76,31.35 v5(15.76,31.15)
  BOTTOM w0.081: UT1.V1 31.79,53.54 v5(31.99,53.34) 32.93,52.4 RT608.1 ; v5(15.76,31.15) RPD22.2
TBT_JTAG_TCK: length 2.5
  TOP w0.081: v2(22.62,53.05) 22.62,53.05 RT6.1
  IN1 w0.064: v4(22.5,53.58) 22.58,53.5 22.58,53.09 v2(22.62,53.05)
  IN3 w0.064: v4(22.5,53.58) 22.53,53.58 22.78,53.33 v5(22.84,53.33)
  BOTTOM w0.081: v5(22.84,53.33) 23.09,53.08 UT1.W19
TBT_JTAG_TDI: length 2.3
  TOP w0.081: RT8.1 21.71,52.34 21.95,52.58 v1(21.95,52.8) 21.95,53.02 v2(21.71,53.26)
  IN1 w0.064: v4(22.09,53.21) 21.75,53.21 v2(21.71,53.26)
  IN3 w0.064: v4(22.09,53.21) 22.18,53.11 22.38,53.11 v5(22.44,53.05)
TBT_JTAG_TDO: length 1.1
  TOP w0.081: RT5.1 v2(23.08,52.29)
  IN1 w0.064: v2(23.08,52.29) 23.08,52.41 v4(22.86,52.63)
  IN3 w0.064: v5(23.09,52.4) v4(22.86,52.63)
TBT_JTAG_TMS: length 1
  TOP w0.081: RT7.1 v2(22.16,52.3)
  IN1 w0.064: v4(22.21,52.63) 22.16,52.59 v2(22.16,52.3)
  IN3 w0.064: v4(22.21,52.63) 22.23,52.63 22.44,52.42 v5(22.44,52.4)

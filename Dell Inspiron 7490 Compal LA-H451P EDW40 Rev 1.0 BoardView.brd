# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP1_N2_C: length 2.3
  BOTTOM w0.091: UT1.C1 31.3,60.44 31.24,60.5 31.24,60.61 31.31,60.68 31.6,60.68 31.76,60.52 32.89,60.52 CT15.1
CPU_DP1_N3: length 188
  IN1 w0.079: v6(34.32,58.99) 34.12,59.19 34.01,59.19 33.86,59.08 32.62,54.94 32.55,54.66 32.55,53.42 32.93,53.04 32.93,43.83 32.68,43.58 32.68,43.45 32.83,43.3 32.92,43.3 33.07,43.45 v4(33.07,43.46)
  IN3 w0.079: v4(33.07,43.46) 33.25,43.28 33.38,43.28 34.17,43.77 35.86,43.77 36.87,42.76 40.74,42.76 42.57,42 43.99,40.58 48.13,40.58 48.45,40.44 50.8,39.25 51.23,38.82 54.56,37.44 55.23,36.77 55.32,36.74 56.32,36.52 56.6,36.52 65.29,27.82 66.5,24.98 66.5,22.43 72.05,16.88 73.39,16.19 74.28,16.19 78.21,15.2 78.22,15.19 80.29,14.67 81.26,14.67 81.43,14.6 82.94,14.6 83.56,13.98 88.09,12.08 93.54,11.35 97.49,11.35 101.51,9.91 101.51,9.91 110.58,9.37 115.6,9.37 115.6,9.37 117.11,9.37 118.94,9.69 128.09,9.69 128.83,9.85 147.29,9.85 152.18,11.88 152.23,11.92 153.12,12.28 153.13,12.28 155.52,13.22 157.48,13.87 158.36,14.75 158.36,17.3 159.4,18.34 159.4,18.7 159.4,19.42 159.52,20.03 159.66,20.74 159.66,21.07 159.66,21.08 159.66,21.86 159.66,21.86 159.66,22.97 159.66,22.98 159.53,23.93 159.51,24.1 159.41,24.95 159.39,25.01 159.39,25.02 159.01,26.4 159.01,32.71 160.7,35.2 161.67,36.17 162.49,36.63 162.53,36.67 162.55,36.67 163.87,38 164.18,38 164.18,38 164.5,38 164.61,38.11 165.37,38.11 165.53,38.27 165.53,38.27 165.53,38.49 165.53,38.5 165.53,38.51 165.31,38.74 165.14,38.74 165.14,38.74 164.83,38.74 164.75,38.66 164.75,38.47 164.84,38.38 v5(165.26,38.38)
  BOTTOM w0.091: v6(34.32,58.99) 34.13,59.18 33.82,59.18 CT17.2
CPU_DP1_N3_C: length 2.4
  BOTTOM w0.091: CT17.1 32.87,59.23 32.23,59.23 32.05,59.41 31.69,59.41 31.58,59.29 31.27,59.29 31.2,59.36 31.2,59.45 31.27,59.52 UT1.E1
CPU_DP1_P0: length 187.7
  IN1 w0.079: v4(30.34,45.39) 30.4,45.39 30.49,45.3 30.62,45.3 30.74,45.42 30.74,46.03 30.4,46.38 30.4,50.64 30.41,50.65 30.41,55.33 30.72,55.64 30.72,58.51 30.72,58.51 30.65,58.81 30.3,59.5 30.29,59.5 29.94,60.2 29.31,60.82 29.31,60.96 v2(29.11,61.16)
  IN3 w0.079: v5(161.23,39.04) 161.28,38.99 161.28,38.77 161.2,38.7 160.56,38.7 160.54,38.68 160.54,38.68 157.23,35.37 157.23,33.34 157.23,33.34 157.23,25.47 157.13,25.37 157.13,25.36 157.06,25.3 157.06,20.77 156.67,20.38 156.67,20.36 156.67,20.35 156.67,18.12 156.4,17.62 156.33,17.59 155.63,17.59 154.91,16.87 154.91,15.93 154.56,15.58 154.56,14.83 146.72,11.61 127.99,11.61 127.31,12.29 126.16,12.29 126.12,12.25 119.38,12.25 118.6,13.02 108.25,13.02 107.06,14.22 99.74,14.22 99.11,14.85 99.11,14.85 98.35,15.6 87.32,15.6 86.86,16.06 86.65,16.06 86.16,16.56 80.5,16.56 78.48,18.58 75.85,18.58 75.14,19.29 75.14,20.38 74.22,21.29 70.47,21.29 68.42,23.34 68.42,28 66.15,30.27 66.15,30.33 65.4,31.08 65.4,31.27 58.03,38.65 55.88,38.65 53.11,41.41 52.95,41.41 52.57,41.41 51.07,42.04 50.66,42.45 44.65,42.45 42.47,44.63 37.71,44.63 36.82,45.52 30.91,45.52 30.62,45.23 30.5,45.23 v4(30.34,45.39)
  BOTTOM w0.091: v5(161.23,39.04) 161.24,39.03 UC1.AL6
CPU_DP1_P0_C: length 2.4
  TOP w0.091: CT10.1 29.3,61.94 29.3,62.16 v6(29.12,62.34)
  BOTTOM w0.091: UT1.A5 29.56,61.24 29.52,61.19 29.38,61.19 29.32,61.26 29.32,61.51 29.42,61.61 29.42,61.76 29.33,61.85 29.33,62.13 v6(29.12,62.34)
CPU_DP1_P1: length 187.8
  IN1 w0.079: v4(30.9,44.14) 31.07,44.31 31.27,44.31 31.53,44.56 31.53,46.36 31.18,46.7 31.18,50.31 31.19,50.32 31.19,55.01 31.51,55.32 31.51,59.05 31.48,59.17 31.46,59.3 30.74,60.79 30.74,60.98 v2(30.92,61.16)
  IN3 w0.079: v5(162.1,39.04) 162.25,38.89 162.32,38.89 162.57,38.64 162.57,38.16 162.05,37.64 161.48,37.42 161.45,37.4 159.19,35.14 158.45,34.09 158.02,33.16 158.02,25.14 157.92,25.04 157.92,20.48 157.46,20.03 157.46,17.92 156.96,17.02 156.51,16.81 155.96,16.81 155.7,16.55 155.7,15.6 155.35,15.25 155.35,14.26 154.1,13.79 153.83,13.67 153.83,13.67 153.75,13.64 153.51,13.53 151.81,12.8 151.8,12.79 149.56,11.92 147.21,10.96 147.01,10.86 146.97,10.82 125.59,10.82 125.57,10.84 122.55,11.38 119.27,11.38 117.14,12.23 117.11,12.24 117.09,12.24 107.77,12.24 106.64,13.38 99.39,13.38 97.95,14.81 95.59,14.81 95.59,14.81 93.22,14.81 92.37,14.38 91.64,14.02 90.95,13.68 89.27,13.68 87.44,14.44 87.06,14.82 86.99,14.82 86.53,15.28 86.33,15.28 85.84,15.76 80.42,15.76 80.21,15.8 75.4,17.8 72.64,17.8 67.5,22.93 67.5,25.48 66.4,28.68 57.3,37.78 55.6,37.78 53,40.39 50.02,41.62 44.36,41.62 43.2,42.78 42.12,43.39 40.5,43.84 37.3,43.84 36.4,44.73 32.28,44.73 31.68,44.58 31.41,44.31 31.07,44.31 v4(30.9,44.14)
  BOTTOM w0.091: UC1.AJ6 v5(162.1,39.04)
CPU_DP1_P1_C: length 2.5
  TOP w0.091: CT12.1 30.72,61.94 30.72,62.16 v6(30.91,62.34)
  BOTTOM w0.091: v6(30.91,62.34) 30.65,62.08 30.65,61.62 30.72,61.55 30.72,61.41 30.72,61.41 30.72,61.1 30.55,60.93 30.52,60.93 UT1.B3
CPU_DP1_P2: length 188.1
  IN1 w0.079: v4(31.55,43.4) 31.69,43.54 31.9,43.54 32.1,43.74 32.1,43.74 32.12,43.82 32.34,44.35 32.34,52.8 32.05,53.09 32.05,53.09 31.96,53.18 31.96,54.73 32.05,55.1 33.35,59.43 33.54,59.57 33.62,59.94 33.96,60.28 34.21,60.28 v6(34.3,60.19)
  IN3 w0.079: v4(31.55,43.4) 31.73,43.58 31.92,43.58 31.93,43.58 32.17,43.58 33.31,44.15 36.1,44.15 37.11,43.14 40.82,43.14 42.85,42.3 44.14,41.01 49.96,41.01 50.36,40.85 54.34,38.22 55.36,37.2 55.42,37.19 55.8,37.11 55.84,37.1 56.26,37.1 57.51,36.75 65.15,29.1 66.88,25.15 66.88,22.67 72.44,17.11 73.65,16.6 74.28,16.6 77.79,15.77 77.8,15.77 80.52,15.13 82.51,15.13 83.14,14.94 83.78,14.3 88.16,12.47 93.54,11.76 97.81,11.76 101.71,10.28 110.6,9.75 115.44,9.75 115.45,9.76 116.14,9.76 118.91,10.07 127.53,10.07 128.52,10.24 147.22,10.24 147.27,10.3 147.36,10.38 147.45,10.43 149.77,11.38 151.58,12.08 151.62,12.1 152.02,12.25 152.08,12.28 155.39,13.58 155.44,13.6 155.48,13.62 155.95,13.81 157.33,14.27 157.96,14.89 157.96,16.68 157.96,16.69 157.96,17.44 157.99,17.47 157.99,17.47 158.59,18.08 158.59,18.08 158.98,18.46 158.98,20.84 158.77,21.04 158.77,22.03 158.97,22.65 158.97,24.99 158.6,25.88 158.6,32.79 159.86,34.91 161.65,36.7 162.33,37 163.97,38.64 164.27,38.64 164.34,38.57 v5(164.34,38.38)
  BOTTOM w0.091: v6(34.3,60.19) 34.14,60.35 33.86,60.35 CT14.2
CPU_DP1_P2_C: length 2.4
  BOTTOM w0.091: UT1.C2 31.18,60.2 31.6,60.2 31.71,60.31 32.94,60.31 CT14.1
CPU_DP1_P3: length 188.1
  IN1 w0.079: v4(33.07,42.93) 32.9,43.1 32.75,43.1 32.48,43.37 32.48,43.66 32.73,43.91 32.73,48.44 32.72,48.44 32.72,52.96 32.35,53.34 32.35,54.68 32.42,55 33.68,59.2 33.95,59.39 34.12,59.39 34.12,59.39 34.13,59.39 v6(34.32,59.58)
  IN3 w0.079: v5(165.26,39.03) 165.3,39.03 165.39,38.95 165.39,38.94 165.73,38.6 165.73,38.58 165.73,38.58 165.73,38.18 165.73,38.18 165.45,37.91 164.69,37.91 164.58,37.8 164.1,37.8 164.1,37.8 163.96,37.8 163.88,37.72 162.72,36.56 162.7,36.52 162.66,36.5 162.63,36.47 162.62,36.47 162.6,36.45 162.58,36.45 161.79,36.01 160.86,35.08 159.21,32.65 159.21,26.43 159.58,25.06 159.6,24.98 159.73,23.96 159.85,23.07 159.86,23.05 159.86,21.82 159.86,21 159.86,20.99 159.86,20.74 159.85,20.7 159.72,19.99 159.6,19.38 159.6,19.14 159.6,18.79 159.6,18.26 158.56,17.22 158.56,14.66 157.59,13.7 155.59,13.03 153.2,12.09 153.2,12.09 152.33,11.75 152.28,11.71 147.33,9.65 128.86,9.65 128.12,9.49 118.95,9.49 117.12,9.17 115.69,9.17 115.69,9.17 110.58,9.17 101.47,9.71 101.45,9.72 97.46,11.15 93.53,11.15 88.04,11.89 83.45,13.81 82.86,14.4 81.39,14.4 81.22,14.47 80.26,14.47 78.17,15 78.17,15 74.25,15.99 73.34,15.99 71.94,16.71 66.3,22.35 66.3,24.94 65.12,27.71 56.52,36.32 56.3,36.32 55.27,36.54 55.12,36.59 54.44,37.27 51.12,38.65 50.68,39.08 48.36,40.26 48.09,40.38 43.91,40.38 42.45,41.83 40.7,42.56 36.79,42.56 35.78,43.57 34.22,43.57 33.44,43.08 33.25,43.08 33.24,43.08 33.22,43.08 v4(33.07,42.93)
  BOTTOM w0.091: v6(34.32,59.58) 34.12,59.38 33.87,59.38 CT16.2
CPU_DP1_P3_C: length 2.4
  BOTTOM w0.091: UT1.E2 31.17,59.74 31.58,59.74 31.71,59.61 32.14,59.61 32.31,59.43 32.93,59.43 CT16.1
CPU_DP2_AUXN: length 193.4
  IN1 w0.079: v4(34.28,39.84) 34.18,39.94 33.86,39.94 33.48,40.31 33.48,42.76 33.64,42.92 33.64,43.58 33.41,43.81 33.41,43.82 33.32,43.91 33.32,51.96 33.72,52.37 33.72,52.79 32.96,53.56 32.96,54.53 33.44,56.18 33.77,56.5 34.09,56.5 v6(34.26,56.67)
  IN3 w0.079: v4(34.28,39.84) 34.35,39.91 34.82,39.91 38.18,38.51 41.27,38.21 42.26,37.22 44.24,37.22 44.46,37 47.4,37 49.89,34.51 52.7,34.51 55.1,32.11 56.13,32.11 59.43,28.81 59.43,28.31 62,25.73 62,23.92 63.24,22.68 63.24,21.09 65.15,19.17 65.15,18.22 72.11,11.27 81.1,11.27 82.6,9.77 85.82,8.89 91.04,5.86 112.51,5.86 112.95,5.41 119.55,5.41 120.02,5.88 126.06,5.88 126.54,5.4 150.2,5.4 153.84,9.04 153.87,9.12 153.95,9.15 155.72,9.89 156.04,10.02 157.14,10.02 157.96,10.36 158.07,10.41 158.59,10.63 159.31,10.96 162.94,14.59 162.94,16.09 162.94,19.91 162.86,19.99 162.86,23.43 162.86,28.94 162.34,29.46 162.34,31.65 164.44,33.75 164.79,33.75 164.82,33.78 165.17,33.78 165.2,33.75 165.5,33.75 v5(165.56,33.68)
  BOTTOM w0.076: UC1.AD4 165.4,37.22 165.39,37.22 165.2,37.03 165.2,36.68 165.23,36.66 165.23,36.39 165.2,36.36 165.2,35.48 165.13,35.41 165.13,35.23 165.12,35.22 165.12,35.15 165.11,35.15 165.11,35.14
  BOTTOM w0.091: v6(34.26,56.67) 34.14,56.55 33.8,56.55 CT184.2 ; v5(165.56,33.68) 165.47,33.78 165.33,33.78 165.23,33.87 165.23,33.87 165.11,33.99 165.11,34.05 165.11,34.05 165.11,34.93
  BOTTOM w0.094: 165.11,35.14 165.11,34.93
CPU_DP2_AUXN_C: length 2.5
  BOTTOM w0.091: CT184.1 32.44,56.68 31.82,56.06 31.16,56.06 UT1.N2
CPU_DP2_AUXP: length 193.4
  IN1 w0.079: v4(34.28,40.37) 34.05,40.14 33.94,40.14 33.69,40.39 33.69,42.68 33.84,42.83 33.84,43.66 33.52,43.99 33.52,51.88 33.92,52.29 33.92,52.88 33.16,53.64 33.16,54.5 33.62,56.07 33.85,56.3 34.12,56.3 34.26,56.16 v6(34.26,56.09)
  IN3 w0.079: v5(165.56,34.07) 165.47,33.98 165.44,33.98 165.41,33.95 165.28,33.95 165.25,33.99 164.74,33.99 164.7,33.95 164.36,33.95 162.14,31.73 162.14,29.38 162.66,28.86 162.66,24.35 162.66,24.35 162.66,24.18 162.66,24.18 162.66,23.51 162.66,23.51 162.66,19.91 162.74,19.83 162.74,19.51 162.74,14.68 159.19,11.13 158.51,10.81 157.98,10.6 157.88,10.54 157.1,10.22 156,10.22 153.72,9.27 153.67,9.16 153.67,9.16 150.12,5.6 126.62,5.6 126.14,6.08 119.94,6.08 119.47,5.62 113.04,5.62 112.59,6.06 91.09,6.06 85.9,9.07 82.7,9.95 81.19,11.47 72.19,11.47 65.35,18.3 65.35,19.26 63.44,21.17 63.44,22.77 62.2,24 62.2,25.81 59.63,28.39 59.63,28.89 56.21,32.31 55.18,32.31 52.78,34.71 49.97,34.71 47.49,37.2 44.54,37.2 44.32,37.42 42.35,37.42 41.36,38.41 38.23,38.71 34.86,40.11 34.55,40.11 v4(34.28,40.37)
  BOTTOM w0.076: 165.32,35.14 165.32,35.33 165.39,35.41 165.39,36.29 165.46,36.35 165.69,36.35 165.8,36.46 165.8,36.93 165.7,37.03 165.47,37.03 165.39,36.96 165.39,36.76 UC1.AD3
  BOTTOM w0.091: v5(165.56,34.07) 165.48,33.98 165.41,33.98 165.32,34.08 165.32,34.93 ; v6(34.26,56.09) 34.26,56.17 34.16,56.27 34.1,56.27 34.07,56.3 33.77,56.3 33.67,56.2 CT178.2
  BOTTOM w0.094: 165.32,35.14 165.32,34.93
CPU_DP2_AUXP_C: length 2.5
  BOTTOM w0.091: UT1.N1 31.75,55.84 31.86,55.73 32.11,55.73 32.21,55.82 32.21,56.16 32.51,56.47 32.65,56.47 32.74,56.38 32.74,56.22 32.83,56.13 CT178.1
CPU_DP2_CTRL_DATA: length 4.6
  BOTTOM w0.091: v1(140.34,32.9) 140.34,33.11 139.76,33.68 RC9.1 139.56,33.84 138.64,34.75 UC1.CH3
CPU_DP2_HPD: length 164.9
  TOP w0.081: v1(135.79,38.51) 136.23,38.95 v2(136.34,38.95) 136.81,39.42 RC12.1
  IN1 w0.064: v2(136.34,38.95) 136.42,38.95 v4(136.72,39.24)
  IN2 w0.066: v4(136.72,39.24) 136.71,39.23 136.71,38.53 137.57,37.67 137.57,37.17 138.1,36.65 138.1,34.89 137.49,34.29 137.49,28.25 139.67,26.07 139.67,19.82 138.73,18.88 133.13,18.88 131.93,17.68 127.89,17.68 125.68,15.47 123.72,15.47 123.45,15.74 122.02,15.74 119.5,13.23 111.18,13.23 110.74,13.66 99.74,13.66 97.27,11.19 96.21,11.19 94.69,9.67 81.95,9.67 80.45,11.18 71.97,11.18 70,13.14 70,14.24 65.71,18.53 65.71,19.64 62.62,22.73 62.62,29.2 55.45,36.36 51.54,36.36 49.57,38.34 48.04,38.34 47.8,38.1 42.6,38.1 39.25,41.46 39.25,43.94 34.98,48.2 34.98,50.28 34.4,50.87 34.4,51.5 33.81,52.09 33.81,53.32 33.84,53.36 33.84,53.4 v4(33.89,53.44)
  IN3 w0.064: v5(30.94,52.16) 31.46,52.67 32.3,52.67 33.1,53.47 33.85,53.47 v4(33.89,53.44) ; v4(136.72,39.24) 136.71,39.23 136.71,39 v5(136.58,38.87)
CPU_DP2_N0: length 187
  IN3 w0.079: v5(28.22,44.85) 28.22,44.72 31.41,41.53 35.07,41.53 35.49,41.11 35.74,41.01 39.63,41.01 41,40.44 41.27,40.17 41.28,40.17 42.74,38.71 44.78,38.71 45.07,38.42 48.28,38.42 48.64,38.27 49.22,37.71 53.38,35.98 54.78,34.58 55.85,34.58 61.27,29.16 61.27,28.61 63.59,26.3 63.59,25.17 64.65,24.11 64.65,21.61 66.52,19.74 66.52,18.84 71.3,14.06 74.18,14.06 77.5,12.69 82.17,12.69 83.26,11.6 88.46,9.45 89.27,8.91 89.28,8.9 91.08,7.7 98.77,7.7 99.13,7.34 113.07,7.34 113.58,6.83 116.68,6.83 117.45,7.6 119.14,7.6 119.47,7.94 130.29,7.94 130.46,8.1 150.87,8.1 152.35,9.57 152.72,9.95 152.86,10.09 153.03,10.25 153.48,10.44 153.76,10.56 153.86,10.6 153.99,10.65 154.03,10.67 154.14,10.72 154.18,10.73 154.18,10.73 154.25,10.76 154.3,10.78 154.3,10.78 155.4,11.24 155.42,11.25 155.47,11.27 155.53,11.29 155.63,11.33 155.7,11.36 155.71,11.36 155.76,11.39 156.74,11.39 158.82,12.41 159.17,12.76 159.17,12.76 159.32,12.91 161.57,15.16 161.57,16.17 161.57,19.35 161.46,19.46 161.46,27.05 160.88,27.62 160.88,32.14 163.9,35.15 163.9,35.15 163.95,35.21 164.9,35.21 165.07,35.38 166.57,35.38 166.93,35.01 166.93,34.85 v5(167.03,34.75)
  BOTTOM w0.076: 166.62,35.33 166.62,35.35 166.6,35.37 166.6,35.73 166.46,35.86 166.46,36.55 166.44,36.57 166.44,36.72 166.54,36.96 166.54,37.29 166.35,37.47 166.22,37.47 UC1.AC4
  BOTTOM w0.091: v5(167.03,34.75) 166.94,34.85 166.94,34.98 166.62,35.3 166.62,35.33 ; CT187.2 29.17,48.89 29.17,46.73 28.75,46.31 28.75,46.29 28.37,45.9 28.35,45.9 28.01,45.57 28.01,44.95 28.11,44.85 v5(28.22,44.85)
CPU_DP2_N0_C: length 2.5
  BOTTOM w0.091: UT1.AB7 28.87,51.47 28.87,51.06 28.68,50.87 28.68,50.74 29.25,50.17 CT187.1
CPU_DP2_N1: length 186.2
  IN3 w0.079: v5(165.86,34.31) 165.77,34.4 165.73,34.4 165.69,34.44 165.25,34.44 165.22,34.42 164.28,34.42 161.68,31.82 161.68,28.78 161.67,28.78 161.67,28.39 162.24,27.82 162.24,19.79 162.36,19.67 162.36,15.85 162.36,15.84 162.36,15 162.36,14.83 160.7,13.17 158.97,11.45 158.65,11.3 158.64,11.3 158.33,11.2 158.31,11.19 158.3,11.18 158.22,11.15 158.21,11.14 157.92,10.99 157.76,10.91 157.75,10.91 157.72,10.9 157.59,10.83 157.03,10.6 155.92,10.6 155.9,10.6 155.84,10.57 155.78,10.55 155.74,10.53 155.73,10.52 155.34,10.36 155.3,10.35 154.96,10.2 154.61,10.06 154.56,10.04 153.58,9.63 153.47,9.59 149.87,5.99 127.19,5.99 126.61,6.56 119.3,6.56 118.74,6 113.2,6 112.64,6.56 91.12,6.56 87.78,8.79 82.91,10.8 81.84,11.88 77.39,11.88 74.05,13.26 70.95,13.26 65.74,18.48 65.74,19.41 63.86,21.3 63.86,22.92 62.7,24.07 62.7,25.98 60.12,28.56 60.12,29 56.38,32.74 55.3,32.74 52.85,35.2 50.03,35.2 47.65,37.58 44.75,37.58 44.41,37.93 42.4,37.93 40.55,39.78 39.47,40.22 35.58,40.22 35.05,40.44 34.75,40.74 30.85,40.74 27.41,44.18 27.41,44.18 27.39,44.2 v5(27.28,44.2)
  BOTTOM w0.076: 165.81,35.47 165.81,35.48 165.81,35.49 165.81,35.49 165.81,35.61 165.92,35.71 166.03,35.71 UC1.AC1
  BOTTOM w0.091: 165.81,35.47 166.27,35.01 166.27,34.64 166.08,34.44 166.03,34.44 165.98,34.39 165.94,34.39 v5(165.86,34.31) ; CT180.2 27.73,48.82 27.73,46.63 27.19,46.09 27.19,45.65 27.18,45.64 27.18,45.09 27.19,45.08 27.19,44.92 27.14,44.87 27.14,44.47 27.28,44.33 v5(27.28,44.2)
CPU_DP2_N1_C: length 2.3
  BOTTOM w0.091: UT1.AC9 27.72,51.36 27.67,51.41 27.59,51.41 27.5,51.32 27.5,51.03 27.74,50.8 27.74,49.72 CT180.1
CPU_DP2_N2: length 181.5
  IN3 w0.079: v5(26.76,45.42) 26.76,45.3 26.83,45.23 27.06,45.23 27.29,45.46 28.92,45.46 31.85,42.54 33.5,42.54 33.86,42.89 34.25,43.05 35.69,43.05 36.57,42.18 40.33,42.18 41.38,41.74 43.13,39.99 47.84,39.99 47.92,39.92 49.33,39.34 50.03,38.64 54.04,36.97 55.1,35.92 56.36,35.92 64.81,27.47 64.81,26.3 65.38,25.72 65.38,25.32 65.9,24.8 65.9,22.08 72.59,15.39 74.03,15.39 77.35,14.01 82.7,14.01 83.88,12.83 84.79,12.83 90.02,10.64 91.5,10.64 91.51,10.66 92.45,10.66 92.46,10.64 97.64,10.64 99.64,9.69 101.57,8.77 118.66,8.77 118.99,9.1 129.81,9.1 129.98,9.27 150.39,9.27 151.24,10.13 151.33,10.22 151.53,10.41 151.73,10.61 151.79,10.67 152.53,11.41 152.53,11.42 154.35,12.13 155.63,12.64 156.43,12.64 157.88,13.31 157.89,13.35 158.3,13.54 158.63,13.87 158.63,13.87 158.94,14.19 158.94,16.98 159.98,18.02 159.98,18.02 159.98,18.1 159.98,19.11 160.23,19.35 160.23,19.58 160.24,19.6 160.24,20.83 160.25,20.84 160.25,21.32 160.25,26.21 159.66,26.79 159.66,32.64 159.75,32.73 159.75,32.74 161.81,34.8 162.08,35.06 162.26,35.25 162.27,35.25 163.02,36 163.02,36.27 163.04,36.33 163.9,37.18 163.9,37.18 164,37.28 164.79,37.28 164.81,37.3 164.86,37.3 164.93,37.36 v5(164.93,37.61)
  BOTTOM w0.091: CT179.2 26.82,48.78 26.82,46.38 26.5,46.06 26.5,45.54 26.62,45.42 v5(26.76,45.42) ; UC1.AE4 v5(164.93,37.61)
CPU_DP2_N2_C: length 2.4
  BOTTOM w0.091: UT1.AB11 27.02,51.48 27.02,50.45 26.82,50.26 26.82,49.75 CT179.1
CPU_DP2_N3: length 187.8
  IN3 w0.079: v5(26.89,43.98) 26.89,43.86 30.45,40.3 37.58,38.19 41.09,37.84 42.16,36.78 44.11,36.78 44.28,36.61 47.24,36.61 49.73,34.13 52.52,34.13 55.01,31.65 56.01,31.65 58.2,29.46 60.5,25.93 61.61,24.83 61.61,23.67 62.85,22.42 62.85,20.3 63.21,19.95 63.21,19.49 65.03,17.67 65.14,17.67 71.92,10.88 80.6,10.88 82.28,9.2 82.35,9.16 83.43,8.52 86.2,7.76 89.37,5.8 90.02,5.63 90.03,5.63 90.26,5.56 90.58,5.48 112.35,5.48 112.85,4.98 150.32,4.98 154.16,8.83 156.11,9.63 157.22,9.63 158.5,10.16 159.53,10.64 163.8,14.91 163.8,15.07 163.8,21.05 163.8,21.05 163.8,23.88 163.81,23.88 163.81,26.01 163.8,26.01 163.8,27.87 163.61,28.5 163.61,28.5 163.5,28.83 162.76,29.98 162.76,31.49 164.55,33.28 164.86,33.28 164.98,33.4 v5(165.01,33.4)
  BOTTOM w0.076: UC1.AE1 165.01,35.76 165.01,35.91 164.93,35.98 164.82,35.98 164.68,35.84 164.68,35.15 164.7,35.13 164.7,35.11
  BOTTOM w0.091: v5(26.89,43.98) 26.76,43.98 26.48,44.26 26.48,44.57 25.85,45.2 25.85,46.42 26.03,46.61 26.03,46.8 25.85,46.99 25.85,47.31 26.05,47.51 26.05,47.67 25.86,47.86 25.86,47.94 25.54,48.25 25.54,48.46 25.62,48.53 25.81,48.53 25.9,48.63 CT181.2 ; v5(165.01,33.4) 164.91,33.31 164.8,33.31 164.7,33.41 164.7,35.11
CPU_DP2_N3_C: length 2.4
  BOTTOM w0.091: CT181.1 25.7,49.76 25.7,49.89 25.87,50.07 25.87,50.77 26.13,51.03 26.13,51.32 26.05,51.4 25.94,51.4 25.88,51.34 UT1.AC13
CPU_DP2_P0: length 187
  IN3 w0.079: v5(166.65,34.75) 166.66,34.75 166.73,34.83 166.73,34.93 166.48,35.18 165.15,35.18 164.98,35.01 164.04,35.01 161.09,32.05 161.09,27.71 161.66,27.14 161.66,19.55 161.77,19.43 161.77,16.09 161.77,15.08 159.44,12.75 159.33,12.64 158.96,12.27 157.1,11.32 157.08,11.31 156.78,11.19 155.8,11.19 155.71,11.15 155.66,11.13 155.58,11.1 155.51,11.06 155.48,11.05 155.18,10.93 154.98,10.84 154.73,10.74 154.41,10.61 154.37,10.59 154.32,10.57 154.25,10.54 154.22,10.53 154.11,10.48 153.97,10.43 153.89,10.39 153.84,10.37 153.25,10.13 153.14,10.08 152.86,9.81 152.49,9.43 150.96,7.9 130.54,7.9 130.38,7.74 119.56,7.74 119.22,7.4 117.53,7.4 116.76,6.63 113.5,6.63 112.99,7.14 99.04,7.14 98.69,7.5 91.02,7.5 89.17,8.74 88.37,9.27 83.14,11.43 82.09,12.49 77.46,12.49 74.14,13.86 71.22,13.86 66.32,18.76 66.32,19.66 64.45,21.53 64.45,24.02 63.39,25.09 63.39,26.21 61.07,28.53 61.07,29.07 55.77,34.38 54.7,34.38 53.27,35.81 49.11,37.54 48.53,38.1 48.24,38.22 44.99,38.22 44.7,38.51 42.66,38.51 41.2,39.97 41.19,39.97 40.89,40.27 39.59,40.81 35.7,40.81 35.38,40.94 34.99,41.33 31.33,41.33 28.06,44.6 27.97,44.6 v5(27.95,44.58)
  BOTTOM w0.076: UC1.AC3 166.06,37.23 166.13,37.31 166.28,37.31 166.37,37.22 166.37,36.99 166.28,36.75 166.28,36.5 166.3,36.48 166.3,35.79 166.43,35.66 166.43,35.37 166.41,35.35 166.41,35.33
  BOTTOM w0.091: CT186.2 28.97,48.7 28.97,46.81 27.81,45.65 27.81,44.86 27.95,44.72 v5(27.95,44.58) ; v5(166.65,34.75) 166.74,34.84 166.74,34.89 166.41,35.22 166.41,35.33
CPU_DP2_P0_C: length 2.5
  BOTTOM w0.091: CT186.1 28.69,49.58 28.8,49.68 28.82,49.68 29.05,49.92 29.05,50.09 28.48,50.66 28.48,50.87 28.41,50.94 28.41,51.31 28.48,51.38 28.57,51.38 28.64,51.31 UT1.AC7
CPU_DP2_P1: length 186.1
  IN3 w0.079: v5(165.86,34.69) 165.81,34.65 165.16,34.65 165.14,34.62 164.2,34.62 161.48,31.9 161.48,28.86 161.47,28.86 161.47,28.31 162.04,27.74 162.04,19.71 162.16,19.59 162.16,15.93 162.16,14.92 159.65,12.41 158.97,11.74 158.97,11.74 158.85,11.62 158.64,11.52 158.25,11.39 158.15,11.34 158.14,11.34 158.11,11.32 157.82,11.17 157.74,11.13 157.64,11.08 157.5,11.02 156.99,10.8 155.88,10.8 155.85,10.79 155.83,10.78 155.74,10.75 155.69,10.72 154.53,10.24 154.48,10.22 153.51,9.82 153.43,9.79 153.39,9.77 153.36,9.76 149.79,6.19 127.27,6.19 126.7,6.76 119.22,6.76 118.66,6.2 113.28,6.2 112.72,6.76 91.18,6.76 87.87,8.96 83.03,10.97 81.92,12.08 77.43,12.08 74.09,13.46 71.04,13.46 65.94,18.56 65.94,19.5 64.06,21.38 64.06,23 62.9,24.15 62.9,26.07 60.33,28.64 60.33,29.09 56.47,32.94 55.39,32.94 52.93,35.4 50.11,35.4 47.73,37.78 44.84,37.78 44.49,38.13 42.49,38.13 40.67,39.95 39.51,40.42 35.62,40.42 35.16,40.61 34.83,40.94 30.93,40.94 27.55,44.33 v5(27.55,44.47)
  BOTTOM w0.076: 165.9,34.65 v5(165.86,34.69) ; UC1.AC2 166.06,36.09 165.87,35.9 165.84,35.9 165.63,35.69 165.63,35.57 165.61,35.55 165.61,35.39 165.67,35.33
  BOTTOM w0.091: 165.67,35.33 166.07,34.93 166.07,34.72 166,34.65 165.9,34.65 ; v5(27.55,44.47) 27.43,44.47 27.34,44.56 27.34,44.79 27.4,44.84 27.4,46 27.94,46.54 27.94,48.78 CT183.2
CPU_DP2_P1_C: length 2.4
  BOTTOM w0.091: UT1.AB9 27.88,51.7 27.94,51.63 27.94,49.75 CT183.1
CPU_DP2_P2: length 181.6
  IN3 w0.079: v5(26.49,45.15) 26.62,45.15 26.74,45.03 27.15,45.03 27.37,45.26 28.84,45.26 31.76,42.33 33.59,42.33 33.82,42.57 33.82,42.57 33.97,42.72 34.29,42.85 35.61,42.85 36.48,41.98 40.29,41.98 41.27,41.57 43.05,39.79 47.76,39.79 47.8,39.75 49.22,39.17 49.92,38.47 53.93,36.8 55.02,35.72 56.28,35.72 64.61,27.39 64.61,26.21 65.18,25.64 65.18,25.24 65.7,24.72 65.7,22 72.51,15.19 73.99,15.19 77.31,13.81 82.61,13.81 83.8,12.63 84.75,12.63 89.98,10.44 91.58,10.44 91.6,10.45 92.37,10.45 92.38,10.44 97.59,10.44 99.56,9.51 101.52,8.57 118.74,8.57 119.07,8.9 129.89,8.9 130.06,9.07 150.47,9.07 151.39,9.98 151.45,10.05 151.87,10.47 152,10.6 152.44,11.04 152.65,11.25 155.67,12.44 156.47,12.44 157.97,13.13 158.25,13.28 158.44,13.4 158.75,13.71 159.14,14.1 159.14,16.89 160.19,17.94 160.19,18.02 160.19,19.03 160.43,19.27 160.43,19.5 160.44,19.51 160.44,20.75 160.45,20.75 160.45,21.4 160.45,26.29 159.87,26.87 159.87,32.56 161.9,34.59 162.16,34.86 162.41,35.1 162.41,35.11 163.22,35.91 163.22,36.22 163.98,36.98 164.08,37.08 164.83,37.08 164.91,37 v5(164.93,37)
  BOTTOM w0.091: v5(26.49,45.15) 26.49,45.16 26.49,45.26 26.3,45.46 26.3,46.15 26.62,46.47 26.62,48.81 CT185.2
CPU_DP2_P2_C: length 2.4
  BOTTOM w0.091: UT1.AC11 26.8,51.34 26.74,51.4 26.65,51.4 26.58,51.33 26.58,51.03 26.81,50.8 26.81,50.54 26.62,50.34 26.62,49.72 CT185.1
CPU_DP2_P3: length 187.8
  IN3 w0.079: v5(26.62,43.71) 26.76,43.71 28.53,41.93 28.54,41.93 30.35,40.12 37.54,37.99 41,37.65 42.08,36.58 44.03,36.58 44.2,36.41 47.16,36.41 49.64,33.93 52.44,33.93 54.92,31.45 55.93,31.45 58.04,29.33 60.35,25.81 61.41,24.75 61.41,23.58 62.65,22.34 62.65,20.22 63,19.87 63,19.41 64.95,17.46 65.06,17.46 71.84,10.68 80.52,10.68 82.17,9.03 83.35,8.33 86.12,7.57 89.29,5.62 89.7,5.5 90.21,5.36 90.37,5.32 90.55,5.28 112.27,5.28 112.76,4.78 150.4,4.78 154.28,8.66 156.15,9.43 157.26,9.43 158.58,9.98 159.65,10.48 164,14.82 164,14.99 164,20.96 164,20.97 164,23.79 164.01,23.79 164.01,26.09 164,26.09 164,27.91 164.01,27.91 163.8,28.56 163.8,28.56 163.72,28.83 163.69,28.91 162.96,30.04 162.96,31.41 164.63,33.08 164.94,33.08 164.95,33.08 v5(165.01,33.02)
  BOTTOM w0.076: UC1.AE2 164.93,36.33 164.51,35.91 164.51,35.15 164.49,35.13 164.49,35.11
  BOTTOM w0.091: CT182.2 25.34,48.15 v7(25.49,48) 25.64,47.85 25.64,45.12 26.27,44.49 26.27,44.17 26.62,43.82 v5(26.62,43.71) ; v5(165.01,33.02) 164.92,33.11 164.71,33.11 164.49,33.33 164.49,35.11
CPU_DP2_P3_C: length 2.4
  BOTTOM w0.091: CT182.1 25.49,49.71 25.49,49.98 25.67,50.15 25.67,51.03 25.65,51.05 25.65,51.47 UT1.AB13
CPU_POPIRCOMP: length 1.6
  TOP w0.305: RC15.1 146.71,51.23 146.71,51.43 v2(146.87,51.59)
  IN1 w0.305: v4(146.46,51.83) 146.7,51.59 v2(146.87,51.59)
  IN3 w0.305: v5(146.92,52.07) 146.75,51.89 146.52,51.89 v4(146.46,51.83)
CPU_SPI_0_CLK: length 8.9
  BOTTOM w0.081: RC21.2 RC187.1 131.15,59.76 131.29,59.9 131.95,59.9 132.94,58.91 134.77,58.91 134.8,58.94 136.64,58.94 136.87,58.71 138.28,58.71 UC1.CH37
CPU_SPI_0_CS#0: length 172.1
  TOP w0.081: v6(48.5,10.52) 48.24,10.27 45.13,10.27 44.98,10.12 44.98,10 45.13,9.86 46.08,9.86 46.17,9.77 46.17,9.59 46.08,9.5 45.13,9.5 45.05,9.42 45.05,9.04 45.13,8.96 v3(45.68,8.96) 46.44,8.96 46.53,9.04 46.53,9.77 46.62,9.86 48.55,9.86 48.92,10.23 48.92,10.8 49.01,10.89 UC3.1 ; RC556.1 55.77,24.54 55.91,24.39 v2(56.27,24.39)
  IN1 w0.064: v4(105.74,33.75) 105.74,33.25 104.5,32.01 104.5,31.86 104.48,31.84 104.48,30.88 104.42,30.81 104.42,30.8 99.5,25.88 96.58,25.88 95.69,24.99 93.06,24.99 93.06,24.99 91.19,24.99 88.02,21.82 88.02,21.32 87.06,20.36 80.85,20.36 79.52,21.69 79.52,22.71 79.3,22.93 79.3,23.18 77.67,24.8 77.67,25.89 74.9,28.67 66.52,28.67 65.72,27.87 61.21,27.87 59.59,26.25 58.57,26.25 57.35,25.03 56.88,25.03 56.27,24.43 v2(56.27,24.39) 56.01,24.39 55.76,24.14 55.76,24.05 v4(55.78,24.03)
  IN3 w0.064: v4(55.78,24.03) 55.78,24.3 54.73,25.34 53.1,25.34 52.86,25.1 52.86,24.46 52.82,24.43 52.82,24.31 52.79,24.28 52.62,24.28 52.56,24.35 52.56,24.39 52.5,24.45 52.36,24.45 52.3,24.39 52.3,21.72 52.73,21.28 52.73,20.57 51.97,19.8 51.55,19.8 51.32,19.58 51.32,18.79 49.62,17.09 49.62,16.94 49.44,16.76 49.44,15.4 49.43,15.39 49.43,14.95 48.29,13.81 48.29,13.67 48.16,13.54 48.16,10.62 48.25,10.52 v6(48.5,10.52) ; v4(105.74,33.75) 105.55,33.94 104.98,33.94 104.53,33.49 102.7,33.49 102.39,33.81 102.39,34.32 101.73,34.98 101.73,35.73 102.88,36.89 102.88,40.48 103.92,41.52 103.92,43.23 103.78,43.36 103.78,48.16 110.26,54.63 110.26,55.24 110.6,55.59 111.84,55.59 112.34,56.1 113.75,56.1 114.36,56.71 115.33,56.71 117.74,59.12 119.75,59.12 121.38,60.75 121.38,60.84 121.25,60.97 121.16,60.97 119.74,59.55 119.65,59.55 119.51,59.69 119.51,59.77 121.79,62.05 122.49,62.05 122.91,62.47 122.91,63.47 123.3,63.87 127.67,63.87 129.02,62.52 129.02,62.11 129.77,61.36 v5(130.24,61.36)
  BOTTOM w0.081: UC1.CG36 139.33,58.51 138.62,59.22 137.05,59.22 136.67,59.6 135.04,59.6 134.09,60.54 132.42,60.54 132.32,60.44 131.87,60.44 130.94,61.38 RC31.2 130.35,61.47 v5(130.24,61.36)
  BOTTOM w0.089: v6(48.5,10.52) 48.2,10.23 JSPI1.5
CPU_SPI_0_CS#1: length 158.4
  IN1 w0.064: v4(54.81,21.55) 54.81,21.59 55.03,21.81 56.12,21.81 56.26,21.95 57.14,21.95 57.89,22.7 58.79,22.7 58.91,22.57 60.52,22.57 60.59,22.64 66.59,22.64 66.65,22.58 66.65,22.39 66.59,22.33 63.22,22.33 63.16,22.27 63.16,22.11 63.22,22.05 67.54,22.05 68.48,21.12 74.89,21.12 75.23,20.77 77.88,20.77 78.61,20.03 78.61,19.95 78.16,19.49 78.16,19.41 78.29,19.27 78.38,19.27 78.83,19.72 78.92,19.72 79.06,19.59 79.06,19.5 78.6,19.05 78.6,18.96 78.74,18.82 78.82,18.82 79.28,19.28 79.36,19.28 80,18.65 87.96,18.65 88.72,19.4 89,19.4 90.59,20.98 91.27,20.98 91.98,21.69 91.98,21.69 92.21,21.92 92.98,21.92 93.45,22.39 102.49,22.39 105.9,25.8 105.9,30.52 107.21,31.83 v4(107.21,32.98)
  IN3 w0.064: v4(107.21,32.98) 107.18,32.98 106.92,33.24 105.82,33.24 105.56,32.98 102.4,32.98 101.77,33.62 101.77,34.07 101.24,34.6 101.24,36.57 102.36,37.69 102.36,40.5 103.54,41.68 103.54,43.07 103.4,43.2 103.4,48.4 109.88,54.87 109.88,55.44 111.39,56.95 112.36,56.95 112.62,56.69 113.42,56.69 113.93,57.2 115.05,57.2 119.27,61.41 119.85,61.41 122.74,64.3 128.98,64.3 131,62.29 131,61.76 131.21,61.55 131.95,61.55 132.42,61.08 132.42,60.18 v5(132.44,60.17) ; v5(50.2,9.9) 50.06,10.03 50.06,11.99 49.73,12.32 49.73,13.51 50.57,14.35 50.57,15.06 51.68,16.17 51.76,16.17 52.41,16.82 52.41,18.26 52.45,18.29 52.45,18.4 52.67,18.63 52.78,18.63 54.55,20.4 54.55,21.39 54.7,21.54 54.8,21.54 v4(54.81,21.55)
  BOTTOM w0.081: v5(132.44,60.17) 133.05,59.56 134.56,59.56 134.92,59.2 136.77,59.2 136.99,58.97 138.42,58.97 138.98,58.42 138.98,57.7 UC1.CG35
  BOTTOM w0.089: v5(50.2,9.9) JSPI1.1
CPU_SPI_0_D0: length 7.8
  TOP w0.081: v2(138.59,55.22) 138.36,55.45 v1(137.67,55.45) 137.51,55.29 135.9,55.29 135.78,55.16 135.78,54.99 RC35.1 135.32,54.87 135.1,55.08 RC23.2
  IN1 w0.064: v4(139.42,55.82) 139.17,55.82 138.59,55.24 v2(138.59,55.22)
  IN3 w0.064: v4(139.42,55.82) 139.69,55.82 v5(139.75,55.88)
  BOTTOM w0.081: UC1.CF36 139.98,57.55 139.67,57.25 139.67,56.56 139.57,56.47 139.57,56.27 139.73,56.12 139.73,55.91 v5(139.75,55.88)
CPU_SPI_0_D1: length 7.5
  BOTTOM w0.081: UC1.CF37 139.98,59.1 139.6,59.49 138.66,59.49 138.43,59.72 137.01,59.72 136.36,60.36 135.2,60.36 134.33,61.24 134.33,61.26 134.28,61.3 RC22.2
CPU_SPI_0_D2: length 5.4
  TOP w0.081: v2(138.86,54.84) 138.33,54.84 138.17,55 136.94,55 RC24.2 RC36.1
  IN1 w0.064: v4(139.91,55.43) 139.12,55.43 138.88,55.19 138.88,55.13 138.88,55.12 138.88,54.85 v2(138.86,54.84)
  IN3 w0.064: v4(139.91,55.43) v5(140.17,55.69)
  BOTTOM w0.081: UC1.CF34 140.17,56.18 v5(140.17,55.69)
CPU_SPI_0_D3: length 11.6
  IN1 w0.064: v4(131.42,59.03) 131.53,59.03 133.22,57.34 136.77,57.34 137.95,58.52 v4(138.04,58.52)
  IN3 w0.064: v5(139.33,56.69) 138.97,57.05 138.97,58 138.49,58.47 138.09,58.47 v4(138.04,58.52) ; v4(131.42,59.03) 131.15,58.76 v5(131.15,58.49)
  BOTTOM w0.081: 130.71,58.49 v5(131.15,58.49)
  BOTTOM w0.089: RC37.1 130.71,58.49
CPU_SPI_CLK: length 162
  TOP w0.081: v2(40.26,12.58) 40.26,13.09 40.6,13.43 RC40.1 ; v6(54.44,24.13) 54.02,24.13 CC111.1 53.76,24.22 53.44,24.54 RC524.1
  IN1 w0.064: v2(40.26,12.58) 40.26,12.49 40.78,11.97 40.85,11.9 41.59,11.9 42.68,10.82 43.79,10.82 44.6,10.01 45.73,10.01 46.89,8.85 48.06,8.85 v4(48.47,9.26) ; v6(54.44,24.13) 54.44,24.29 55.97,25.82 56.43,25.82 58.35,27.74 59.43,27.74 61.24,29.56 65.25,29.56 65.57,29.87 75.35,29.87 75.39,29.83 75.39,29.83 78.77,26.46 78.77,25.52 78.77,25.52 78.77,25.3 78.77,25.29 78.77,25.25 79.68,24.35 79.72,24.35 79.72,24.35 80.14,24.35 82.68,21.81 86.38,21.81 86.54,21.97 90.65,26.07 93.51,26.07 94.79,26.07 95.29,26.57 95.44,26.57 96.02,27.15 98.96,27.15 102.99,31.18 102.99,31.18 103.09,31.28 103.09,32.74 104.06,33.71 104.06,33.94 104.42,34.3 v4(104.42,35.21)
  IN3 w0.064: v6(54.44,24.13) 54.44,24.45 54.3,24.59 53.44,24.59 53.14,24.3 53.14,24.11 53.04,24.01 53.04,22.59 53.06,22.58 53.06,22.53 52.81,22.28 52.81,22.19 52.87,22.13 53.07,22.13 53.13,22.07 53.13,21.93 53.07,21.86 52.86,21.86 52.8,21.8 52.8,21.66 52.86,21.6 52.92,21.6 52.98,21.54 52.98,21.48 53.05,21.41 53.05,20.07 50.35,17.37 50.35,16.37 49.95,15.97 49.95,15.43 49.87,15.35 49.87,14.82 48.66,13.61 48.66,13.45 48.52,13.45 48.48,13.41 48.48,13.22 48.51,13.19 48.66,13.19 48.66,12.84 48.48,12.66 48.48,11.19 48.92,10.75 48.92,10.3 v5(48.92,10.3) 48.6,9.98 48.6,9.55 48.47,9.42 v4(48.47,9.26) ; v4(104.42,35.21) 104.18,35.45 103.88,35.45 103.82,35.51 103.82,36.21 103.23,36.8 103.23,40.21 103.97,40.95 103.97,41.13 104.24,41.39 104.24,43.09 104.24,43.36 104.1,43.49 104.1,47.74 110.69,54.33 110.96,54.33 111.12,54.33 111.72,54.93 111.76,54.93 111.77,54.94 112.08,54.94 112.08,54.93 112.72,54.93 112.73,54.94 113.15,54.94 113.58,55.37 113.66,55.37 114.6,56.3 115.37,56.3 116.24,57.17 116.47,57.17 117.3,58 117.61,58 117.84,58.23 117.84,58.74 117.9,58.8 118.29,58.8 118.35,58.74 118.35,58.31 118.53,58.13 118.78,58.13 118.88,58.23 118.88,58.59 119.1,58.8 119.88,58.8 121.54,60.46 121.63,60.46 121.74,60.35 121.74,60.26 119.81,58.34 119.81,58.25 119.94,58.11 120.03,58.11 121.64,59.72 121.73,59.72 121.86,59.59 121.86,59.5 120.65,58.28 120.65,58.2 120.78,58.06 120.87,58.06 121.69,58.88 121.78,58.88 121.91,58.75 121.91,58.66 121.51,58.26 121.51,58.17 121.65,58.03 121.73,58.03 122.18,58.48 122.18,61.15 123.28,62.25 123.28,63.35 123.48,63.55 127.54,63.55 128.7,62.39 128.7,61.98 130.17,60.51 v5(130.17,60.37)
  BOTTOM w0.081: RC21.1 130.53,60.26 130.44,60.35 130.44,60.68 CC73.1 130.17,60.83 v5(130.17,60.37)
  BOTTOM w0.089: JSPI1.4 v1(48.7,9.99) 48.7,10.07 v5(48.92,10.3)
CPU_SPI_D0: length 164.5
  TOP w0.081: v2(39.92,12.9) 39.92,13.13 39.52,13.53 39.42,13.53 39.18,13.77 39.18,14.47 39.41,14.7 RC42.1 ; RC525.1 53.31,23.56 53.38,23.49 53.44,23.34 53.58,23.2 53.84,23.2 54.12,22.91 54.12,22.16 v2(54.16,22.12) ; v2(133.32,52.17) v1(133.63,52.48) 133.81,52.67 133.81,53.89 134.07,54.15 134.07,54.93 RC23.1
  IN1 w0.064: v4(132.98,52.2) 133.01,52.17 v2(133.32,52.17) ; v2(39.92,12.9) 39.92,12.48 39.94,12.46 39.94,12.28 40.56,11.65 40.65,11.65 41.01,11.29 41.55,11.29 41.94,10.9 41.94,10.69 43.27,9.36 45.63,9.36 46.46,8.54 48.19,8.54 48.51,8.85 48.95,8.85 v4(49.52,8.29) ; v4(107.08,35.28) 106.77,35.28 106.48,34.98 106.48,34.41 106.53,34.35 106.53,32.05 105.27,30.78 105.27,29.67 104.68,29.08 104.6,29.08 104.41,29.27 104.32,29.27 104.18,29.13 104.18,29.05 104.37,28.86 104.37,28.78 103.17,27.57 103.17,27.57 102.99,27.39 102.99,24.3 101.73,23.04 92.87,23.04 92.42,22.58 91.97,22.58 91.34,21.95 91.34,21.95 91.11,21.72 91.01,21.62 89.51,21.62 87.17,19.28 80.26,19.28 78.05,21.49 75.48,21.49 75.42,21.55 75.42,21.75 75.48,21.81 77.37,21.81 77.43,21.87 77.43,22.06 77.37,22.12 75.01,22.12 74.89,22.25 74.68,22.25 74.58,22.35 68.48,22.35 66.76,24.07 63.16,24.07 62.31,24.92 58.57,24.92 57.63,23.97 57.11,23.97 55.62,22.48 54.9,22.48 54.72,22.3 v4(54.52,22.3) 54.34,22.3 v2(54.16,22.12)
  IN3 w0.064: v4(54.52,22.3) 54.47,22.36 54.47,23.65 54.53,23.71 54.71,23.71 54.77,23.65 54.77,22.82 54.83,22.76 55.21,22.76 55.27,22.7 55.27,22.56 55.21,22.5 54.92,22.5 54.86,22.44 54.86,22.16 53.87,21.17 53.87,21.14 53.76,21.03 53.76,20.04 53.69,19.96 53.69,19.96 50.86,17.14 50.86,16.91 50.92,16.84 51.06,16.84 51.12,16.91 51.12,17.03 52.04,17.95 52.13,17.95 52.2,17.87 52.2,17.73 51.38,16.91 51.38,16.52 50.46,15.6 50.46,15.22 50.37,15.14 50.37,14.43 49.54,13.59 49.54,13.03 49.24,12.73 49.24,12.47 49.82,11.89 49.82,10.01 49.62,9.81 49.49,9.81 49.43,9.74 49.12,9.74 49.05,9.68 49.05,9.53 49.1,9.49 v5(49.68,9.49) ; v4(107.08,35.28) 107.08,35.58 105.5,37.16 105.5,38.8 105.67,38.97 105.67,39.93 106.32,40.59 106.32,47.89 111.3,52.87 111.72,52.87 112.32,53.47 114.59,53.47 115.33,54.21 117.01,54.21 117.78,54.97 118.02,54.97 118.51,55.46 119.84,55.46 120.21,55.83 121.67,55.83 122.45,55.04 124.06,55.04 125.12,53.99 125.78,53.99 126.82,52.95 127.19,52.95 127.98,52.16 131.88,52.16 131.94,52.23 132.95,52.23 v4(132.98,52.2) ; v4(49.52,8.29) 49.61,8.2 v5(49.94,8.2)
  BOTTOM w0.089: v5(49.94,8.2) 49.7,8.44 JSPI1.2 49.7,9.47 v5(49.68,9.49)
CPU_SPI_D1: length 166.7
  TOP w0.081: RC526.1 53.4,21.25 53.59,21.43 v2(53.59,22.36) ; v6(49.39,10.19) 49.61,9.97 50.96,9.97 51.07,9.86 51.07,9.69 50.97,9.59 47.08,9.59 46.97,9.48 46.97,9.28 47.21,9.04 v1(48.79,9.04) 51.14,9.04 51.33,9.24 RC43.1
  IN1 w0.064: v2(53.59,22.36) 53.59,22.49 v4(53.75,22.65) 53.97,22.87 55.46,22.87 57.03,24.44 57.29,24.44 58.22,25.36 63.5,25.36 64.56,26.43 65,26.43 65.05,26.48 65.05,26.48 66.79,28.22 74.76,28.22 77.29,25.69 77.29,24.54 77.3,24.54 77.3,23.85 78.1,23.04 78.1,22.47 80.67,19.9 87.14,19.9 88.69,21.45 88.69,21.95 90.1,23.36 92.66,23.36 92.72,23.43 92.73,23.43 92.77,23.47 101.15,23.47 101.37,23.69 101.37,26.99 104.88,30.51 104.88,31.73 105.82,32.67 v4(105.94,32.67)
  IN3 w0.064: v5(132.72,61.26) 132.09,61.89 132.09,62.22 129.79,64.52 122.69,64.52 119.92,61.75 119.33,61.75 115.3,57.72 114.19,57.72 113.34,56.88 112.7,56.88 112.44,57.14 111.31,57.14 109.69,55.52 109.69,54.95 103.21,48.48 103.21,43.12 103.35,42.99 103.35,41.76 102.17,40.58 102.17,40.42 102.17,37.77 100.99,36.59 100.99,34.58 101.58,33.99 101.58,33.54 102.32,32.79 105.82,32.79 v4(105.94,32.67) ; v4(53.75,22.65) 53.43,22.65 53.36,22.72 53.36,23.88 53.42,23.94 53.56,23.94 53.63,23.88 53.63,23.1 53.69,23.04 53.83,23.04 53.89,23.1 53.89,23.83 53.96,23.9 54.13,23.9 54.19,23.83 54.19,22.57 53.49,21.87 53.49,21.16 53.43,21.09 53.43,21.09 53.37,21.03 53.37,20.89 53.43,20.83 53.49,20.83 53.56,20.77 53.56,20.63 53.49,20.57 53.43,20.57 53.37,20.5 53.37,20.36 53.43,20.3 53.49,20.3 53.56,20.24 53.56,20.13 50.67,17.24 50.67,16.23 50.27,15.84 50.27,15.3 50.18,15.22 50.18,14.5 49.35,13.67 49.35,13.11 49.05,12.81 49.05,12.35 49.11,12.28 49.11,11.01 49.17,10.95 49.31,10.95 49.37,11.01 49.37,11.71 49.43,11.77 49.56,11.77 49.63,11.71 49.63,10.42 v6(49.39,10.19)
  BOTTOM w0.081: v5(132.72,61.26) 132.99,61.26 133.07,61.33 133.27,61.33 133.29,61.3 RC22.1
  BOTTOM w0.089: JSPI1.3 49.2,8.75 49.2,9.99 v6(49.39,10.19)
CPU_SPI_D2: length 170.4
  TOP w0.081: v6(50.7,12.8) 50.7,12.77 50.61,12.69 48.87,12.69 48.72,12.83 48.72,13.9 48.85,14.02 50.81,14.02 50.92,14.14 50.92,15.45 51.01,15.54 51.17,15.54 51.27,15.44 51.27,13.94 51.36,13.85 51.53,13.85 51.63,13.95 v1(51.63,14.49) 51.63,15.24 51.72,15.33 51.89,15.33 51.98,15.23 51.98,14.59 52.07,14.5 52.64,14.5 52.73,14.41 52.73,14.23 52.64,14.14 52.5,14.14 52.41,14.05 52.41,14.02 RC39.1 ; v2(134.26,52.16) 134.45,52.36 134.45,52.55 135.79,53.89 136.5,53.89 136.8,54.19 RC24.1
  IN1 w0.064: v2(134.26,52.16) 133.83,52.16 v4(133.78,52.22) ; v4(51.87,22.04) 52.93,22.04 v2(53.14,21.83) 53.33,22.02 53.65,22.02 54.31,22.67 55.54,22.67 57.11,24.25 57.37,24.25 58.3,25.17 63.32,25.17 64.12,24.38 66.72,24.38 68.55,22.54 74.86,22.54 75.09,22.31 77.45,22.31 77.45,22.31 77.9,22.31 80.59,19.62 87.13,19.62 89.17,21.66 89.17,22.07 90.23,23.13 92.7,23.13 92.8,23.24 101.66,23.24 102.79,24.37 102.79,28.02 105.08,30.3 105.08,30.86 106.34,32.13 106.34,34.28 106.29,34.33 106.29,35.17 106.36,35.24 v4(106.36,35.61)
  IN3 w0.064: v4(133.78,52.22) 133.78,52.24 133.43,52.59 132.79,52.59 132.7,52.49 131.92,52.49 131.78,52.36 128,52.36 127.67,52.69 127.67,52.77 127.78,52.88 127.78,52.97 127.64,53.1 127.56,53.1 127.45,52.99 127.36,52.99 127.23,53.13 127.23,53.22 127.34,53.33 127.34,53.41 127.2,53.55 127.11,53.55 126.86,53.29 126.74,53.29 126.18,53.86 126.18,53.94 126.44,54.21 126.44,54.3 126.31,54.43 126.22,54.43 125.97,54.18 125.88,54.18 125.75,54.32 125.75,54.41 126,54.66 126,54.74 125.86,54.88 125.77,54.88 125.22,54.33 125.12,54.33 123.99,55.47 122.94,55.47 122.29,56.12 121.56,56.12 121.5,56.18 121.5,56.58 121.44,56.64 121.25,56.64 121.19,56.58 121.19,56.18 121.13,56.12 120.93,56.12 120.87,56.18 120.87,56.58 120.81,56.64 120.62,56.64 120.56,56.58 120.56,56.18 120.5,56.12 119.78,56.12 119.72,56.18 119.72,56.56 119.66,56.62 119.47,56.62 119.41,56.56 119.41,56.18 119.35,56.12 119.15,56.12 119.09,56.18 119.09,56.56 119.03,56.62 118.84,56.62 118.78,56.56 118.78,56.18 118.72,56.12 118.28,56.12 116.65,54.5 115.35,54.5 114.51,53.66 112.24,53.66 111.64,53.06 111.22,53.06 105.99,47.83 105.99,40.65 105.48,40.14 105.48,39.14 105.25,38.92 104.87,38.92 104.81,38.85 104.81,38.66 104.87,38.6 105.25,38.6 105.31,38.54 105.31,38.35 105.25,38.29 104.87,38.29 104.81,38.22 104.81,38.03 104.87,37.97 105.25,37.97 105.31,37.91 105.31,37.72 105.25,37.66 104.87,37.66 104.81,37.59 104.81,37.4 104.87,37.34 105.25,37.34 105.31,37.28 105.31,37.08 106.36,36.03 v4(106.36,35.61) ; v6(50.7,12.8) 50.63,12.87 50.63,13.35 51.33,14.05 51.33,14.73 53.78,17.17 54.29,17.17 55.91,18.79 55.91,20.68 56.95,21.73 56.95,22.78 56.3,23.43 56.3,24.05 54.8,25.55 52.85,25.55 52.04,24.74 52.04,22.21 v4(51.87,22.04)
  BOTTOM w0.089: v6(50.7,12.8) 50.21,12.8 48.06,10.65 48.06,10.55 47.7,10.19 JSPI1.6
CPU_SPI_D3: length 158.7
  TOP w0.081: v6(41.18,12.94) 40.96,12.72 40.78,12.72 40.63,12.57 RC41.1
  IN1 w0.064: v2(53.13,22.99) 52.57,22.99 52.32,23.24 51.92,23.24 51.68,23.48 v4(51.68,23.56) 52.58,23.56 52.69,23.66 54.63,23.66 55.3,24.33 55.3,24.64 56.01,25.35 57.4,25.35 58.49,26.44 59.46,26.44 61.11,28.09 65.68,28.09 66.44,28.86 74.97,28.86 77.86,25.97 77.86,24.88 79.29,23.46 79.73,23.46 80,23.19 80,21.48 80.93,20.55 86.98,20.55 87.63,21.2 87.63,21.7 91.11,25.18 93.14,25.18 93.14,25.18 95.61,25.18 96.5,26.07 99.4,26.07 104.07,30.73 104.07,30.74 104.29,30.96 104.29,32.42 105.24,33.36 v4(105.31,33.36)
  IN3 w0.064: v5(131.15,57.9) 131.15,57.98 130.52,58.61 130.52,59.53 130.62,59.62 130.62,61.38 130.38,61.62 130.38,61.62 130.36,61.64 129.76,61.64 129.21,62.19 129.21,62.6 127.75,64.06 122.87,64.06 121.86,63.05 121.86,62.74 118.55,59.43 117.78,59.43 115.25,56.9 113.9,56.9 113.5,56.5 112.54,56.5 112.37,56.67 111.38,56.67 110.07,55.36 110.07,54.79 103.59,48.32 103.59,43.28 103.73,43.15 103.73,41.6 102.69,40.56 102.69,37.16 101.43,35.91 101.43,34.67 101.96,34.15 101.96,33.69 102.36,33.3 105.18,33.3 105.24,33.36 v4(105.31,33.36) ; v5(47.03,9.57) 47.14,9.68 47.14,11.76 47.94,12.56 47.94,13.59 48.1,13.75 48.1,13.94 49.24,15.08 49.24,16.98 49.1,17.12 49.1,17.62 50.08,18.6 50.08,18.84 51.87,20.63 51.87,21.3 51.45,21.72 51.45,22.13 51.51,22.19 51.51,23.42 51.65,23.56 v4(51.68,23.56)
  BOTTOM w0.081: v5(47.03,9.57) 46.95,9.65 v1(46.95,10.04) 46.95,10.83 46.46,11.32 42.97,11.32 42.59,10.94 39.71,10.94 39.57,11.09 39.57,11.22 39.72,11.38 41.04,11.38 41.18,11.52 v6(41.18,12.94)
  BOTTOM w0.089: v5(47.03,9.57) 47.2,9.39 JSPI1.7
CPU_XDP_PRDY#: length 3
  BOTTOM w0.081: TP104.1 169.84,33.48 169.84,33.94 169.28,34.5 169.28,34.71 168.5,35.49 UC1.W1
CPU_XDP_PREQ#: length 1.6
  IN1 w0.064: v4(169.05,36.06) 168.71,36.06 168.66,36.11 168.52,36.11 168.5,36.1 v2(168.11,36.1)
  IN3 w0.064: v4(169.05,36.06) 168.77,36.06 v5(168.5,36.33)
CPU_XDP_TCK: length 10.6
  TOP w0.081: v2(175.03,34.48) v3(176.01,34.48)
  IN1 w0.064: v4(172.05,38.82) 172.05,38.5 v2(171.53,37.98) 171.53,35.66 172.45,34.74 173.65,34.74 173.9,34.48 v2(175.03,34.48)
  IN3 w0.064: v4(172.05,38.82) 171.69,38.82 171.48,39.03 v5(170.81,39.03)
  BOTTOM w0.081: v5(170.81,39.03) UC1.P6
CPU_XDP_TDI: length 7.3
  TOP w0.081: v2(171.53,34.77) 171.59,34.77 v3(172.54,33.83)
  IN1 w0.064: v4(170.31,38.81) 170.2,38.7 v2(170.2,38.14) 170.2,37.73 171.07,36.86 171.07,35.23 v2(171.53,34.77)
  IN3 w0.064: v4(170.31,38.81) v5(169.88,38.38)
  BOTTOM w0.081: UC1.U6 v5(169.88,38.38)
CPU_XDP_TDO: length 5.8
  TOP w0.081: v3(170.99,34.75) 170.75,34.99 v2(170.75,35.59)
  IN1 w0.064: v4(169.34,38.38) 169.38,38.38 v2(169.62,38.14) 169.62,38.04 170.88,36.78 170.88,35.72 v2(170.75,35.59)
  IN3 w0.064: v5(168.96,38.38) v4(169.34,38.38)
  BOTTOM w0.081: v5(168.96,38.38) UC1.Y5
CPU_XDP_TMS: length 8
  TOP w0.081: v2(173.29,34.39) v3(174.19,34.39)
  IN1 w0.064: v4(171.28,38.38) 171.07,38.18 v2(170.93,38.18) 170.93,37.74 171.26,37.41 171.26,35.49 172.36,34.39 v2(173.29,34.39)
  IN3 w0.064: v5(171.73,38.38) v4(171.28,38.38)
  BOTTOM w0.081: UC1.T5 v5(171.73,38.38)
CPU_XDP_TRST#: length 1.9
  IN1 w0.064: v4(168.38,39.03) 168.38,38.86 v2(168.06,38.55)
  IN3 w0.064: v5(168.04,39.03) v4(168.38,39.03)
  BOTTOM w0.081: v5(168.04,39.03) UC1.AB6
CS_CORE1: length 27.5
  IN1 w0.203: v4(150.87,21.86) 150.39,21.39 150.39,19.97 152.01,18.35 154.4,18.35 155.17,17.58 156.03,17.58 157.28,16.33 157.78,16.33 159.28,14.82 161.48,14.82 164.97,11.33 165.75,11.33 v4(165.89,11.19)
  IN3 w0.203: v4(165.89,11.19) 165.89,12.07 166.69,12.87 167.6,12.87 v5(167.79,12.68) ; v4(150.87,21.86) v5(150.87,21.51)
  BOTTOM w0.203: PRZ52.1 151.58,21.32 152.34,22.08 PUZ01.5
CS_CORE2: length 34.6
  IN1 w0.203: v4(151.67,20.92) 152.97,22.22 158.1,22.22 159.23,21.09 159.93,21.09 162.35,18.67 163.63,18.67 164.48,17.81 164.48,16.55 165.82,15.21 166.38,15.21 170.08,11.51 172.79,11.51 173.97,12.69 v4(173.97,13.39)
  IN3 w0.203: v5(151.29,20.55) 151.33,20.59 151.34,20.59 v4(151.67,20.92) ; v4(173.97,13.39) 174.23,13.39 v5(174.94,12.68)
  BOTTOM w0.203: PUZ01.4 152.57,21.68 v1(151.82,20.93) 151.45,20.55 v5(151.29,20.55) PRZ51.1 ; PUI02.12 v5(174.94,12.68)
CS_CORE3: length 43.9
  IN1 w0.203: v4(150.98,20.21) 151.68,20.21 151.83,20.36 153.13,20.36 154.53,21.76 157.92,21.76 159.05,20.62 159.71,20.62 162.71,17.63 163.6,17.63 163.89,17.35 163.89,16.5 165.63,14.75 166.19,14.75 169.89,11.06 172.98,11.06 174.57,12.65 175.96,12.65 177.85,10.75 179.59,10.75 181.73,12.9 v4(182.41,12.9)
  IN3 w0.203: v4(182.41,12.9) 182.53,12.9 v5(182.73,12.7) ; v4(150.98,20.21) 150.81,20.04 150.81,19.82 v5(150.81,19.81)
  BOTTOM w0.203: PUZ01.3 152.75,21.28 151.65,20.18 151.42,20.18 151.02,19.79 PRZ50.1 ; PUI03.12 182.75,12.68 v5(182.73,12.7)
CS_GT1: length 116
  IN1 w0.203: v4(201.38,35.02) 201.38,32.83 200.01,31.46 199.46,31.46 198.14,30.15 198.14,29.67 197.82,29.35 197.82,27.37 198.8,26.39 198.8,25.22 201.92,22.1 202.06,22.1 208.02,16.14 208.02,10.9 208.02,10.74 208.02,10.59 208.02,9.09 208.02,5.87 207.07,4.92 170.51,4.92 169.6,5.82 166.15,5.82 165.69,5.35 163.96,5.35 158.97,10.35 149.17,10.35 145.32,14.2 145.32,15.9 v4(145.31,15.9)
  IN3 w0.203: v5(150.14,18.38) 150.01,18.38 148.53,16.89 146.38,16.89 145.52,16.03 145.44,16.03 v4(145.31,15.9)
  IN3 w0.254: v5(201.54,36) 201.54,35.57 201.38,35.42 v4(201.38,35.02)
  BOTTOM w0.203: PUZ01.1 152.76,20.48 152.03,19.75 151.54,19.75 151.32,19.53 151.32,19.23 151.12,19.02 PRZ49.1 150.49,18.77 150.49,18.66 150.21,18.38 v5(150.14,18.38) ; PUG01.12 v5(201.54,36)
CS_SA: length 15.5
  IN2 w0.203: v4(145.5,18.97) 145.9,19.37 147.74,19.37 149.06,18.05 v4(149.07,18.05)
  IN3 w0.203: v5(141.28,19.49) 141.35,19.42 142.56,19.42 142.59,19.39 144.76,19.39 144.78,19.41 145.27,19.41 145.5,19.19 v4(145.5,18.97)
  IN3 w0.254: v4(149.07,18.05) 149.24,18.23 v5(149.35,18.23)
  BOTTOM w0.203: v5(141.28,19.49) 141.89,19.49 PUA01.12 ; v5(149.35,18.23) 149.62,17.96 151.29,17.96 151.68,18.36 PRZ48.1 152.05,18.47 153.2,18.47 154.05,19.32 PUZ01.48
CSN_GPU: length 4.8
  TOP w0.254: PRV39.2 PRV35.2 PCV44.1 42.67,65.54 42.67,63.99 42.33,63.66 PUV01.13
CSON_CHG: length 4.2
  BOTTOM w0.203: PCB41.2 199.31,25.88 199.31,25.81 198.77,25.27 PUB01.1
  BOTTOM w0.254: PCB41.2 200.53,27.09 PCB43.1 200.82,27.4 200.67,27.55 PRB36.1
CSOP_CHG: length 3.6
  BOTTOM w0.203: PCB41.1 199.6,25.61 198.86,24.87 PUB01.2
  BOTTOM w0.254: PRB32.1 PCB38.1 200.43,25.44 200.26,25.61 PCB41.1
CSSUMA: length 13.9
  IN2 w0.254: v4(149.8,21.38) 149.8,21.5 152.65,24.35 152.65,24.81 154.22,26.39 155.38,26.39 v4(155.44,26.44)
  IN3 w0.254: v5(149.38,21.11) 149.53,21.11 v4(149.8,21.38) ; v5(156.55,26.87) 156.46,26.79 156.15,26.79 155.8,26.44 v4(155.44,26.44)
  BOTTOM w0.081: v5(149.38,21.11) 148.96,21.11 v1(148.86,21.01)
  BOTTOM w0.203: PUZ01.18 156.05,26.28 156.55,26.77 v5(156.55,26.87)
  BOTTOM w0.254: v5(149.38,21.11) 149.59,21.32 PRZ52.2 PRZ51.2 PRZ50.2
CSSUMB: length 12.9
  IN2 w0.254: v4(156.05,25.84) 154.36,25.84 153.19,24.66 153.19,23.94 151.73,22.48 151.73,21.91 150.02,20.19 v4(150.02,19.56)
  IN3 w0.254: v4(150.02,19.56) 149.75,19.56 149.51,19.32 v5(149.32,19.32) ; v5(156.72,26.43) 156.13,25.84 v4(156.05,25.84)
  BOTTOM w0.203: PUZ01.19 156.45,26.19 156.69,26.43 v5(156.72,26.43)
  BOTTOM w0.254: v5(149.32,19.32) 149.61,19.02 PRZ49.2
CSSUMC: length 9
  IN2 w0.254: v4(156.1,25.31) 155.5,25.31 152.25,22.05 152.25,19.87 v4(152.22,19.84)
  IN3 w0.254: v4(156.1,25.31) 156.35,25.31 v5(156.86,25.82) ; v5(151.99,19.3) 152.22,19.52 v4(152.22,19.84)
CT1_UV2: length 1.1
  TOP w0.081: CV326.1 118.38,52.75 118.33,52.7 UV2.12
CT1_UZ1: length 1.4
  BOTTOM w0.203: CZ7.1 146.09,29.24 145.94,29.09 UZ1.12
CT1_UZ3: length 1.3
  TOP w0.081: CZ16.1 91.07,27.49 90.79,27.21 UZ3.12
CT2_UV2: length 1.2
  TOP w0.081: CV327.1 119.01,52.95 119.13,52.83 UV2.10
CT2_UZ1: length 1.4
  BOTTOM w0.203: CZ6.1 146.16,29.8 146.08,29.88 UZ1.10
CT2_UZ3: length 1.3
  TOP w0.081: CZ17.1 91.59,27.42 UZ3.10
CT_U19: length 2.7
  TOP w0.081: U19.6 49.28,41.59 49.36,41.51 C60.1 49.36,40.13 v1(49.03,39.8)
CT_UZ4: length 1.3
  BOTTOM w0.081: CZ22.1 122.64,44.54 122.27,44.91 UZ4.6
CT_UZ8: length 2
  TOP w0.081: UZ8.6 CZ224.1 v1(139,70.58)
DAT_SMB: length 4.2
  TOP w0.081: v1(109.09,9.58) 108.2,9.58 v2(107.91,9.87)
  IN1 w0.064: v2(107.91,9.87) 107.91,10.58 v4(108.18,10.85)
  IN3 w0.064: v4(108.18,10.85) 108.72,11.39 108.72,11.58 108.98,11.84 v5(109.42,11.84)
DAT_TP_SIO_I2C_CLK: length 105.8
  TOP w0.081: v2(41.95,29.05) 41.98,29.08 UE1.B51 ; R33.2 v2(115.46,5.37)
  IN1 w0.064: v4(41.69,29.45) 41.95,29.18 v2(41.95,29.05) ; v2(115.46,5.37) 115.46,5.3 114.12,3.96 106.89,3.96 106.79,4.07 106.78,4.07 106.53,4.32 102.54,4.32 102.32,4.1 99.95,4.1 99.56,3.71 50.94,3.71 48.36,6.29 45.23,6.29 43.84,7.69 42.88,7.69 42.37,8.19 40.42,8.19 40.3,8.31 40.29,8.31 39.98,8.62 39.18,8.62 37.18,10.63 37.18,11.96 v4(37.16,11.98)
  IN3 w0.064: v4(41.69,29.45) 41.07,28.83 41.07,25.47 41.5,25.03 41.5,17.91 41.17,17.58 41.17,16.21 39.79,14.82 38.76,14.82 37.16,13.22 v4(37.16,11.98)
DBC_PANEL_EN: length 153.6
  TOP w0.081: RC106.2 140.21,51.8 v2(140.11,51.89) 140.11,52.21 v1(139.72,52.6)
  IN1 w0.064: v4(140.91,52.09) 140.75,51.92 140.14,51.92 v2(140.11,51.89)
  IN2 w0.066: v4(140.91,52.09) 140.91,52.15 140.77,52.29 137.86,52.29 137.52,52.63 135.37,52.63 134.2,51.46 133.26,51.46 129.57,47.77 127.61,47.77 123.46,43.62 123.46,40.82 120.04,37.4 120.04,36.25 113.52,29.73 109.98,29.73 109.46,30.26 100.22,30.26 100.15,30.33 80.98,30.33 80.76,30.1 77.23,30.1 76.82,30.51 72.45,30.51 67.56,35.4 67.56,36.23 60.54,43.26 59.97,43.26 58.32,44.91 53.65,44.91 53.03,44.29 50.03,44.29 48.91,45.41 48.91,46.16 48.02,47.05 48.02,52.66 46.67,54.01 46.67,57.6 45.36,58.91 45.36,62.86 44.76,63.46 44.76,66.15 42.95,67.96 42.95,70.36 42.37,70.94 41.94,70.94 38.88,74 34.91,74 34.57,73.66 v4(34.57,73.64)
  IN3 w0.064: v5(140.91,52.53) v4(140.91,52.09) ; v4(34.57,73.64) 34.57,73.12 34.75,72.93 v5(34.75,72.88)
  BOTTOM w0.081: v5(140.91,52.53) 140.73,52.72 UC1.CE28 ; JEDP1.16 v5(34.75,72.88)
DDC_SCL_HDMI: length 24.5
  TOP w0.081: v2(24.46,36.63) 24.46,36.97 RM3.2 24.48,37 24.48,37.26 24.51,37.29 UM1.52
  IN1 w0.064: v4(24.54,37.58) 24.46,37.5 v2(24.46,36.63)
  IN3 w0.064: JHDMI1.15 12.24,45.07 12.24,38.79 12.72,38.32 13.57,38.32 14.49,37.4 22.42,37.4 23.23,36.58 24.24,36.58 24.46,36.79 24.46,37.5 v4(24.54,37.58)
DDC_SDA_HDMI: length 23.2
  TOP w0.081: UM1.51 24.11,37.37 24.03,37.29 24.03,37 RM4.2 24.07,36.96 v2(24.07,36.62)
  IN1 w0.064: v2(24.07,36.62) v4(24.07,37.05)
  IN3 w0.064: v4(24.07,37.05) 23.93,37.05 23.6,37.38 22.7,37.38 22.47,37.61 14.57,37.61 14.29,37.89 14.29,39.9 15.53,41.13 15.53,43.77 15.32,43.98 14.58,43.98 14.29,44.27 14.29,45.07 JHDMI1.16
DDR_A0_ZQ0: length 4.3
  BOTTOM w0.081: UD42.B3 194.36,58.64 196.07,58.64 197.18,59.75 RD1.1
DDR_A0_ZQ1: length 5
  BOTTOM w0.081: RD3.1 197.05,60.31 196.02,59.29 193.55,59.29 UD42.B4

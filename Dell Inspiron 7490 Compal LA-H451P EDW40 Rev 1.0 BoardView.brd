# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A1_ZQ0: length 4.1
  BOTTOM w0.089: UD41.B3 176.16,73.26 175.82,73.6 175.82,74.82 175.22,75.41 175.22,76.24 175.38,76.4 RD2.1
DDR_A1_ZQ1: length 5.2
  BOTTOM w0.089: UD41.B4 175.83,72.56 175.83,73.26 175.65,73.44 175.39,73.44 174.82,74.01 RD4.1
DDR_B0_ZQ0: length 4
  BOTTOM w0.089: RD5.1 154.79,75.8 155.26,75.32 155.26,73.36 UD44.B3
DDR_B0_ZQ1: length 4.8
  BOTTOM w0.089: RD7.1 154.23,75.57 154.62,75.17 154.62,72.56 UD44.B4
DDR_B1_ZQ0: length 4
  BOTTOM w0.081: RD6.1 139.44,75.42 140.05,74.81 140.05,73.37 UD43.B3
DDR_B1_ZQ1: length 5.1
  BOTTOM w0.081: UD43.B4 139.4,72.56 139.4,73.21 139.23,73.38 138.95,73.38 138.68,73.65 138.68,74.98 138.78,75.08 138.78,75.76 138.88,75.87 RD8.1
DDR_CHA_EN: length 2.4
  TOP w0.081: RC227.1 RC226.2 137.35,47.28 v2(137.27,47.36)
  IN1 w0.064: v2(137.27,47.36) 137.37,47.26 v4(137.79,47.26)
  IN3 w0.064: v4(137.79,47.26) 137.66,47.13 137.58,47.13 v5(137.24,46.78)
DDR_CHB_EN: length 3.7
  TOP w0.081: v1(139.08,44.57) 139.34,44.83 v2(139.34,44.95) 138.85,44.95 138.68,45.11 RC228.1 138.68,45.87 RC225.2
  IN1 w0.064: v2(139.34,44.95) 139.56,44.95 v4(139.89,45.28)
  IN3 w0.064: v5(139.58,45.39) 139.6,45.36 139.74,45.36 139.82,45.28 v4(139.89,45.28)
  BOTTOM w0.081: UC1.CG17 139.22,45.75 v5(139.58,45.39)
DDR_M0_CAA_0: length 46.3
  IN1 w0.094: v4(167.33,57.1) 167.25,57.01 167.25,56.2 170.07,53.38 170.07,51.4 170.48,50.98 170.48,50.04 174.02,46.5 188.47,46.5 189.2,47.23 189.33,47.23 189.52,47.04 189.93,46.63 190.06,46.63 190.25,46.82 190.25,46.95 189.53,47.66 189.53,47.79 189.72,47.98 189.84,47.98 190.6,47.22 190.73,47.22 190.92,47.41 190.92,47.53 190.1,48.35 190.1,48.47 190.29,48.66 190.42,48.66 190.99,48.09 191.12,48.09 191.3,48.28 191.3,48.4 190.9,48.81 190.9,48.93 191.78,49.81 193.7,49.81 193.76,49.87 194.93,49.87 v6(195.22,50.16)
  IN3 w0.094: v4(167.33,57.1) 167.3,57.1 167.05,57.34 v5(167.02,57.34)
  BOTTOM w0.127: RD88.1 196.45,49.73 195.79,50.39 195.63,50.55 194.86,50.55 UD42.R2 194.83,50.48 195.15,50.16 v6(195.22,50.16)
DDR_M0_CAA_1: length 45.7
  IN1 w0.094: v4(195.23,50.9) 195.16,50.9 194.84,51.23 194.84,52.22 194.59,52.47 191.89,52.47 191.6,52.18 191.6,52.1 190.98,51.47 190.98,50.84 190.14,50 189.09,50 186.16,47.07 174.48,47.07 171.21,50.33 171.21,50.96 170.46,51.7 170.46,53.5 170.59,53.63 170.59,54.05 169.36,55.29 168.74,55.29 167.74,56.28 167.74,56.68 168.52,57.45 168.52,58.55 v6(169.11,59.14)
  IN3 w0.094: v4(195.23,50.9) 195.16,50.9 194.9,51.17 v5(194.83,51.17)
  BOTTOM w0.127: RD77.1 196.79,50.84 196.46,51.17 v5(194.83,51.17) ; UC1.W36 169.21,57.99 169.21,59.04 v6(169.11,59.14)
DDR_M0_CAA_2: length 46.4
  IN1 w0.094: v4(195.23,51.49) 195.95,50.77 195.95,49.27 195.24,48.55 194.95,48.55 192.23,45.84 173.88,45.84 169.84,49.88 169.84,50.95 169.73,51.06 169.73,52.88 169.47,53.14 169.11,53.14 168.91,53.35 168.91,53.88 167.23,55.56 167.07,55.56 166.52,56.11 166.52,56.75 168.03,58.26 v4(168.12,58.26)
  IN3 w0.094: v4(168.12,58.26) 168.07,58.31 167.68,58.31 v5(167.67,58.31) ; v4(195.23,51.49) 194.9,51.82 v5(194.83,51.82)
  BOTTOM w0.127: v5(194.83,51.82) 197.57,51.82 RD63.1
DDR_M0_CAA_3: length 45.6
  IN1 w0.094: v4(166.86,56.26) 166.86,56.03 167.03,55.86 167.35,55.86 169.9,53.31 169.9,51.22 170.15,50.97 170.15,49.96 173.92,46.19 190.37,46.19 193.23,49.05 195.2,49.05 195.64,49.49 195.64,50.32 195.45,50.52 194.89,50.52 194.74,50.36 194.25,50.36 194.04,50.57 194.04,51.11 v4(194.43,51.49)
  IN3 w0.094: v5(194.03,51.82) 194.1,51.82 v4(194.43,51.49) ; v5(167.02,56.69) 166.86,56.53 v4(166.86,56.26)
  BOTTOM w0.127: RD75.1 196.66,50.28 196.1,50.84 194.61,50.84 194.35,51.1 194.35,51.39 194.03,51.72 v5(194.03,51.82)
DDR_M0_CAA_4: length 47.5
  IN1 w0.094: v4(167.95,57.39) 167.94,57.38 167.94,57.14 167.56,56.76 167.56,56.15 169.26,54.45 169.96,54.45 170.42,53.98 170.42,53.7 170.29,53.57 170.29,51.52 170.86,50.95 170.86,50.22 174.3,46.78 186.38,46.78 186.65,47.05 186.78,47.05 187.02,46.81 187.14,46.81 187.33,47 187.33,47.13 187.06,47.4 187.06,47.52 187.25,47.71 187.38,47.71 188.12,46.96 188.25,46.96 188.44,47.15 188.44,47.28 187.69,48.03 187.69,48.15 187.86,48.32 188.57,48.32 188.66,48.23 188.66,47.7 188.75,47.61 189.02,47.61 189.11,47.7 189.11,48.23 189.19,48.32 189.39,48.32 189.47,48.32 189.89,48.74 189.89,48.87 189.68,49.08 189.68,49.2 189.87,49.39 189.99,49.39 190.21,49.18 190.33,49.18 191.42,50.26 191.42,51.45 191.75,51.78 194.07,51.78 194.42,52.14 v4(194.43,52.14)
  IN3 w0.094: v5(194.03,52.47) 194.1,52.47 194.43,52.14 v4(194.43,52.14) ; v4(167.95,57.39) 167.94,57.39 v5(167.67,57.66)
  BOTTOM w0.127: v5(194.03,52.47) 194.34,52.16 194.34,52 194.48,51.86 194.48,51.7 194.71,51.48 194.93,51.48 194.98,51.53 197.59,51.53 RD29.1
DDR_M0_CAA_5: length 45.1
  IN1 w0.094: v4(169.59,56.36) 169.34,56.61 168.82,56.61 168.69,56.73 168.69,56.92 169.71,57.94 169.91,57.94 170.15,57.7 170.15,57.57 169.71,57.14 169.71,57.01 169.9,56.82 170.03,56.82 170.46,57.26 170.59,57.26 170.9,56.95 170.9,56.58 170.84,56.52 170.29,56.52 170.02,56.25 170.02,55.11 170.93,54.19 170.93,51.96 171.77,51.12 173.52,51.12 173.56,51.16 176.24,51.16 176.32,51.24 179.09,51.24 184.97,57.12 186.74,57.12 186.83,57.21 186.83,57.53 186.92,57.62 187.19,57.62 187.27,57.53 187.27,57.21 187.36,57.12 189.14,57.12 189.23,57.21 189.23,57.46 189.31,57.55 189.58,57.55 189.67,57.46 189.67,57.21 189.76,57.12 189.94,57.12 190.17,56.89 190.64,56.89 191.81,55.72 192.43,55.72 192.51,55.64 193.79,55.64 194.23,56.07 v6(194.41,56.07)
  IN3 w0.089: v5(169.54,56.69) 169.51,56.66 169.51,56.5 169.58,56.43 169.58,56.37 v4(169.59,56.36)
  BOTTOM w0.127: RD31.1 197.12,56.96 196.86,56.7 194.36,56.7 UD42.F3 194.32,56.07 v6(194.41,56.07)
DDR_M0_CAA_6: length 46.2
  IN1 w0.094: v6(168.12,56.54) 168.22,56.63 168.22,56.87 168.82,57.47 168.82,58.4 169,58.58 169.73,58.58 171.23,57.08 171.23,56.4 171.11,56.28 170.34,56.28 170.19,56.14 170.19,55.17 171.1,54.26 171.1,52.19 172,51.29 173.45,51.29 173.49,51.33 176.17,51.33 176.25,51.41 178.86,51.41 184.91,57.45 186.28,57.45 187.13,58.31 187.47,58.31 187.56,58.22 187.56,57.71 187.65,57.62 187.91,57.62 188,57.71 188,58.22 188.09,58.31 188.36,58.31 188.45,58.22 188.45,57.71 188.54,57.62 188.8,57.62 188.89,57.71 188.89,58.22 188.98,58.31 189.54,58.31 190.16,57.69 190.16,57.69 190.59,57.69 191.25,57.03 194.09,57.03 v4(194.43,56.69)
  IN3 w0.094: v4(194.43,56.69) 194.35,56.69 v5(194.03,57.02)
  BOTTOM w0.127: UC1.AA34 167.95,56.36 v6(168.12,56.54) ; v5(194.03,57.02) 194.35,57.34 196.56,57.34 197.29,58.07 RD33.1
DDR_M0_CAA_7: length 42.4
  IN1 w0.094: v4(195.23,56.69) 194.97,56.69 194.82,56.55 194.82,55.97 194.57,55.72 194.28,55.72 193.97,55.41 192.97,55.41 192.22,54.67 191.94,54.67 191.8,54.8 191.8,55 191.61,55.19 191.61,55.55 190.66,56.5 190.1,56.5 189.85,56.76 189.42,56.76 189.33,56.67 189.33,56.48 189.24,56.4 188.97,56.4 188.88,56.48 188.88,56.67 188.79,56.76 188.53,56.76 188.44,56.67 188.44,56.48 188.35,56.4 188.08,56.4 187.99,56.48 187.99,56.67 187.9,56.76 187.64,56.76 187.55,56.67 187.55,56.48 187.46,56.4 187.19,56.4 187.1,56.48 187.1,56.67 187.02,56.76 186.69,56.76 186.57,56.64 186.3,56.64 186.19,56.76 185.8,56.76 185.68,56.64 185.42,56.64 185.32,56.74 185,56.74 179.33,51.07 176.39,51.07 176.31,50.99 173.63,50.99 173.59,50.95 171.6,50.95 170.63,51.92 170.63,53.43 170.76,53.56 170.76,54.12 169.49,55.39 169.49,55.98 169.17,56.3 168.66,56.3 168.52,56.16 168.52,55.89 168.71,55.7 168.83,55.7 v6(169.04,55.91)
  IN3 w0.094: v4(195.23,56.69) 194.9,57.02 v5(194.83,57.02)
  BOTTOM w0.127: v5(194.83,57.02) 196.68,57.02 197.17,57.52 RD35.1 ; UC1.W34 168.88,56.07 v6(169.04,55.91)
DDR_M0_CAA_8: length 45.6
  IN1 w0.094: v6(195.24,58.06) 194.74,58.55 194.74,58.87 194.28,59.32 193.52,59.32 193.13,59.72 188.53,59.72 188.34,59.53 185.45,59.53 183.63,57.7 183.51,57.7 183.37,57.85 183.24,57.85 183.05,57.66 183.05,57.53 183.19,57.39 183.19,57.27 183,57.08 182.85,57.08 182.74,57.19 182.62,57.19 182.43,57 182.43,56.87 182.55,56.75 182.55,56.63 182.37,56.45 182.25,56.45 182.14,56.56 182.02,56.56 181.83,56.37 181.83,56.24 181.93,56.14 181.93,56.01 181.74,55.82 181.62,55.82 181.51,55.93 181.36,55.93 181.17,55.74 181.17,55.61 181.29,55.49 181.29,55.37 181.12,55.19 180.97,55.19 180.86,55.3 180.73,55.3 180.54,55.11 180.54,54.99 180.66,54.86 180.66,54.74 180.49,54.56 180.36,54.56 180.23,54.7 180.1,54.7 179.91,54.51 179.91,54.38 180.05,54.25 180.05,54.12 179.86,53.93 179.73,53.93 179.61,54.05 179.49,54.05 179.31,53.88 179.31,53.73 179.42,53.62 179.42,53.49 179.23,53.31 179.08,53.31 179,53.39 178.87,53.39 178.68,53.2 178.68,53.07 178.78,52.97 178.78,52.85 178.6,52.67 178.48,52.67 178.29,52.86 178.17,52.86 177.98,52.67 177.98,52.55 178.16,52.36 178.16,52.23 177.85,51.92 176.04,51.92 175.96,51.84 173.28,51.84 173.24,51.81 172.35,51.81 171.61,52.54 171.61,56.13 171.59,56.15 171.59,57.09 170.63,58.05 170.63,58.31 v4(169.91,59.03)
  IN3 w0.094: v5(169.54,57.34) 169.54,58.41 169.91,58.78 v4(169.91,59.03)
  BOTTOM w0.127: v6(195.24,58.06) 195.04,58.06 194.83,57.85 UD42.D2 194.83,57.66 196.27,57.66 197.24,58.63 RD37.1
DDR_M0_CAA_9: length 46.2
  IN1 w0.094: v4(169.56,59.49) 170.36,59.49 170.98,58.87 170.98,58.03 171.78,57.22 171.78,53.73 172.35,53.17 172.35,52.24 172.61,51.98 173.17,51.98 173.21,52.01 175.89,52.01 175.97,52.09 177.08,52.09 183.55,58.56 183.86,58.56 185.81,60.52 186.31,60.52 186.4,60.61 186.4,61.13 186.49,61.22 186.76,61.22 186.85,61.13 186.85,60.61 186.94,60.52 187.2,60.52 187.29,60.61 187.29,61.13 187.38,61.22 187.65,61.22 187.74,61.13 187.74,60.61 187.83,60.52 188.09,60.52 188.18,60.61 188.18,61.02 188.27,61.11 188.54,61.11 188.63,61.02 188.63,60.61 188.71,60.52 193.52,60.52 193.92,60.12 193.92,59.79 194.14,59.57 194.32,59.57 195.11,58.78 195.11,58.76 v4(195.23,58.64)
  IN3 w0.094: v4(169.56,59.49) 169.56,59.36 169.51,59.31 169.51,58.76 169.19,58.45 169.19,57.37 168.9,57.08 v5(168.9,57.03) ; v5(194.83,58.32) 194.9,58.32 v4(195.23,58.64)
  BOTTOM w0.127: RD39.1 197.19,59.19 196.43,58.43 194.94,58.43 v5(194.83,58.32)
DDR_M0_CAB_0: length 42.6
  IN3 w0.094: v5(166.06,55.32) 166.06,55.54 165.66,55.95 165.66,56.75 166.01,57.1 166.01,57.35 165.9,57.46 165.9,58.45 166.14,58.69 166.14,60.87 167.69,62.42 167.69,62.68 169.57,64.55 169.57,74.32 169.44,74.44 169.44,75.43 172.38,78.37 176.12,78.37 176.24,78.25 182.97,78.25 v5(184.9,76.32)
  BOTTOM w0.127: UD41.R2 184.61,74.82 184.9,75.11 v5(184.9,76.32) 184.78,76.44 RD41.1
DDR_M0_CAB_1: length 42.1
  IN3 w0.094: v5(184.39,75.92) 184.39,76.11 183.39,77.12 181.05,77.12 180.2,77.96 176.08,77.96 176.01,78.03 172.58,78.03 169.85,75.3 169.85,64.43 167.98,62.56 167.98,62.31 166.34,60.67 166.34,58.65 166.11,58.41 166.11,57.49 166.18,57.42 166.18,57.01 165.91,56.74 165.91,56.02 166.29,55.64 166.65,55.64 v5(166.98,55.32)
  BOTTOM w0.127: UD41.P2 183.96,74.27 184.24,74.55 184.24,75.76 v5(184.39,75.92) 184.39,76.28 184.22,76.46 RD43.1
DDR_M0_CAB_2: length 42.2
  IN3 w0.094: v5(183.38,75.83) 183.69,75.83 183.88,76.02 183.88,76.18 183.24,76.83 180.91,76.83 180.31,77.43 179.33,77.43 179.07,77.16 178.83,77.16 177.32,75.66 176.85,75.66 176.79,75.59 176.21,75.59 175.94,75.87 173.35,75.87 173.33,75.85 173.28,75.85 170.95,73.51 170.95,73.47 170.7,73.22 170.7,64.08 168.83,62.21 168.83,61.95 167.13,60.26 167.13,59.17 166.91,58.95 166.91,58.08 166.63,57.8 166.63,57.54 166.6,57.51 166.6,57.44 166.39,57.24 166.39,56.94 166.11,56.66 166.11,56.19 166.36,55.95 166.75,55.95 167.26,55.44 167.26,55.21 167.12,55.07 166.26,55.07 166.06,54.87 v5(166.06,54.67)
  BOTTOM w0.127: UD41.N2 183.31,74.83 183.38,74.91 183.6,74.91 183.68,74.99 183.68,75.21 183.6,75.29 183.38,75.29 183.26,75.41 183.26,75.71 v5(183.38,75.83) 183.37,75.84 183.37,75.97 183.1,76.24 RD45.1
DDR_M0_CAB_3: length 38.6
  IN3 w0.094: v5(167.89,55.32) 167.89,55.77 167.41,56.25 167.41,56.46 167.59,56.65 167.68,56.65 168.28,57.25 168.28,57.59 167.88,57.99 167.64,57.99 167.42,58.21 167.42,58.42 167.74,58.74 167.99,58.74 168.25,59 168.25,60.16 169.68,61.6 169.68,61.85 171.56,63.73 171.56,72.13 174.4,74.97 175.45,74.97 175.62,74.8 177.96,74.8 179.31,76.15 180.48,76.15 180.84,76.51 182.23,76.51 183.24,75.5 183.82,75.5 v5(183.88,75.57)
  BOTTOM w0.127: RD47.1 183.66,76.28 183.88,76.06 183.88,75.57 v5(183.88,75.57) 183.94,75.51 183.94,74.65 183.64,74.35 183.64,73.38 UD41.N3
DDR_M0_CAB_4: length 37.9
  IN3 w0.094: v5(168.8,55.32) 168.47,55.65 168.47,56.24 168.54,56.32 168.54,56.64 168.47,56.72 168.47,59.98 169.97,61.48 169.97,61.74 171.86,63.62 171.86,71.99 174.54,74.68 175.4,74.68 175.46,74.61 176.22,74.61 176.31,74.52 176.31,74.2 176.4,74.11 176.67,74.11 176.76,74.2 176.76,74.52 176.84,74.61 178.18,74.61 179.43,75.87 180.79,75.87 180.97,76.04 182.29,76.04 182.5,75.83 182.5,75.33 182.59,75.24 v5(182.97,75.24)
  BOTTOM w0.127: RD49.1 182.54,76.2 182.86,75.88 182.86,75.34 v5(182.97,75.24) 182.96,75.23 182.96,73.98 182.97,73.97 182.97,73.71 182.96,73.7 182.96,73.63 182.81,73.47 182.54,73.47 182.33,73.27 182.33,72.67 182.39,72.61 182.55,72.61 182.66,72.71 UD41.M3
DDR_M0_CAB_5: length 41.1
  IN3 w0.094: v5(178.76,76.14) 179.08,76.45 180.28,76.45 180.4,76.58 180.4,76.81 180.18,77.03 179.47,77.03 179.27,76.83 179.03,76.83 178.27,76.08 178.27,75.96 178.43,75.8 178.43,75.67 178.24,75.49 178.11,75.49 177.96,75.64 177.73,75.64 177.43,75.34 175.99,75.34 175.75,75.58 173.47,75.58 170.99,73.1 170.99,63.96 169.12,62.09 169.12,61.84 167.42,60.14 167.42,59.22 167.08,58.88 167.08,57.95 166.8,57.67 166.8,57.47 166.79,57.46 166.79,57.45 166.77,57.43 166.77,57.36 166.7,57.29 166.7,56.69 v5(166.37,56.36)
  BOTTOM w0.076: UD41.F3 179.01,73.04 179.15,72.89 179.15,72.82 179.31,72.67 179.55,72.67 179.73,72.49 179.73,72.09 179.49,71.85 179.23,71.85 179.08,72.01 179.08,72.4 178.9,72.58 178.68,72.58 178.42,72.84 178.42,73.22 178.31,73.33 178.31,73.57 178.42,73.68 178.42,73.97 178.77,74.32 178.77,74.48
  BOTTOM w0.127: 178.77,74.48 178.77,75.09 178.41,75.46 178.41,75.68 178.76,76.04 v5(178.76,76.14) 178.55,76.14 178.17,76.52 RD51.1
DDR_M0_CAB_6: length 42.1
  IN3 w0.094: v5(177.84,75.07) 177.83,75.08 175.83,75.08 175.65,75.25 174.21,75.25 174.09,75.14 173.97,75.14 173.82,75.29 173.69,75.29 173.5,75.1 173.5,74.98 173.67,74.81 173.67,74.69 173.47,74.49 173.35,74.49 173.14,74.71 173.01,74.71 172.82,74.52 172.82,74.4 173.04,74.18 173.04,74.06 172.84,73.87 172.73,73.87 172.51,74.08 172.38,74.08 172.19,73.89 172.19,73.77 172.41,73.55 172.41,73.43 172.22,73.24 172.1,73.24 171.87,73.46 171.75,73.46 171.56,73.27 171.56,73.15 171.76,72.95 171.76,72.82 171.27,72.34 171.27,63.84 169.4,61.97 169.4,61.72 168,60.32 168,59.08 167.88,58.96 167.47,58.96 167.28,58.77 167.28,58.53 167.25,58.49 167.25,58.08 167.35,57.98 167.35,57.89 167.14,57.69 167.14,57.58 167.29,57.43 167.48,57.43 167.62,57.28 167.62,57.26 167.67,57.21 167.67,56.95 167.51,56.8 167.49,56.8 167.19,56.5 167.19,56.11 167.59,55.71 167.59,55.22 167.74,55.06 167.74,54.91 167.5,54.67 v5(166.98,54.67)
  BOTTOM w0.127: UD41.E3 178.11,72.83 178.4,72.54 178.4,72.39 178.42,72.37 178.42,72.11 178.4,72.09 178.4,71.59 178.42,71.57 178.42,71.31 178.4,71.29 178.4,70.79 178.42,70.77 178.42,70.47 178.28,70.33 177.96,70.33 177.79,70.5 177.79,70.77 177.84,70.81 177.84,71.26 177.79,71.31 177.79,71.57 177.84,71.61 177.84,72.06 177.79,72.11 177.79,72.37 177.84,72.41 177.84,72.86 177.79,72.91 177.79,73.17 177.84,73.21 177.84,73.66 177.8,73.71 177.8,73.79 177.79,73.79 177.79,73.91 177.74,73.96 177.74,74.38 177.8,74.44 177.8,74.8 177.84,74.83 v5(177.84,75.07) 177.84,75.89 177.05,76.68 RD53.1
DDR_M0_CAB_7: length 42.4
  IN3 w0.094: v5(178.01,74.27) 178.25,74.27 179.56,75.57 182.03,75.57 182.19,75.42 182.19,75.21 182.1,75.12 179.7,75.12 178.35,73.77 177.64,73.77 177.55,73.86 177.55,74.24 177.46,74.33 177.2,74.33 177.11,74.24 177.11,73.86 177.02,73.77 176.63,73.77 176.41,73.56 175.98,73.56 175.75,73.79 175.75,73.92 175.9,74.07 175.9,74.19 175.71,74.38 175.58,74.38 175.42,74.22 175.29,74.22 175.12,74.39 174.66,74.39 172.14,71.87 172.14,63.51 170.25,61.62 170.25,61.36 169.6,60.71 169.6,60.14 168.74,59.28 168.74,57.97 168.64,57.88 168.64,56.83 168.73,56.75 168.73,56.26 168.64,56.18 168.64,55.81 168.9,55.56 168.9,55.56 168.91,55.55 168.98,55.55 169.11,55.42 169.11,55.25 168.91,55.04 168.66,55.04 168.49,55.21 168.49,55.37 168.4,55.46 168.23,55.46 168.15,55.38 168.15,54.93 v5(167.89,54.67)
  BOTTOM w0.127: RD55.1 177.61,76.65 178.16,76.1 178.16,74.86 178.01,74.71 v5(178.01,74.27)
  BOTTOM w0.135: UD41.E2 178.07,73.88 178.07,74.21 v5(178.01,74.27)
DDR_M0_CAB_8: length 41.6
  IN3 w0.094: v5(166.37,57.62) 166.37,57.83 166.74,58.2 166.74,59.42 166.84,59.53 166.84,60.37 168.55,62.07 168.55,62.33 170.42,64.2 170.42,74.79 172.37,76.74 172.5,76.74 172.69,76.55 172.69,76.43 171.04,74.78 171.04,74.65 171.23,74.46 171.35,74.46 173.05,76.16 176.04,76.16 176.29,75.92 176.71,75.92 176.73,75.93 176.73,75.93 177.14,76.34 177.14,76.34 177.15,76.36 177.15,76.87 177.89,77.61 178.19,77.61 178.37,77.43 178.37,77.13 177.26,76.02 v5(177.24,76.02)
  BOTTOM w0.127: RD57.1 176.5,76.66 176.87,76.28 177,76.28 177.24,76.04 v5(177.24,76.02) 177.28,76.02 177.61,75.69 177.61,75.44 177.52,75.35 177.03,75.35 176.95,75.27 176.95,75.05 177.03,74.97 177.33,74.97 177.53,74.77 177.53,74.47 177.13,74.07 177.13,73.42 177.18,73.36 177.38,73.36 177.51,73.49 177.51,73.79 UD41.D2
DDR_M0_CAB_9: length 41.6
  IN3 w0.094: v5(176.46,76.22) 176.61,76.22 176.85,76.46 176.85,77.04 177.16,77.35 177.16,77.46 176.95,77.67 176.61,77.67 176.12,77.18 175.59,77.18 175.43,77.02 175.43,76.53 175.35,76.45 175.07,76.45 174.99,76.53 174.99,76.99 174.9,77.08 174.63,77.08 174.54,76.99 174.54,76.53 174.46,76.45 173.99,76.45 173.9,76.53 173.9,77.6 173.81,77.69 173.58,77.69 173.49,77.6 173.49,76.59 173.4,76.51 173.13,76.51 173.04,76.59 173.04,77.6 172.95,77.69 172.74,77.69 170.13,75.08 170.13,64.32 168.26,62.44 168.26,62.19 166.52,60.45 166.52,58.47 v5(166.37,58.31)
  BOTTOM w0.127: RD59.1 175.94,76.56 176.17,76.33 176.35,76.33 v5(176.46,76.22) 176.34,76.1 175.65,76.1 175.51,75.97 175.51,75.51 175.8,75.22 175.97,75.22 176.73,75.98 176.83,75.98 177,75.81 177,75.71 176.47,75.18 176.47,74.87 176.58,74.76 176.79,74.76 176.93,74.61 176.93,74.33 176.84,74.24 176.66,74.24 176.47,74.04 176.47,73.71 176.43,73.67 176.43,73.48 176.55,73.37 176.75,73.37 176.81,73.43 UD41.C2
DDR_M0_CKE0: length 52.5
  IN1 w0.094: v4(171.06,55.54) 171.27,55.32 171.27,52.4 172.21,51.46 173.38,51.46 173.42,51.5 176.1,51.5 176.18,51.58 178.47,51.58 184.76,57.87 186.09,57.87 186.93,58.71 190.6,58.71 190.93,58.38 190.93,57.92 191.15,57.7 191.33,57.7 191.51,57.87 191.51,58.22 191.62,58.34 193,58.34 193.24,58.09 193.24,57.91 193.33,57.81 193.36,57.81 193.49,57.69 193.83,57.69 194.11,57.41 194.45,57.41 194.54,57.32 194.54,57.04 194.63,56.95 194.9,56.95 194.99,57.04 194.99,57.32 195.08,57.41 195.28,57.41 195.61,57.09 195.61,56.44 195.2,56.04 195.14,56.04 194.89,55.78 194.89,55.15 194.74,55.01 193.1,55.01 192.49,54.4 192.49,52.87 192.59,52.77 193.12,52.77 193.24,52.89 193.24,54.22 193.54,54.52 193.81,54.52 194.24,54.09 v4(194.43,54.09)
  IN3 w0.094: v4(171.06,55.54) 171.06,55.89 170.85,56.1 170.38,56.1 170.37,56.08 170.04,56.08 169.94,56.18 169.94,56.47 170.09,56.62 170.23,56.62 170.37,56.62 170.61,56.85 170.61,57.67 170.38,57.89 170.25,57.89 170.19,57.83 v5(170.19,57.66) ; v5(194.03,53.77) 194.1,53.77 v4(194.43,54.09)
  BOTTOM w0.127: RD65.1 196.58,53.43 195.91,54.1 194.36,54.1 v5(194.03,53.77)
DDR_M0_CKE1: length 53
  IN1 w0.094: v4(170.52,55.77) 170.8,56.04 171.37,56.04 171.44,55.97 171.44,52.47 172.28,51.64 173.31,51.64 173.35,51.67 176.03,51.67 176.11,51.75 178.24,51.75 184.84,58.36 184.97,58.36 185.15,58.17 185.28,58.17 185.47,58.36 185.47,58.49 185.28,58.67 185.28,58.8 185.51,59.02 188.79,59.02 188.88,59.11 188.88,59.11 188.97,59.2 189.24,59.2 189.33,59.11 189.33,59.11 189.41,59.02 189.68,59.02 189.77,59.11 189.77,59.11 189.86,59.2 190.13,59.2 190.22,59.11 190.22,59.11 190.3,59.02 190.57,59.02 190.66,59.11 190.66,59.11 190.75,59.2 191.02,59.2 191.2,59.01 193.76,59.01 194.02,58.75 194.02,57.84 194.22,57.64 195.56,57.64 195.8,57.4 195.8,54.22 195.34,53.76 194.95,53.76 194.74,53.55 194.16,53.55 193.79,53.18 193.63,53.18 193.5,53.3 193.5,53.97 v6(193.63,54.09)
  IN3 w0.094: v4(170.52,55.77) 170.52,55.6 170.25,55.33 170.09,55.33 169.85,55.57 169.49,55.57 169.4,55.66 169.4,56.07 169.21,56.26 169.21,56.81 169.42,57.03 169.8,57.03 170.03,56.79 170.3,56.79 170.44,56.92 170.44,57.2 170.22,57.41 170.06,57.41 169.93,57.54 169.93,57.88 170.19,58.13 v5(170.19,58.31)
  BOTTOM w0.127: RD67.1 196.53,52.88 195.75,53.66 195.29,53.66 195.08,53.45 193.54,53.45 UD42.K4 193.55,54.09 v6(193.63,54.09)
DDR_M0_CKE2: length 52.3
  IN3 w0.094: v5(181.36,73.04) 181.1,73.3 181.1,73.55 181.2,73.65 182.14,73.65 182.3,73.81 183.55,73.81 183.72,73.98 184.64,73.98 185.39,74.73 185.84,74.73 186.58,73.99 186.71,73.99 187.13,74.42 187.31,74.42 187.52,74.21 187.52,73.99 186.82,73.29 186.82,72 187.02,71.8 187.31,71.8 187.53,72.02 187.53,72.87 188.03,73.37 188.03,74.59 187.65,74.96 185.2,74.96 184.9,74.67 179.81,74.67 178.48,73.34 176.72,73.34 176.52,73.14 175.91,73.14 175.25,73.8 175.03,73.8 172.9,71.67 172.9,63.3 170.97,61.37 170.97,61.09 170.39,60.51 170.39,59.37 170.5,59.26 170.5,58.02 170.78,57.74 170.78,57.56 170.78,57.56 170.78,56.56 170.57,56.35 170.2,56.35 v5(170.19,56.36)
  BOTTOM w0.127: v5(181.36,73.04) 181.02,73.37 181.02,76.24 180.87,76.39 RD69.1
DDR_M0_CKE3: length 54.8
  IN3 w0.094: v5(170.19,57.04) 170.16,57.04 169.79,57.42 169.79,57.44 169.76,57.47 169.76,58.07 169.93,58.24 169.93,58.42 170.27,58.76 170.27,59.17 169.89,59.55 169.89,60.43 170.65,61.2 170.65,61.45 172.54,63.34 172.54,71.71 174.82,73.99 175.3,73.99 175.91,73.38 176.49,73.38 176.64,73.53 178.41,73.53 179.77,74.89 183.26,74.89 183.44,75.07 184.63,75.07 184.92,75.36 187.18,75.36 187.34,75.52 187.98,75.52 188.62,74.88 188.62,73.03 188.53,72.94 188.3,72.94 188.21,72.85 188.21,72.59 188.3,72.5 188.53,72.5 188.62,72.41 188.62,71.74 187.78,70.89 187.65,70.89 187.26,71.29 187.13,71.29 186.94,71.1 186.94,70.97 187.34,70.58 187.34,70.32 187.15,70.14 181.73,70.14 181.3,70.58 181.3,70.66 181,70.96 v5(181.03,70.96)
  BOTTOM w0.127: v5(181.03,70.96) 181.02,70.97 181.02,71.54 181.09,71.61 181.09,72.06 181.1,72.09 UD41.K4 181.69,72.57 181.68,75.34 181.68,75.68 181.43,75.93 RD80.1 ; v5(170.19,57.04) UC1.U35
DDR_M0_CLK0: length 45.4
  IN3 w0.076: 172.38,55.65 172.36,55.64 172.36,55.61 171,54.25 170.42,54.25 169.96,54.71 169.96,54.85 169.87,54.94 169.78,54.94 169.71,54.87 v5(169.71,54.67)
  IN3 w0.109: 172.38,55.65 173.04,55.65 173.12,55.58 173.5,55.58 173.58,55.65 174.3,55.65 174.38,55.58 174.76,55.58 175.03,55.85 175.03,55.87 175.06,55.9 175.41,55.9 175.85,56.34 177.07,56.34 177.95,57.21 178.81,57.21 178.83,57.23 179.32,57.71 179.32,58.42 184.42,63.52 189.44,63.52 189.97,62.99 190.33,62.99 191.03,62.3 191.03,61.44 191.25,61.22 192.64,61.22 192.74,61.12 192.74,60.81 192.64,60.71 191.25,60.71 191.03,60.49 191.03,55.02 191.37,54.67 192.49,54.67 192.69,54.47 193.54,54.47 193.76,54.69 194.27,54.69 194.35,54.6 194.35,54.48 194.29,54.42 v5(194.03,54.42)
  BOTTOM w0.076: v5(194.03,54.42) 194.17,54.42 194.52,54.77 194.94,54.77 194.96,54.78 195.15,54.78 195.17,54.8 195.18,54.8
  BOTTOM w0.132: 195.18,54.8 196.23,54.8 196.65,54.38 197.54,54.38 RD79.1
DDR_M0_CLK1: length 38.2
  IN3 w0.076: 170.88,59.18 170.88,59.17 170.87,59.16 170.87,59.03 170.87,59.02 170.87,58.95 170.87,58.12 171.14,57.85 171.14,56.35 171.16,56.33 171.16,56.26 171.3,56.12 171.58,56.12 171.89,55.81 171.89,55.6 171.36,55.06 171.31,55.06 171.29,55.05 170.65,55.05 170.64,55.06 170.51,55.06 170.51,55.07 170.43,55.07 170.35,54.98 170.35,54.83 170.51,54.67 v5(170.62,54.67)
  IN3 w0.109: 170.88,59.18 170.88,59.97 170.88,59.97 170.88,60.14 171.58,60.84 171.58,61.11 173.51,63.05 173.51,65.78 173.63,65.91 173.63,68.8 173.72,68.88 174.48,68.88 174.73,69.13 174.73,69.57 174.51,69.8 173.79,69.8 173.7,69.89 173.7,70.21 173.79,70.3 174.52,70.3 174.74,70.52 174.74,71 174.52,71.22 173.79,71.22 173.7,71.31 173.7,71.6 174.62,72.52 175.65,72.52 175.79,72.39 175.79,71.97 175.99,71.76 176.63,71.76 176.91,72.04 177.56,72.04 177.88,71.72 179.55,71.72 179.95,71.32 180.12,71.32 180.84,71.32 181.19,71.67 181.19,72.47 180.91,72.75 180.86,72.75 180.71,72.9 v5(180.71,73.04)
  BOTTOM w0.076: 180.35,73.69 180.35,73.39 v5(180.71,73.04)
  BOTTOM w0.132: RD84.1 179.96,76.51 179.96,76.32 180.34,75.94 180.34,74 180.37,73.97 180.37,73.71 180.35,73.69
DDR_M0_CLK#0: length 44.6
  IN3 w0.076: v5(169.71,55.32) 169.89,55.14 169.96,55.14 170.17,54.94 170.17,54.76 170.5,54.42 170.93,54.42 172.19,55.68 172.19,55.73 172.3,55.84 172.35,55.84 172.37,55.86 172.38,55.86
  IN3 w0.109: 172.38,55.86 173.13,55.86 173.2,55.78 173.42,55.78 173.49,55.86 174.39,55.86 174.46,55.78 174.68,55.78 174.83,55.93 174.83,55.96 174.99,56.12 175.1,56.12 175.11,56.11 175.15,56.11 175.33,56.11 175.76,56.55 176.99,56.55 177.86,57.42 178.03,57.42 178.73,57.42 178.74,57.43 179.11,57.8 179.11,58.5 184.34,63.72 189.52,63.72 190.05,63.2 190.42,63.2 191.23,62.38 191.23,61.52 191.33,61.42 192.72,61.42 192.94,61.2 192.94,60.73 192.72,60.51 191.33,60.51 191.23,60.41 191.23,55.1 191.46,54.87 192.57,54.87 192.77,54.68 193.46,54.68 193.67,54.89 194.35,54.89 v5(194.83,54.42)
  BOTTOM w0.076: 195.18,54.58 195.17,54.58 195.14,54.61 195.02,54.61 v5(194.83,54.42)
  BOTTOM w0.132: RD78.1 197.55,54.16 196.56,54.16 196.13,54.58 195.18,54.58
DDR_M0_CLK#1: length 37.1
  IN3 w0.076: 170.68,59.14 170.68,59.1 170.7,59.07 170.7,58.88 170.7,58.05 170.97,57.78 170.97,56.28 170.99,56.26 170.99,56.19 171.23,55.95 171.49,55.95 171.67,55.77 171.67,55.67 171.22,55.22 170.72,55.22 v5(170.62,55.32)
  IN3 w0.109: v5(180.71,73.84) 180.71,73.58 180.43,73.31 180.43,72.84 180.72,72.55 180.83,72.55 180.99,72.39 180.99,71.76 180.75,71.52 180.03,71.52 179.63,71.92 177.97,71.92 177.65,72.24 176.82,72.24 176.55,71.97 176.08,71.97 175.99,72.05 175.99,72.47 175.74,72.73 174.53,72.73 173.49,71.69 173.49,71.22 173.7,71.01 174.44,71.01 174.54,70.91 174.54,70.61 174.44,70.51 173.7,70.51 173.49,70.3 173.49,69.8 173.7,69.59 174.42,69.59 174.53,69.49 174.53,69.22 174.4,69.08 173.63,69.08 173.43,68.88 173.43,65.99 173.31,65.87 173.31,63.13 171.37,61.2 171.37,60.92 170.68,60.22 170.68,59.89 170.68,59.14
  BOTTOM w0.076: v5(180.71,73.84) 180.69,73.84 180.59,73.94
  BOTTOM w0.132: RD81.1 180.18,76.6 180.18,76.41 180.56,76.03 180.56,74.09 180.59,74.06 180.59,73.94
DDR_M0_CS#0: length 70
  IN1 w0.094: v4(183,73.2) 183.16,73.2 183.3,73.05 186.39,73.05 189.83,69.61 189.83,63.03 v6(189.25,62.45) 189.2,62.4 189.2,61.8 189.81,61.2 194.25,61.2 195.9,59.56 195.9,58.48 196.3,58.07 196.3,53.46 195.67,52.82 v6(194.43,52.82)
  IN3 w0.094: v4(183,73.2) 182.82,73.2 182.68,73.06 182.02,73.06 v5(182.01,73.04) ; v6(189.25,62.45) 188.9,62.79 188.49,62.79 188.05,62.35 184.23,62.35 179.81,57.93 179.81,57.6 179.79,57.58 179.79,57.57 179.06,56.84 179.05,56.84 178.91,56.84 178.91,56.84 178.21,56.84 176.76,55.4 176.18,55.4 175.94,55.16 175.94,52.29 175.78,52.14 175.78,52.01 175.51,51.73 174.6,51.73 174.41,51.55 170.58,51.55 169.58,50.54 166.72,50.54 166.3,50.97 166.3,51.39 165.43,52.26 165.43,53.45 165.39,53.49 165.39,53.49 165.29,53.59 165.29,53.84 164.9,54.23 164.9,54.78 165.15,55.03 v5(165.15,55.32)
  BOTTOM w0.127: v6(194.43,52.82) 194.14,53.12 UD42.L3 ; RD61.1 189.54,62.16 v6(189.25,62.45)
DDR_M0_CS#1: length 70.1
  IN1 w0.094: v6(193.62,52.82) 193.84,52.82 194.33,53.3 194.75,53.3 195.39,53.57 195.97,54.15 195.97,57.56 195.68,58.26 195.68,59.16 193.92,60.92 189.69,60.92 188.58,62.03 v6(188.58,62.29) 188.58,62.52 189.13,63.07 189.13,64.09 189.22,64.18 189.46,64.18 189.55,64.27 189.55,64.54 189.46,64.63 189.22,64.63 189.13,64.71 189.13,69.38 186.27,72.23 182.74,72.23 v4(182.33,72.64)
  IN3 w0.094: v4(182.33,72.64) 182.01,72.31 v5(182.01,72.24) ; v5(164.24,55.32) 163.66,54.74 163.66,52.78 166.1,50.35 170.23,50.35 170.74,50.86 172.7,50.86 173.19,51.34 174.7,51.34 174.84,51.48 176.05,51.48 177,52.43 177,52.86 177.25,53.11 177.25,53.61 177.03,53.83 177.03,54.13 177.27,54.37 177.27,54.84 177.05,55.06 177.05,55.39 178.31,56.66 179.13,56.66 180.08,57.6 180.08,57.8 184.35,62.07 188.35,62.07 v6(188.58,62.29)
  BOTTOM w0.127: v6(188.58,62.29) 188.44,62.16 RD64.1 ; UD42.L4 193.32,53.12 v6(193.62,52.82)
DDR_M0_D0: length 12.3
  IN3 w0.094: v5(179.27,51.4) 182.63,51.4 182.67,51.44 182.69,51.44 186.46,55.21 188.51,55.21 188.62,55.31 188.62,55.31 188.97,55.66 188.97,56.1 189.23,56.35 v5(189.23,56.37)
DDR_M0_D1: length 15.5
  IN3 w0.094: v5(189.23,57.67) 189.23,57.5 188.95,57.22 188.95,56.8 188.72,56.58 188.72,55.65 188.46,55.4 186.25,55.4 182.51,51.66 182.51,51.61 179.78,51.61 179.69,51.7 177.62,51.7 v5(177.32,51.4)
DDR_M0_D2: length 13.6
  IN3 w0.094: v5(177.32,52.7) 177.54,52.7 177.73,52.89 177.73,53.29 178,53.56 178.95,53.56 178.95,53.56 178.98,53.56 179.11,53.43 179.59,53.43 179.85,53.69 181.9,53.69 185.64,57.43 187.36,57.43 187.48,57.31 187.71,57.31 188,57.02 v5(188.43,57.02)
DDR_M0_D3: length 11.6
  IN3 w0.094: v5(187.63,57.02) 187.56,57.08 187.32,57.08 187.25,57.14 185.75,57.14 182.09,53.49 180.04,53.49 180.03,53.48 180.03,53.48 179.67,53.13 179.02,53.13 178.94,53.05 178.31,53.05 v5(177.97,52.7)
DDR_M0_D4: length 14.5
  IN3 w0.094: v5(178.62,51.4) 178.89,51.4 179.19,51.09 179.51,51.09 179.58,51.16 182.81,51.16 186.5,54.84 188.59,54.84 188.71,54.97 188.71,55.04 189.13,55.46 189.37,55.46 189.54,55.64 189.54,56.7 v5(189.23,57.02)
DDR_M0_D5: length 14.9
  IN3 w0.094: v5(177.97,51.4) 178.13,51.4 178.43,51.09 178.91,51.09 179.14,50.87 182.92,50.87 186.72,54.67 186.87,54.67 186.87,54.67 188.72,54.67 188.94,54.89 188.94,55.02 189.21,55.29 189.44,55.29 189.44,55.3 189.74,55.59 189.74,56.08 v5(190.03,56.37)
DDR_M0_D6: length 11.7
  IN3 w0.094: v5(188.43,56.37) 188.07,56.37 187.79,56.65 187.16,56.65 187.02,56.79 186.11,56.79 185.8,56.79 182.32,53.31 180.1,53.31 179.74,52.95 179.12,52.95 178.87,52.7 v5(178.62,52.7)
DDR_M0_D7: length 10.1
  IN3 w0.094: v5(187.63,56.37) 187.18,56.37 186.93,56.62 186.04,56.62 182.53,53.12 180.23,53.12 179.81,52.7 v5(179.27,52.7)
DDR_M0_D8: length 11.9
  IN3 w0.094: v5(187.63,58.29) 187.65,58.32 187.85,58.32 187.93,58.24 187.93,58.06 187.83,57.95 186.38,57.95 186.21,57.78 185.03,57.78 184.77,57.52 184.69,57.52 181.04,53.86 179.63,53.86 179.38,53.62 179.2,53.62 179.07,53.75 178.69,53.75 178.62,53.82 v5(178.62,53.92)
DDR_M0_D9: length 12.8
  IN3 w0.094: v5(177.32,53.92) 177.42,53.92 177.82,54.32 178.18,54.32 178.19,54.32 178.39,54.32 178.4,54.32 178.41,54.32 178.42,54.34 178.79,54.34 178.81,54.32 179.04,54.32 179.05,54.32 179.06,54.32 179.24,54.5 180.52,54.5 181.57,55.54 181.57,55.62 181.76,55.81 181.77,55.81 184.66,58.7 185.43,58.7 185.87,59.15 186.13,59.15 186.25,59.02 186.36,59.02 186.66,58.71 186.94,58.71 187.2,58.97 187.6,58.97 v5(187.63,58.99)
DDR_M0_D10: length 14.7
  IN3 w0.094: v5(190.03,58.32) 189.84,58.51 189.84,58.51 189.76,58.59 189.76,59.35 188.12,60.99 184.7,60.99 179.61,55.9 v5(178.95,55.9)
DDR_M0_D11: length 17.3
  IN3 w0.094: v5(177.32,55.22) 177.58,55.22 177.93,55.56 178.31,55.56 178.56,55.81 178.56,55.95 178.8,56.19 179.5,56.19 184.62,61.3 188.2,61.3 188.92,60.59 190,60.59 190.09,60.49 190.09,59.03 v5(190.03,58.97)
DDR_M0_D12: length 11.3
  IN3 w0.094: v5(179.27,53.92) 179.4,54.06 180.91,54.06 182.09,55.24 182.09,55.32 184.85,58.08 186.21,58.08 186.22,58.09 186.24,58.09 186.36,58.2 187.09,58.2 187.45,58.55 188.33,58.55 188.43,58.46 v5(188.43,58.32)
DDR_M0_D13: length 12.8
  IN3 w0.094: v5(188.42,58.97) 188.18,58.72 187.26,58.72 187.07,58.54 186.58,58.54 186.28,58.84 185.91,58.84 185.49,58.42 184.79,58.42 182.01,55.64 182.01,55.61 180.65,54.24 179.24,54.24 179.14,54.14 178.74,54.14 178.72,54.17 178.51,54.17 178.49,54.14 178.33,54.14 178.11,53.92 v5(177.97,53.92)
DDR_M0_D14: length 13.5
  IN3 w0.094: v5(189.23,58.97) 189.23,59.22 188.07,60.37 184.89,60.37 180,55.48 179.11,55.48 179.03,55.4 178.98,55.4 178.98,55.39 178.79,55.39 v5(178.62,55.22)
DDR_M0_D15: length 15.5
  IN3 w0.094: v5(177.97,55.22) 178.22,55.22 178.59,55.59 178.93,55.59 178.99,55.65 179.77,55.65 184.77,60.65 185.24,60.65 185.24,60.66 188.12,60.66 189.53,59.24 189.53,58.63 189.23,58.33 v5(189.23,58.32)
DDR_M0_D16: length 21.7
  IN1 w0.094: v6(187.23,51.49) 187.34,51.38 187.34,50.84 187.28,50.79 187,50.79 186.61,51.17 186.26,51.17 186.01,50.92 186.01,49.37 186.14,49.25 186.14,48.86 185.34,48.06 185.21,48.06 185.02,48.24 185.02,48.37 185.51,48.86 185.51,48.99 185.32,49.18 185.2,49.18 184.93,48.9 183.99,48.9 183.84,48.75 183.84,48.62 184.27,48.19 184.27,48.06 184.08,47.88 183.95,47.88 183.52,48.31 183.4,48.31 182.92,47.83 180.49,47.83 180.38,47.94 177.71,47.94 177.59,48.07 174.53,48.07 174.39,48.21 v6(174.39,48.6)
  BOTTOM w0.127: v6(187.23,51.49) 187.55,51.82 UD42.N11 ; UC1.J22 174.72,48.93 v6(174.39,48.6)
DDR_M0_D17: length 23.6
  IN1 w0.094: v6(175.04,50.64) 174.85,50.64 174.75,50.54 174.75,50.36 174.84,50.27 176.52,50.27 176.78,50.02 177.46,50.02 177.56,50.12 180.4,50.12 181.66,51.38 181.72,51.38 185.57,55.23 188.74,55.23 188.96,55.01 189.12,55.01 189.33,55.23 189.56,55.23 189.95,54.84 189.95,53.83 189.85,53.73 189.61,53.73 189.51,53.63 189.51,53.37 190.08,52.81 190.08,51.99 189.99,51.91 189.67,51.91 189.58,52 189.58,52.12 v6(189.62,52.17)
  BOTTOM w0.127: UD42.M9 189.32,52.47 v6(189.62,52.17) ; v6(175.04,50.64) 175.37,50.96 UC1.H25
DDR_M0_D18: length 20.2
  IN1 w0.094: v4(175.69,48.6) 175.53,48.6 175.46,48.67 175.46,48.85 175.55,48.94 176.65,48.94 176.81,48.78 181.95,48.78 182.17,49 182.3,49 182.48,48.82 182.6,48.82 182.79,49.01 182.79,49.14 182.61,49.31 182.61,49.44 182.8,49.63 182.93,49.63 183.11,49.45 183.23,49.45 183.42,49.64 183.42,49.76 183.24,49.94 183.24,50.07 183.52,50.35 183.52,51.26 185.37,53.11 187.16,53.11 187.79,52.48 188.6,52.48 188.75,52.33 188.75,51.88 188.68,51.81 188.32,51.81 v6(188.03,52.11)
  IN3 w0.094: v5(176.02,49.06) 176.02,48.93 v4(175.69,48.6)
  BOTTOM w0.127: v6(188.03,52.11) 188.38,52.47 UD42.M10
DDR_M0_D19: length 20
  IN1 w0.094: v6(187.23,52.14) 187.23,51.9 187.17,51.84 187.02,51.84 186.69,51.51 186.47,51.51 186.08,51.9 185.32,51.9 185.06,51.64 185.06,50.67 185.59,50.14 185.59,50.02 185.4,49.83 185.28,49.83 184.75,50.36 184.62,50.36 184.43,50.17 184.43,50.04 184.96,49.51 184.96,49.39 184.78,49.2 184.65,49.2 184.28,49.57 184.15,49.57 184.06,49.48 184.06,49.38 182.85,48.17 178.4,48.17 178.33,48.24 174.88,48.24 174.74,48.37 174.74,48.49 174.86,48.6 v6(175.04,48.6)
  BOTTOM w0.127: UD42.M11 187.55,52.47 v6(187.23,52.14) ; v6(175.04,48.6) 175.37,48.93 UC1.H22
DDR_M0_D20: length 23.8
  IN1 w0.094: v6(190.43,52.14) 190.6,51.97 190.74,51.97 190.85,52.07 190.85,52.93 190.93,53.02 191.22,53.02 191.31,53.11 191.31,53.37 191.22,53.46 190.85,53.46 190.76,53.55 190.76,53.82 190.85,53.91 191.24,53.91 191.33,54 191.33,54.8 190.99,55.15 190.85,55.15 190.76,55.06 190.76,54.57 190.65,54.46 190.35,54.46 190.24,54.57 190.24,54.96 189.98,55.22 189.98,55.39 189.81,55.56 185.5,55.56 181.6,51.66 181.54,51.66 180.39,50.52 177.05,50.52 177.04,50.53 v6(176.99,50.53)
  BOTTOM w0.127: v6(190.43,52.14) 190.16,52.14 190.03,52.28 UD42.M8 ; v6(176.99,50.53) 176.67,50.85 UC1.F25
DDR_M0_D21: length 22.7
  IN1 w0.094: v6(174.39,50.64) 174.39,50.28 174.59,50.08 176.47,50.08 176.73,49.82 177.57,49.82 177.7,49.95 180.63,49.95 181.77,51.09 181.83,51.09 185.76,55.02 188.6,55.02 189.19,54.43 189.19,51.26 189.61,50.84 v6(189.63,50.84)
  BOTTOM w0.127: UC1.J25 174.72,50.96 v6(174.39,50.64) ; UD42.P9 189.3,51.17 v6(189.63,50.84)
DDR_M0_D22: length 23.8
  IN1 w0.094: v6(175.69,50.64) 176.28,50.64 176.54,50.9 180.37,50.9 181.42,51.95 181.48,51.95 185.27,55.73 190.08,55.73 190.85,55.53 191.5,54.87 191.5,53.1 190.99,51.97 190.8,51.79 190.28,51.79 v6(189.6,51.5)
  BOTTOM w0.127: UD42.N9 v6(189.6,51.5) ; v6(175.69,50.64) UC1.G25
DDR_M0_D23: length 20.2
  IN1 w0.094: v4(176.34,48.6) 176.45,48.49 182.68,48.49 183.81,49.62 183.81,51.15 184.92,52.26 186.05,52.26 186.29,52.5 187.38,52.5 187.6,52.28 187.6,50.08 187.73,49.96 188.25,49.96 188.74,50.45 188.74,51.06 188.31,51.49 v6(188.03,51.49)
  IN3 w0.094: v4(176.34,48.6) 176.67,48.93 v5(176.67,49.06)
  BOTTOM w0.127: v6(188.03,51.49) 188.35,51.82 UD42.N10
DDR_M0_D24: length 18
  IN3 w0.094: v5(190.03,50.52) 190.59,49.95 190.59,47.91 188.8,46.12 184.87,46.12 184.34,46.65 180.48,46.65 179.11,48.02 178.81,48.02 178.25,48.58 177.62,48.58 v5(177.32,48.88)
DDR_M0_D25: length 15.9
  IN3 w0.094: v5(177.97,48.88) 178.23,48.88 178.48,48.63 178.7,48.63 179.03,48.3 179.26,48.3 180.56,47 184.5,47 185.05,46.45 188.73,46.45 190.28,48 190.28,49.61 v5(190.03,49.87)
DDR_M0_D26: length 11.2
  IN3 w0.094: v5(187.63,50.52) 187.19,50.08 187.19,49.76 186.6,49.16 186.25,49.16 185.58,49.83 182.82,49.83 182.35,50.29 181.06,50.29 180.71,50.64 179.27,50.64 179.19,50.56 179.09,50.56 179.04,50.51 178.3,50.51 177.98,50.18 v5(177.97,50.18)
DDR_M0_D27: length 13.2
  IN3 w0.094: v5(188.43,49.87) 188.43,49.69 187.92,49.19 187.92,48.45 187.62,48.15 185.88,48.15 185.12,48.91 181.06,48.91 180.25,49.72 179.11,49.72 179.01,49.82 177.7,49.82 177.33,50.18 v5(177.32,50.18)
DDR_M0_D28: length 13.5
  IN3 w0.094: v5(179.27,48.88) 179.57,48.88 180.74,47.71 184.81,47.71 185.42,47.09 188.57,47.09 189.3,47.82 189.3,47.82 189.7,48.22 189.7,49.39 v5(189.23,49.87)
DDR_M0_D29: length 15.5
  IN3 w0.094: v5(178.62,48.88) 178.88,48.88 179.13,48.63 179.39,48.63 180.64,47.37 184.63,47.37 185.25,46.75 188.63,46.75 189.92,48.04 189.92,49.53 189.75,49.7 189.75,49.99 v5(189.23,50.52)
DDR_M0_D30: length 10.7
  IN3 w0.094: v5(179.27,50.18) 179.45,50.18 179.6,50.33 180.56,50.33 181.35,49.54 181.62,49.54 181.71,49.62 181.71,49.99 181.8,50.07 182.06,50.07 182.15,49.99 182.15,49.62 182.24,49.54 185.42,49.54 186.09,48.86 186.69,48.86 187.16,49.33 187.52,49.33 187.75,49.57 187.75,49.74 v5(187.63,49.87)
DDR_M0_D31: length 12
  IN3 w0.094: v5(178.62,50.18) 178.9,50.18 179.16,49.93 179.55,49.93 179.65,50.02 180.41,50.02 181.18,49.25 185.22,49.25 186,48.47 187.37,48.47 187.4,48.49 187.4,48.49 187.61,48.7 187.61,49.11 188.12,49.62 188.12,50.21 v5(188.43,50.52)
DDR_M0_D32: length 15.4
  IN3 w0.094: v5(177.46,68.24) 177.89,67.81 179.46,67.81 179.73,67.54 179.73,64.46 179.88,64.32 179.88,63.7 180.44,63.14 180.44,62.19 180.11,61.86 180.11,61.28 177.55,58.71 177.15,58.71 176.91,58.47 175.38,58.47 v5(175.22,58.31)
DDR_M0_D33: length 17.4
  IN3 w0.094: v5(178.76,69.04) 179.05,68.75 179.53,68.75 180.61,67.67 180.61,67.23 180.46,67.07 180.46,66.23 180.94,65.75 180.94,63.69 181.38,63.24 181.38,61.34 177.99,57.95 177.38,57.95 176.39,56.96 175.82,56.96 v5(175.22,56.36)
DDR_M0_D34: length 13.2
  IN3 w0.094: v5(178.76,66.64) 178.76,66.28 178.75,66.28 178.6,66.13 178.6,64.84 178.67,64.76 178.67,63.57 178.77,63.47 178.77,61.4 176.33,58.96 174.97,58.96 174.48,58.48 174.48,57.64 174.17,57.32 174.17,56.95 174.17,56.95 174.17,56.91 173.92,56.66 v5(173.92,56.36)
DDR_M0_D35: length 13.3
  IN3 w0.094: v5(178.76,67.44) 178.4,67.08 178.4,66.36 178.33,66.3 178.33,65.61 178.42,65.53 178.42,65.17 178.32,65.07 178.32,63.78 178.41,63.69 178.41,62.94 178.27,62.81 178.27,61.31 176.11,59.15 174.84,59.15 174.27,58.57 174.27,57.66 173.92,57.31 v5(173.92,57.01)
DDR_M0_D36: length 15.1
  IN3 w0.094: v5(178.76,68.24) 179.31,68.24 179.95,67.6 179.95,66.04 180.6,65.39 180.6,63.3 180.81,63.08 180.81,61.58 177.64,58.41 177.1,58.41 176.99,58.3 175.86,58.3 v5(175.22,57.66)
DDR_M0_D37: length 17.2
  IN3 w0.094: v5(175.22,57.01) 175.7,57.5 176.09,57.5 176.25,57.34 176.52,57.34 177.33,58.15 177.78,58.15 181.1,61.46 181.1,63.12 180.77,63.45 180.77,65.67 180.24,66.19 180.24,67.18 180.38,67.32 180.38,67.66 179.53,68.51 178.37,68.51 v5(178.11,68.24)
DDR_M0_D38: length 12.5
  IN3 w0.094: v5(173.92,57.66) 173.78,57.8 173.78,58.08 173.66,58.2 173.66,58.45 174.7,59.49 175.69,59.49 176.45,60.24 176.45,60.29 177.48,61.32 177.48,62.87 177.48,62.87 177.48,62.92 177.73,63.17 177.73,63.62 177.48,63.87 177.48,65.78 177.71,66.01 177.71,66.64 177.81,66.74 177.81,67.14 v5(178.11,67.44)
DDR_M0_D39: length 11
  IN3 w0.094: v5(173.92,58.31) 173.92,58.46 174.77,59.32 175.76,59.32 176.54,60.09 176.65,60.09 177.76,61.2 177.76,62.77 178.1,63.11 178.1,63.7 177.89,63.91 177.89,65 177.69,65.19 177.69,65.48 177.89,65.69 178.11,65.9 v5(178.11,66.64)
DDR_M0_D40: length 11.6
  IN3 w0.094: v5(176.16,67.44) 176.46,67.13 176.46,66.38 176.6,66.25 176.6,65.66 176.41,65.47 176.41,64.86 176.11,64.56 176.11,61.88 172.96,58.73 172.96,58.22 172.7,57.96 v5(172.7,57.66)
DDR_M0_D41: length 13.5
  IN3 w0.094: v5(176.81,67.44) 176.81,67.04 177.13,66.72 177.13,65.8 177.3,65.62 177.3,64.34 176.75,63.79 176.75,63.51 176.75,63.5 176.75,63.06 176.75,63.05 176.75,61.62 174.83,59.7 174.67,59.7 173.44,58.48 173.44,58.13 173.57,58 173.57,57.72 173.44,57.58 173.25,57.58 173.05,57.39 173.05,56.71 v5(172.7,56.36)
DDR_M0_D42: length 13.2
  IN3 w0.094: v5(176.16,69.04) 175.83,68.71 174.97,68.71 174.36,68.11 174.36,65.44 174.2,65.28 174.2,62.76 172.27,60.83 172.27,60.7 171.56,60 171.56,58.48 v5(171.4,58.31)
DDR_M0_D43: length 14.5
  IN3 w0.094: v5(171.4,56.36) 171.8,56.77 171.8,57.24 171.8,57.44 171.92,57.56 171.92,57.81 171.8,57.93 171.8,58.1 172.02,58.33 172.02,58.93 172.1,59.01 172.1,59.81 174.78,62.49 174.78,65.05 174.87,65.15 174.87,65.27 175.32,65.71 175.32,66.49 174.9,66.91 174.9,67.38 175.11,67.58 175.25,67.58 175.9,68.24 v5(176.16,68.24)
DDR_M0_D44: length 10
  IN3 w0.094: v5(172.7,58.31) 172.7,58.91 175.79,62 175.79,62.07 175.81,62.08 175.81,64.62 175.8,64.63 176.16,64.99 176.16,65.48 176.43,65.75 176.43,66.06 176.16,66.34 v5(176.16,66.64)
DDR_M0_D45: length 11.6
  IN3 w0.094: v5(172.7,57.01) 172.7,57.3 172.97,57.57 172.97,57.93 173.16,58.12 173.16,58.45 176.46,61.75 176.46,63.17 176.47,63.18 176.47,64.43 177.13,65.09 177.13,65.47 176.87,65.72 176.87,65.95 176.81,66.01 v5(176.81,66.64)
DDR_M0_D46: length 15.1
  IN3 w0.094: v5(171.4,57.66) 171.4,57.96 171.15,58.21 171.15,58.33 171.15,58.33 171.15,58.46 171.31,58.63 171.31,60.03 171.98,60.7 171.98,60.95 173.92,62.88 173.92,65.45 174.14,65.68 174.14,68.16 174.88,68.9 175.42,68.9 175.86,69.34 176.49,69.34 176.78,69.04 v5(176.81,69.04)
DDR_M0_D47: length 15
  IN3 w0.094: v5(171.4,57.01) 171.4,57.3 171.68,57.58 171.68,57.74 171.62,57.8 171.62,58.17 171.85,58.4 171.85,59.97 174.49,62.6 174.49,65.16 174.65,65.32 174.65,65.61 174.59,65.67 174.59,68.09 174.98,68.48 176.04,68.48 176.05,68.49 176.56,68.49 v5(176.81,68.24)
DDR_M0_D48: length 23.1
  IN1 w0.094: v6(184.91,68.65) 184.91,68.66 185.27,69.03 186.64,69.03 187.42,68.25 187.42,64.31 177.45,54.34 v6(176.52,54.34)
  BOTTOM w0.127: UD41.R9 184.61,68.35 v6(184.91,68.65) ; UC1.G31 176.19,54.67 v6(176.52,54.34)
DDR_M0_D49: length 22.7
  IN1 w0.094: v6(176.54,54.99) 176.86,54.68 177.38,54.68 177.55,54.85 177.55,54.97 177.44,55.08 177.44,55.21 177.63,55.4 177.76,55.4 177.87,55.29 177.99,55.29 187.11,64.41 187.11,67.85 186.76,68.21 185.77,68.21 185.6,68.04 185.36,68.04 185.21,68.18 185.21,68.46 185.39,68.64 v6(185.58,68.64)
  BOTTOM w0.127: UC1.G32 176.21,55.32 v6(176.54,54.99) ; v6(185.58,68.64) 185.26,68.31 UD41.T9
DDR_M0_D50: length 21.6
  IN1 w0.094: v6(184.89,66.25) 184.89,66.49 184.8,66.58 184.66,66.58 184.26,66.18 184.26,65.93 184.63,65.55 184.63,64.55 180.7,60.61 179.61,60.61 177.23,58.24 177.23,57.82 176.96,57.55 176.22,57.55 175.02,56.34 175.02,54.43 174.9,54.32 174.9,52.86 175,52.77 175.48,52.77 175.58,52.86 v6(175.58,53.04)
  BOTTOM w0.127: UD41.R11 184.61,66.54 v6(184.89,66.25) ; v6(175.58,53.04) 175.25,53.37 UC1.H29
DDR_M0_D51: length 22.1
  IN1 w0.094: v6(184.93,67.04) 184.65,66.76 184.55,66.76 184.04,66.25 184.04,65.77 183.98,65.71 183.98,64.34 180.72,61.08 179.6,61.08 176.94,58.42 176.3,58.42 174.84,56.96 174.84,54.64 174.65,54.45 174.65,52.8 174.55,52.7 174.55,52.45 174.62,52.39 175.53,52.39 v6(175.55,52.41)
  BOTTOM w0.127: UC1.H28 175.25,52.72 v6(175.55,52.41) ; v6(184.93,67.04) 184.61,67.36 UD41.R10
DDR_M0_D52: length 26.2
  IN1 w0.094: v6(176.49,52.44) 176.49,52.44 177.25,53.2 177.25,53.33 188.03,64.11 188.03,68.79 186.65,70.17 185.66,70.17 v6(184.93,69.44)
  BOTTOM w0.127: v6(184.93,69.44) 184.61,69.11 UD41.R8 ; v6(176.49,52.44) 176.49,52.44 176.21,52.72 UC1.G28
DDR_M0_D53: length 24.3
  IN1 w0.094: v6(185.58,69.44) 186.06,69.92 186.5,69.92 187.74,68.68 187.74,64.22 176.56,53.04 v6(176.49,53.04)
  BOTTOM w0.127: UD41.T8 185.26,69.11 v6(185.58,69.44) ; v6(176.49,53.04) 176.16,53.37 UC1.G29
DDR_M0_D54: length 21.4
  IN1 w0.094: v6(185.58,67.04) 185.83,67.04 185.91,66.96 185.91,66.72 185.84,66.65 185.37,66.65 185.24,66.52 185.24,65.89 185.38,65.75 185.38,64.87 180.79,60.28 179.73,60.28 177.59,58.14 177.59,57.74 177.91,57.41 177.91,57.2 177.67,56.96 177.43,56.96 177.26,57.13 176.95,57.13 176.52,56.7 176.39,56.7 176.18,56.91 176.06,56.91 175.87,56.72 175.87,56.59 176.08,56.39 176.08,56.26 175.22,55.4 175.22,54.52 175.4,54.34 v6(175.58,54.34)
  BOTTOM w0.127: UC1.H31 175.25,54.67 v6(175.58,54.34) ; v6(185.58,67.04) 185.26,67.36 UD41.T10
DDR_M0_D55: length 23.2
  IN1 w0.094: v6(175.58,54.99) 175.58,55.34 175.99,55.75 175.99,55.78 176.74,56.53 177.66,56.53 178.43,57.3 178.43,57.42 177.96,57.89 177.96,58.02 178.15,58.21 178.28,58.21 178.75,57.74 178.87,57.74 179.06,57.93 179.06,58.05 178.59,58.52 178.59,58.65 178.78,58.84 178.91,58.84 179.38,58.37 179.5,58.37 179.69,58.56 179.69,58.68 179.22,59.15 179.22,59.28 179.41,59.46 179.54,59.46 180,59 180.13,59 180.32,59.19 180.32,59.31 179.97,59.66 179.97,59.78 180.16,59.97 180.29,59.97 180.63,59.63 180.76,59.63 186.34,65.21 186.34,65.53 185.63,66.25 v6(185.61,66.25)
  BOTTOM w0.127: UD41.T11 185.26,66.6 v6(185.61,66.25) ; v6(175.58,54.99) 175.25,55.32 UC1.H32
DDR_M0_D56: length 23.5
  IN1 w0.094: v6(173.78,54.34) 173.78,54.37 173.85,54.44 173.85,54.47 174.16,54.79 174.16,55.38 174,55.54 174,58.08 175.17,59.25 175.17,60.01 175.93,60.77 177.05,60.77 179.74,63.46 179.74,63.58 179.34,63.98 179.34,64.1 179.53,64.29 179.65,64.29 180.06,63.88 180.39,63.88 180.59,64.09 180.59,64.42 180.68,64.51 181.48,64.51 181.57,64.6 181.57,64.87 181.48,64.95 180.68,64.95 180.59,65.04 180.59,65.64 180.75,65.8 181.89,65.8 182.7,66.61 183.85,66.61 183.94,66.7 183.94,66.92 183.83,67.04 v6(183.59,67.04)
  BOTTOM w0.127: v6(173.78,54.34) 173.76,54.34 173.43,54.67 UC1.L31 ; UD41.N10 183.31,67.32 v6(183.59,67.04)
DDR_M0_D57: length 24.8
  IN1 w0.094: v6(173.78,54.99) 173.76,55.02 173.76,58.26 174.59,59.1 174.59,60.11 176.23,61.75 176.35,61.75 176.88,61.23 177,61.23 177.19,61.41 177.19,61.54 176.67,62.06 176.67,62.19 176.86,62.38 176.98,62.38 177.53,61.83 177.66,61.83 177.85,62.02 177.85,62.14 177.3,62.69 177.3,62.82 177.49,63.01 177.61,63.01 178.16,62.46 178.29,62.46 178.48,62.65 178.48,62.77 177.93,63.32 177.93,63.45 178.22,63.74 178.35,63.74 178.86,63.23 178.99,63.23 179.18,63.41 179.18,63.54 178.66,64.06 178.66,64.18 179.12,64.64 179.53,64.64 179.72,64.84 179.72,65.45 180.65,66.38 180.65,66.4 180.92,66.66 182.48,66.66 182.69,66.87 182.81,66.87 v6(182.98,67.04)
  BOTTOM w0.127: UC1.L32 173.43,55.32 173.76,54.99 v6(173.78,54.99) ; UD41.M10 182.98,67.11 v6(182.98,67.04)
DDR_M0_D58: length 24.6
  IN1 w0.094: v6(172.87,53.05) 172.87,53.16 172.32,53.71 172.32,59.12 172.5,59.3 172.5,60.86 174.89,63.24 174.89,64.01 176.04,65.17 176.04,66.36 178.65,68.96 179.92,68.96 180.01,69.06 180.59,69.06 180.82,68.82 181.85,68.82 182.14,69.11 182.62,69.11 v6(182.96,69.45)
  BOTTOM w0.127: v6(172.87,53.05) 172.55,53.37 UC1.N29 ; v6(182.96,69.45) 182.66,69.15 UD41.M8
DDR_M0_D59: length 28.1
  IN1 w0.094: v6(172.84,52.39) 172.52,52.72 172.52,53.24 172.02,53.74 172.02,60.82 174.6,63.4 174.6,64.13 175.76,65.29 175.76,66.61 179,69.85 180.13,69.85 180.9,69.09 181.76,69.09 182,69.32 182,69.57 182.27,69.84 183.14,69.84 183.32,69.65 183.32,68.94 183.59,68.67 v6(183.6,68.67)
  BOTTOM w0.127: UD41.N9 183.31,68.37 v6(183.6,68.67) ; v6(172.84,52.39) 172.52,52.72 UC1.N28
DDR_M0_D60: length 20.2
  IN1 w0.094: v6(173.79,52.41) 174.4,53.02 174.4,54.45 174.64,54.69 174.64,57.8 176.29,59.45 176.6,59.45 179.05,61.9 180.36,61.9 183.26,64.8 183.26,65.68 183.4,65.82 183.69,65.82 183.77,65.89 183.77,66.1 v6(183.63,66.24)
  BOTTOM w0.127: v6(183.63,66.24) 183.31,66.56 UD41.N11 ; v6(173.79,52.41) 173.48,52.72 UC1.L28
DDR_M0_D61: length 21
  IN1 w0.094: v6(182.98,66.24) 182.6,66.24 181.97,65.61 181.97,64.18 181.73,63.93 181.61,63.93 181.34,64.2 181.22,64.2 181.03,64.01 181.03,63.88 181.29,63.62 181.29,63.49 181.1,63.31 180.98,63.31 180.71,63.57 180.59,63.57 180.4,63.38 180.4,63.26 180.66,62.99 180.66,62.87 180.16,62.36 179.07,62.36 177.03,60.32 176.73,60.32 174.26,57.86 174.26,55.66 174.39,55.54 174.39,54.76 174.16,54.53 174.16,53.45 v6(173.76,53.04)
  BOTTOM w0.127: UC1.L29 173.43,53.37 v6(173.76,53.04) ; v6(182.98,66.24) 182.66,66.56 UD41.M11
DDR_M0_D62: length 22.9
  IN1 w0.094: v6(182.98,68.64) 182.68,68.94 182.22,68.94 182.06,68.78 182.06,68.78 181.67,68.39 180.87,68.39 180.7,68.23 179.78,68.23 179.69,68.32 179.69,68.43 179.6,68.52 179.33,68.52 179.24,68.43 179.24,68.32 179.15,68.23 178.4,68.23 176.56,66.39 176.56,66.25 176.33,66.02 176.33,65.05 175.17,63.89 175.17,62.95 172.9,60.68 172.9,59.4 172.49,58.99 172.49,54.7 v6(172.84,54.34)
  BOTTOM w0.127: v6(182.98,68.64) 182.66,68.31 UD41.M9 ; v6(172.84,54.34) 172.52,54.67 UC1.N31
DDR_M0_D63: length 23.9
  IN1 w0.094: v6(172.84,54.99) 172.84,55.23 172.77,55.31 172.77,58.83 173.35,59.41 173.35,60.71 175.46,62.82 175.46,63.78 176.48,64.8 176.95,64.8 177.22,65.06 177.22,65.51 176.86,65.88 176.86,66.28 178.51,67.93 181.75,67.93 182.01,68.18 182.58,68.18 182.73,68.03 182.73,67.65 182.84,67.54 183.15,67.54 183.23,67.62 183.23,67.79 184.11,68.67 v6(184.27,68.67)
  BOTTOM w0.127: v6(184.27,68.67) 183.96,68.36 UD41.P9 ; v6(172.84,54.99) 172.52,55.32 UC1.N32
DDR_M0_DQS0: length 14.5
  IN3 w0.076: 186.97,56.07 187.05,56.07 187.06,56.06 187.07,56.06 187.23,56.06 187.29,56.13 187.73,56.13 187.76,56.16 188.01,56.16 188.2,55.98 188.2,55.78 188.26,55.72 v5(188.43,55.72) ; v5(177.64,52.05) 177.72,52.13 177.72,52.29 177.87,52.44 178.05,52.44 178.15,52.55 178.4,52.55 178.51,52.44 179.36,52.44 179.38,52.47 179.4,52.47
  IN3 w0.102: 179.4,52.47 179.65,52.47
  IN3 w0.109: 186.97,56.07 186.7,56.07 186.6,56.17 186.16,56.17 182.11,52.12 181.39,52.12 181.29,52.23 181.29,52.65 181.07,52.87 180.6,52.87 180.38,52.65 180.38,52.23 180.27,52.12 179.99,52.12 179.65,52.47

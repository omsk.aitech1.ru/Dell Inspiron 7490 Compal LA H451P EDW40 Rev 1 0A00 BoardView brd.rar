# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 117.35,12.79 117.35,11.16 116.94,10.75 116.94,10.44 116.59,10.09 116.59,9.23 115.13,7.77 113.84,7.77 111.23,5.16 110.43,5.16 109.77,5.82 108.64,5.82 108.06,5.23 102.67,5.23 102.39,5.52 102.39,8.81 102.56,8.98 106.38,8.98 107.54,10.14 111.03,10.14 111.45,10.56 111.45,12.84 111.6,12.99 117.14,12.99
GND on BOTTOM (solid shape): 147.98,21.3 147.98,18.52 147.98,16.91 147.6,16.53 146.01,16.53 145.63,16.15 144.61,16.15 144.61,16.16 144.12,16.16 144.08,16.2 144.08,17.1 143.45,17.73 143.45,19.35 143.55,19.46 144.95,19.46 145.28,19.79 145.28,21.41 145.4,21.54 147.75,21.54
GND on BOTTOM (solid shape): 20.58,35.67 20.58,34.57 20.62,34.53 21.76,34.53 21.88,34.65 21.88,35.1 21.87,35.11 21.87,35.69 21.9,35.72 22.09,35.72 22.14,35.68 22.14,27.75 22.06,27.68 21.98,27.68 21.91,27.75 21.91,28.72 21.73,28.89 18.68,28.89 18.58,29 18.58,34.46 18.66,34.53 19.38,34.53 19.49,34.65 19.49,35.66 19.58,35.74 20.51,35.74
GND on BOTTOM (solid shape): 130.34,20.39 130.34,20.2 130.35,20.18 130.35,19.17 130.44,19.08 130.52,19 132.05,19 132.08,18.98 132.08,17.85 131.41,17.17 131.41,16.04 131.36,15.99 130.52,15.99 130.37,16.14 130.37,17.36 129.96,17.76 129.65,17.76 129.63,17.78 129.23,17.78 129.14,17.87 129.14,18.7 128.88,18.95 128.88,20.33 129.01,20.46 130.27,20.46
GND on BOTTOM (solid shape): 132.37,29.5 132.37,26.71 131.3,25.64 131.3,22.32 130.85,21.88 129.03,21.88 128.92,21.98 128.92,23.25 129.49,23.82 129.49,24.41 129.56,24.48 130.08,24.48 130.17,24.57 130.17,26.08 130.27,26.18 130.62,26.18 131.41,26.96 131.41,27.6 131.18,27.83 130.09,27.83 129.37,27.12 126.5,27.12 125.06,28.56 125.06,31.21 126.58,32.73 129.15,32.73
GND on BOTTOM (solid shape): 15.92,28.33 17.26,28.33 17.43,28.16 17.43,26.55 17.31,26.43 15.94,26.43 15.6,26.77 15.21,26.77 14.95,26.51 14.95,24.98 14.69,24.73 12.37,24.73 11.95,24.31 9.27,24.31 9.26,24.32 9.26,25.24 9.36,25.34 11.99,25.34 12.09,25.24 12.92,25.24 13.04,25.36 13.04,26.38 13.17,26.51 13.42,26.51 13.68,26.76 13.68,27.4 13.8,27.52 13.8,28.54 14.06,28.79 15.46,28.79
GND on BOTTOM (solid shape): 193.92,71.79 193.92,71.22 193.82,71.12 193.47,71.12 193.44,71.1 193.36,71.04 193.3,70.95 193.25,70.9 193.25,69.73 193.19,69.67 192.89,69.67 192.83,69.72 192.83,70.66 192.91,70.74 192.91,70.93 193.12,71.14 193.12,71.6 193.12,71.61 193.2,71.68 193.2,71.82 193.26,71.88 193.82,71.88
GND on BOTTOM (solid shape): 198.21,34.04 200.61,34.04 200.95,33.7 200.95,30.85 201.17,30.64 201.17,29.11 200.93,28.87 200.52,28.87 200.39,29 200.39,29.23 200.03,29.6 199.64,29.6 199.44,29.8 199.43,29.81 199.38,29.86 198.49,29.86 198.29,30.06 198.29,30.85 198.51,31.08 198.51,32.95 198.21,33.26 196.11,33.26 195.96,33.4 195.96,33.97 196.13,34.14 198.11,34.14
GND on BOTTOM (solid shape): 38.55,59.01 36.05,55.01 36.05,48.5 35.62,48.07 35.62,44.4 34.97,43.76 29.04,43.76 28.98,43.7 27.15,40.77 27.15,37.15 26.35,37.15 26.35,38.64 25.41,38.64 25.39,38.67 25.39,39.99 25.46,40.06 26.17,40.06 26.17,40.06 26.35,40.06 26.35,41 31.54,49.3 35.25,49.3 35.25,55.24 35.42,55.51 37.75,59.24 37.75,63.7 28.83,63.7 28.83,64.5 38.55,64.5
GND on BOTTOM (solid shape): 118.3,71.22 118.41,71.24 118.47,71.15 118.47,71.06 118.25,70.84 118.24,70.83 118.13,70.76 118.06,70.65 118.06,70.64 117.99,70.58 117.99,67.21 117.93,67.12 117.82,67.14 117.7,67.25 117.7,70.62
GND on BOTTOM (solid shape): 181.23,14.17 181.23,13.26 181.63,12.85 182.25,12.85 182.62,13.22 183.69,13.22 183.78,13.13 183.78,13.01 183.7,12.93 182.63,12.93 182.4,12.71 182.4,11.37 182.32,11.28 181.57,11.28 181.37,11.09 181.37,10.48 181.72,10.14 181.72,9.48 181.62,9.38 177.77,9.38 177.59,9.56 177.59,10.65 177.23,11.02 177.23,12.54 177.31,12.62 178.99,12.62 179.21,12.84 179.21,14.64 179.29,14.72 180.68,14.72
GND on BOTTOM (solid shape): 177.85,30.51 177.85,29.94 177.83,29.92 177.83,29.33 177.83,29.32 177.83,26.07 177.66,25.9 176.19,25.9 175.99,26.1 175.99,28.33 175.82,28.5 175.82,29.61 175.82,29.61 175.47,29.97 175.25,29.97 175.25,30.09 174.36,30.09 174.36,30.08 173.4,30.08 173.4,29.97 173.06,29.97 172.86,29.77 172.86,28.85 172.77,28.76 169.5,28.76 168.93,29.33 168.93,29.62 169.02,29.71 169.02,30.87 170.87,30.87 170.92,30.92 171.08,30.92 171.16,31.01 177.35,31.01
GND on BOTTOM (solid shape): 139.46,20.45 139.46,19.48 139.47,19.46 140.11,19.46 140.19,19.55 140.19,19.75 140.35,19.9 140.89,19.9 141.08,20.09 141.48,20.09 141.53,20.07 141.6,20.06 142.18,20.06 142.23,20.07 142.27,20.08 142.32,20.03 142.32,19.89 142.24,19.81 141.11,19.81 140.94,19.64 140.94,18.26 140.83,18.15 140.04,18.15 139.61,18.58 138.45,18.58 138.36,18.67 138.36,20.38 138.51,20.52 139.38,20.52
GND on BOTTOM (solid shape): 17.48,18.32 17.48,17.04 17.34,16.91 16.45,16.91 16.33,16.8 16.33,15.78 16.15,15.6 14.5,15.6 14.08,15.18 12.93,15.18 12.88,15.13 11.92,15.13 11.74,14.95 10.9,14.95 10.82,15.03 10.82,15.48 10.85,15.5 11.59,15.5 11.69,15.41 12.84,15.41 13.3,15.87 15.55,15.87 15.67,15.99 15.67,17.31 16.06,17.7 16.06,18.32 16.19,18.45 17.34,18.45
GND on BOTTOM (solid shape): 172.54,14.61 173.29,14.61 173.55,14.35 173.55,12.99 173.68,12.86 173.69,12.87 174.4,12.87 174.75,13.22 175.96,13.22 176.03,13.14 176.03,13.02 175.96,12.95 174.81,12.95 174.66,12.81 174.66,11.21 174.58,11.13 173.95,11.13 173.25,10.43 171.67,10.43 171.57,10.32 171.57,9.32 171.47,9.22 170.57,9.22 170.46,9.33 170.46,10.45 170.16,10.75 169.53,10.75 169.39,10.89 169.39,12.44 169.47,12.53 171.21,12.53 171.39,12.71 171.39,14.51 171.49,14.62 172.53,14.62
GND on BOTTOM (solid shape): 193.63,63.35 193.71,63.26 194.37,63.26 194.46,63.17 194.46,62.56 194.33,62.42 192.67,62.42 192.42,62.17 192.41,62.16 192.29,62.03 191.35,62.03 191.33,62.05 191.33,62.23 191.22,62.35 190.26,62.35 189.93,62.67 189.56,62.67 189.4,62.83 188.44,62.83 188.12,63.16 187.72,63.16 187.06,62.5 187.06,61.97 187.04,61.95 184.84,61.95 184.67,62.12 184.67,63.72 184.92,63.97 184.96,63.97 185.21,64.22 188.72,64.22 188.78,64.16 188.81,64.16 189.49,63.47 191.03,63.47 191.31,63.19 191.31,62.8 191.56,62.56 192.08,62.56 192.16,62.64 192.16,63.24 192.34,63.42 192.34,64.34 192.45,64.45 193.63,64.45
GND on BOTTOM (solid shape): 136.75,58.41 138.16,58.41 138.44,58.13 138.44,57.79 138.43,57.75 138.43,57.71 138.43,57.62 138.43,57.58 138.44,57.54 138.44,57.14 138.43,57.07 138.31,56.96 137.98,56.96 137.92,57.02 137.92,57.17 137.91,57.26 137.86,57.35 137.86,57.72 137.43,58.15 137.12,58.15 136.94,58.23 136.76,58.17 136.74,58.15 136.7,58.15 136.56,58.29 135.08,58.29 134.9,58.47 134.89,58.47 134.89,58.54 134.95,58.61 136.55,58.61
GND on BOTTOM (solid shape): 189.32,37.49 189.32,36.11 189.32,36.11 189.32,36.05 189.3,36.04 188.41,35.16 187.85,34.05 187.85,34.03 187.52,33.71 187.52,29.24 187.98,28.77 187.98,28.74 188.01,28.74 188.17,28.58 188.17,27.34 188.09,27.25 184.37,27.25 184.3,27.18 184.3,26.1 184.09,25.89 181.94,25.89 181.88,25.95 181.88,30.08 181.37,30.59 178.26,30.59 177.97,30.88 177.97,31.8 178.14,31.97 183.3,31.97 184.45,33.12 184.45,34.02 184.15,34.32 184.15,34.9 183.97,35.08 183.59,35.08 183.58,35.08 183.19,35.08 183.15,35.12 183.15,37.19 183.24,37.29 185.2,37.29 185.54,37.62 186.47,37.62 186.47,37.65 189.16,37.65
GND on BOTTOM (solid shape): 135.64,79.7 135.74,79.62 135.86,79.59 135.86,79.02 136.15,78.74 136.15,78.66 136.11,78.49 136.15,78.32 136.15,62.4 119.87,62.4 119.85,62.42 119.85,77.2 76.25,77.2 76.25,63.32 75.45,63.32 75.45,78 115.15,78 115.15,78 115.31,77.61 115.7,77.44 116,77.44 116.39,77.61 116.56,78 116.56,78 120.65,78 120.65,63.2 135.35,63.2 135.35,79.7
GND on BOTTOM (solid shape): 31.08,36.16 31.84,36.16 32.22,35.78 32.22,32.4 32.25,32.37 32.25,31.12 32.09,30.97 30.01,30.97 29.31,30.27 29.31,30.09 29.15,29.92 29.15,29.87 29.11,29.83 29.11,29.32 29,29.2 28.99,29.2 28.91,29.15 28.85,29.09 28.28,29.09 28.28,29.41 28.66,29.41 28.69,29.43 28.69,30.09 28.54,30.24 28.54,32.3 28.59,32.35 29.02,32.35 29.04,32.38 29.04,32.96 28.84,33.16 28.84,33.82 28.9,33.88 29.56,33.88 29.56,33.9 29.86,33.9 29.93,33.82 30.38,33.82 30.38,34.27 30.37,34.29 30.37,34.33 29.87,34.83 29.87,35.91 30.13,36.17 31.07,36.17
GND on BOTTOM (solid shape): 191.01,72.89 191.01,72.77 190.78,72.77 190.78,71.96 191.28,71.96 191.39,71.85 191.99,71.85 192.11,71.72 192.11,69.51 192.21,69.42 193.95,69.42 194.12,69.24 194.12,69.06 194.07,69 191.58,69 191.23,69.36 191.2,69.36 191.15,69.41 190.23,69.41 189.71,68.89 189.71,67.5 189.45,67.24 189.45,65.55 189.42,65.52 188.91,65.52 188.71,65.72 188.23,65.72 188.21,65.74 188.21,68.77 188.23,68.79 188.38,68.79 188.48,68.9 188.48,69.92 188.45,69.95 188.45,70.02 188.38,70.02 188.28,70.12 188.28,71.76 188.42,71.76 188.43,71.77 188.45,71.77 188.45,71.79 188.53,71.87 188.53,72.88 188.41,73 188.3,73 188.3,73.4 188.34,73.48 188.44,73.49 189.37,73.33 190.26,73.64
GND on BOTTOM (solid shape): 20.98,43.75 21.01,43.67 20.95,43.59 20.83,43.35 21.03,43.16 21.1,43.13 21.12,43.06 21.12,41.94 21.12,41.85 21.09,41.78 21.03,41.75 20.82,41.48 21.11,41.3 21.12,41.3 21.19,41.3 21.19,41.26 21.42,41.04 21.42,40.08 21.38,40.04 20.38,40.04 20.23,40.19 20.23,40.97 20.11,41.09 20.11,41.12 20.1,41.12 20.1,42.34 20.07,42.38 20.07,43.31 20.07,43.31 20.07,43.78 20.12,43.83 20.9,43.83
GND on BOTTOM (solid shape): 110.87,72.64 111.08,72.56 111.29,72.63 111.3,72.64 111.42,72.64 111.56,72.5 111.56,72.45 111.55,72.44 111.58,72.14 111.88,72.12 111.91,72.15 112.51,71.55 112.52,71.54 112.58,71.41 112.69,71.32 112.74,71.25 112.72,71.17 112.77,70.73 113.21,70.73 113.28,70.75 113.34,70.72 116.42,67.64 116.42,67.08 118.07,65.43 118.07,64.34 117.68,63.95 117.24,63.95 109.76,71.43 109.76,71.46 110.14,71.84 110.64,72.33 110.64,72.63 110.65,72.64
GND on BOTTOM (solid shape): outline of 119 points within 163.79,57.13 175.08,76.98
GND on BOTTOM (solid shape): outline of 82 points within 116.81,60.66 122.53,73.18
GND on BOTTOM (solid shape): outline of 145 points within 126.94,30.44 134.1,35.3
GND on BOTTOM (solid shape): outline of 231 points within 191.35,72.91 197,79.11
GND on BOTTOM (solid shape): outline of 514 points within 0.3,43.01 21.08,63.67
GND on BOTTOM (solid shape): outline of 3929 points within 20.43,50.43 32.79,62.34
GND on BOTTOM (solid shape): outline of 6464 points within 0.2,0.2 215.51,81.6
GND on IN1 (solid shape): 18.67,17.38 18.67,14.63 18.15,14.11 15.53,14.11 15.1,14.54 15.1,17.38 15.41,17.69 18.36,17.69
GND on IN1 (solid shape): 26.35,57.62 26.35,55.08 26.3,55.03 25.93,55.03 25.85,55.11 25.85,57.63 25.95,57.73 26.24,57.73
GND on IN1 (solid shape): 46.54,62.6 46.54,59.97 46.35,59.78 45.65,59.78 45.5,59.93 45.5,62.68 45.53,62.71 46.43,62.71
GND on IN1 (solid shape): 56.85,65.36 56.85,62.26 56.71,62.12 53.53,62.12 53.31,62.35 53.31,65.3 53.51,65.5 56.71,65.5
GND on IN1 (solid shape): 59.48,74.59 59.48,67.45 58.96,66.93 57.74,66.93 57.56,67.11 57.56,74.48 58.21,75.13 58.93,75.13
GND on IN1 (solid shape): 96.72,28.73 96.72,28.24 96.5,28.02 93.44,28.02 93.31,28.15 93.31,28.65 93.48,28.83 96.63,28.83
GND on IN1 (solid shape): 111.71,67.75 111.71,63.1 111.65,63.04 110.33,63.04 110.16,63.21 110.16,67.83 110.27,67.95 111.51,67.95
GND on IN1 (solid shape): 137.78,25.26 137.78,21.93 137.68,21.83 136.66,21.83 136.41,22.09 136.41,25.44 136.59,25.62 137.43,25.62
GND on IN1 (solid shape): 198.33,59.8 198.33,58.9 198.1,58.66 196.44,58.66 196.32,58.78 196.32,59.89 196.4,59.98 198.15,59.98
GND on IN1 (solid shape): 101.79,18.76 101.79,18.15 101.61,17.97 101.08,17.97 101,18.05 98.16,18.05 97.83,18.38 97.83,18.91 98.18,19.27 101.28,19.27
GND on IN1 (solid shape): 20.73,24.26 20.73,20.91 21.39,20.25 25.23,20.25 25.68,19.8 25.68,18.98 25.31,18.62 18.96,18.62 18.54,19.04 18.54,24.39 18.8,24.65 20.34,24.65
GND on IN1 (solid shape): 110.77,19.29 110.77,18.63 110.71,18.56 108.98,18.56 108.84,18.71 108.84,18.86 108.99,19.01 109.12,19.01 109.18,19.08 109.18,19.35 109.31,19.48 110.58,19.48
GND on IN1 (solid shape): 112.38,30.5 112.38,30.38 112.38,29.27 111.89,28.78 110.25,28.78 109.86,29.17 109.86,30.13 110.42,30.69 112.18,30.69
GND on IN1 (solid shape): 116.57,11.2 116.57,10.46 116.46,10.35 115.97,10.35 115.16,9.54 111.96,9.54 111.72,9.78 111.72,11.16 111.84,11.27 116.5,11.27
GND on IN1 (solid shape): 188.5,14.12 188.5,10.89 187.89,10.28 185.13,10.28 184.86,10.55 184.86,11.77 184.94,11.85 185.86,11.85 186.05,12.04 186.05,14.33 186.28,14.56 188.06,14.56
GND on IN1 (solid shape): 204.69,43.46 204.69,39.69 204.5,39.5 200.4,39.5 199.84,40.05 199.84,41.07 199.4,41.51 199.4,42 198.99,42.41 198.99,43.3 199.47,43.79 204.36,43.79
GND on IN1 (solid shape): 173.68,14.94 173.68,14.32 172.26,12.9 172.26,12.1 172.07,11.91 170.82,11.91 170.68,12.05 170.68,13.13 170.38,13.43 169.36,13.43 169.1,13.69 169.1,14.81 169.28,14.99 173.63,14.99
GND on IN1 (solid shape): 56.85,74.5 56.85,70.56 56.27,69.98 52.2,69.98 51.73,70.44 51.73,71.82 51.88,71.96 52.72,71.96 52.84,72.08 52.84,72.63 52.9,72.69 53.08,72.69 53.16,72.78 53.16,74.36 53.21,74.4 53.21,74.74 53.47,75 56.36,75
GND on IN1 (solid shape): 73.44,57.47 73.44,53.18 70.29,50.03 66.69,50.03 66.38,50.33 66.38,50.87 66.87,51.35 66.87,52.96 69.68,52.96 69.68,52.76 70.27,52.17 70.53,52.17 70.94,52.59 70.94,52.9 70.42,53.42 70.14,53.42 69.68,52.96 66.87,52.96 66.87,58.28 67.83,59.25 71.67,59.25
GND on IN1 (solid shape): 180.16,15.07 181.16,15.07 181.28,14.95 181.28,13.91 180.34,12.97 180.34,11.83 180.02,11.51 178.15,11.51 178.06,11.6 178.06,12.64 178.09,12.72 178.1,12.8 178.1,13.55 178.09,13.62 178.06,13.71 178.06,14.89 178.25,15.08 180.16,15.08
GND on IN1 (solid shape): 169.92,49.37 169.92,47.28 169.81,47.17 169.81,46.26 169.81,46.25 169.81,43.19 168.73,42.11 168.73,40.98 168.66,40.79 168.73,40.6 168.73,39.77 168.64,39.68 168.14,39.68 168.01,39.81 168.01,44.43 167.84,44.6 166.56,44.6 165.73,45.42 165.73,47.54 166.13,47.94 168.24,47.94 168.3,48 168.32,48 168.44,48.07 168.51,48.2 168.51,48.21 168.89,48.59 168.89,49.4 169.08,49.59 169.26,49.59 169.28,49.62 169.67,49.62
GND on IN1 (solid shape): 103.63,54 104.86,54 104.9,53.99 104.95,54 107.12,54 107.34,53.77 107.34,53.55 107.34,53.55 107.34,52.86 107.02,52.54 105.77,52.54 105.24,53.08 105.24,53.09 104.85,53.3 104.6,52.93 104.6,52.9 104.24,52.54 103.61,52.54 103.46,52.7 103.42,52.75 103.37,52.78 103.31,52.85 103.17,52.85 102.9,52.85 102.82,52.93 102.82,53.6 102.82,53.61 102.82,54.05 102.95,54.18 103.44,54.18
GND on IN1 (solid shape): 25.33,17.91 25.33,13.61 24.39,12.67 22.32,12.67 22.29,12.67 22.25,12.68 22.21,12.67 22.18,12.67 19.6,12.67 19.27,12.99 19.27,17.51 22.75,17.51 22.75,17.46 22.76,17.41 22.77,17.36 22.8,17.31 22.83,17.27 22.86,17.24 22.91,17.2 22.95,17.18 23,17.16 23.05,17.16 23.1,17.16 23.16,17.16 23.2,17.18 23.25,17.2 23.29,17.24 23.33,17.27 23.36,17.31 23.38,17.36 23.4,17.41 23.41,17.46 23.41,17.51 23.4,17.56 23.38,17.61 23.36,17.66 23.33,17.7 23.29,17.74 23.25,17.77 23.2,17.79 23.16,17.81 23.1,17.82 23.05,17.82 23,17.81 22.95,17.79 22.91,17.77 22.86,17.74 22.83,17.7 22.8,17.66 22.77,17.61 22.76,17.56 22.75,17.51 19.27,17.51 19.27,17.95 19.65,18.32 24.92,18.32
GND on IN1 (solid shape): 27.5,57.7 27.57,57.67 27.6,57.6 27.6,57.29 27.67,57.22 27.67,57.01 27.72,56.97 28.53,56.97 28.54,56.96 28.64,56.94 28.75,56.96 28.76,56.97 28.86,56.97 29.02,56.81 29.02,56.79 28.97,56.62 29.02,56.45 29.02,56.29 28.96,56.23 28.86,56.23 28.73,56.36 28.67,56.37 28.63,56.38 28.6,56.4 28.56,56.42 27.87,56.42 27.68,56.23 27.68,55.9 28.05,55.53 28.05,55.29 28.06,55.23 28.05,55.17 28.05,55.06 28,55.02 27.79,55.02 27.54,55.26 27.53,55.26 27.5,55.29 27.22,55.29 27.12,55.39 27.12,57.67 27.14,57.7
GND on IN1 (solid shape): outline of 154 points within 161.06,36.86 166.5,41.52
GND on IN1 (solid shape): outline of 156 points within 174.62,42.86 180.53,44.92
GND on IN1 (solid shape): 8.44,62.4 8.44,61.77 8.5,61.7 9.54,61.7 9.83,61.41 9.83,60.75 9.31,60.23 7.18,60.23 6.94,60.06 6.68,59.93 4.94,58.19 4.94,53.84 6.07,52.71 12.57,52.71 14.16,51.12 14.16,50.3 13.52,49.66 10.94,49.66 10.79,49.72 10.63,49.71 10.6,49.7 10.55,49.75 10.51,49.75 10.51,50.08 11.01,50.85 10.31,51.45 1.7,51.45 1.7,52.15 1.56,52.51 1.2,52.65 0.6,52.65 0.53,52.68 0.5,52.75 0.5,53.85 0.53,53.92 0.6,53.95 1.45,53.95 1.81,54.09 1.95,54.45 1.95,58.65 1.75,59.15 1.25,59.35 0.4,59.35 0.33,59.38 0.3,59.45 0.3,59.75 0.33,59.82 0.4,59.85 0.52,59.85 0.86,59.98 1.02,60.3 1.15,60.76 1.44,61.15 2.81,61.15 4.1,61.15 5.79,61.15 6.56,60.66 7.16,61.35 7.16,62.72 8.11,62.72
GND on IN1 (solid shape): outline of 296 points within 0.2,0.2 215.51,81.6
GND on IN2 (solid shape): 204.94,43.26 204.94,39.76 204.41,39.23 199.05,39.23 198.5,39.78 198.5,43.61 198.89,44 204.2,44
GND on IN2 (solid shape): 114.35,11.19 116.48,11.19 116.55,11.12 116.55,10.27 116.45,10.17 111.3,10.17 111.16,10.31 111.16,11.16 111.21,11.22 114.32,11.22
GND on IN2 (solid shape): 181.21,14.64 181.21,11.69 180.87,11.35 178.19,11.35 177.91,11.63 177.91,12.56 178.02,12.8 177.91,13.04 177.91,14.87 178.11,15.08 180.78,15.08
GND on IN2 (solid shape): 57.02,66.35 57.02,62.37 56.35,61.7 53.3,61.7 52.73,62.27 52.73,64.59 52.88,64.87 52.73,65.15 52.73,66.41 53.08,66.76 56.6,66.76
GND on IN2 (solid shape): 188.53,13.74 188.53,10.38 188.15,10 185.03,10 184.26,10.77 184.26,12.45 185.23,12.45 185.24,12.4 185.25,12.35 185.27,12.31 185.29,12.27 185.33,12.23 185.37,12.2 185.41,12.17 185.45,12.16 185.5,12.15 185.55,12.14 185.6,12.15 185.65,12.16 185.69,12.18 185.73,12.21 185.77,12.25 185.8,12.29 185.82,12.33 185.84,12.38 185.84,12.42 185.84,12.47 185.84,12.52 185.82,12.57 185.8,12.61 185.77,12.65 185.73,12.69 185.69,12.71 185.65,12.74 185.6,12.75 185.55,12.76 185.5,12.75 185.45,12.74 185.41,12.73 185.37,12.7 185.33,12.67 185.29,12.63 185.27,12.59 185.25,12.55 185.24,12.5 185.23,12.45 184.26,12.45 184.26,13.76 184,14.02 184.18,14.2 188.07,14.2
GND on IN2 (solid shape): 172.75,15.1 173.58,15.1 173.75,14.93 173.75,14.02 173.17,13.45 173.17,12.4 172.52,11.74 169.13,11.74 168.84,12.04 168.84,12.39 169.54,12.39 169.55,12.34 169.56,12.29 169.58,12.25 169.6,12.2 169.64,12.17 169.67,12.14 169.72,12.11 169.76,12.09 169.81,12.08 169.86,12.08 169.91,12.09 169.96,12.1 170,12.12 170.04,12.15 170.08,12.19 170.11,12.22 170.13,12.27 170.14,12.31 170.15,12.36 170.15,12.41 170.14,12.46 170.13,12.51 170.11,12.55 170.08,12.59 170.04,12.62 170,12.65 169.96,12.67 169.91,12.69 169.86,12.69 169.81,12.69 169.76,12.68 169.72,12.66 169.67,12.64 169.64,12.61 169.6,12.57 169.58,12.53 169.56,12.48 169.55,12.44 169.54,12.39 168.84,12.39 168.84,14.76 169.18,15.1 172.74,15.1
GND on IN2 (solid shape): 8.42,62.41 8.42,61.75 8.49,61.68 9.5,61.68 9.84,61.34 9.84,60.71 9.46,60.33 7.54,60.33 6.28,59.07 4.73,59.07 4.17,58.51 4.17,54.08 5.98,52.26 10.31,52.26 10.39,52.26 10.48,52.26 13.49,52.26 14.23,51.52 14.23,50.35 13.54,49.66 10.67,49.66 10.58,49.75 10.52,49.75 10.52,50.08 11.01,50.85 10.31,51.45 1.7,51.45 1.7,52.15 1.56,52.51 1.2,52.65 0.6,52.65 0.53,52.68 0.5,52.75 0.5,53.85 0.53,53.92 0.6,53.95 1.45,53.95 1.81,54.09 1.95,54.45 1.95,58.65 1.75,59.15 1.25,59.35 0.4,59.35 0.33,59.38 0.3,59.45 0.3,59.75 0.33,59.82 0.4,59.85 0.52,59.85 0.86,59.98 1.02,60.3 1.15,60.76 1.44,61.15 5.79,61.15 6.56,60.66 7.16,61.35 7.16,62.75 8.09,62.75
GND on IN2 (solid shape): outline of 282 points within 0.2,0.2 215.51,81.6
GND on IN2 (solid shape): outline of 3651 points within 149.81,42.54 178.26,57.2
GND on IN3 (solid shape): 138.82,6.61 138.78,6.58 130.7,6.58 130.67,6.61 130.67,7.61 138.82,7.61
GND on IN3 (solid shape): 8.21,21.08 8.21,17.78 7.94,17.52 7.42,17.52 7.17,17.77 7.17,21.02 7.34,21.19 8.1,21.19
GND on IN3 (solid shape): 11.33,29.79 11.33,28.19 11.04,27.9 8.41,27.9 8.01,28.3 8.01,30.11 8.16,30.26 10.86,30.26
GND on IN3 (solid shape): 11.59,25.16 11.59,24.61 11.31,24.33 9.03,24.33 8.86,24.5 8.86,25.18 9.05,25.37 11.38,25.37
GND on IN3 (solid shape): 15.46,28.67 15.46,26.38 15.33,26.25 12.66,26.25 12.28,26.63 12.28,28.54 12.53,28.79 15.33,28.79
GND on IN3 (solid shape): 116.97,11.94 116.97,10.45 116.94,10.42 111.29,10.42 111.17,10.54 111.17,11.9 111.22,11.95 116.96,11.95
GND on IN3 (solid shape): 147.92,19.52 147.92,19.16 147.19,18.44 145.65,18.44 145.65,18.54 145.83,18.72 145.83,19.54 145.93,19.64 147.8,19.64
GND on IN3 (solid shape): 18.58,17.77 18.58,14.8 18.35,14.57 15.89,14.57 15.71,14.75 15.71,17.61 16.13,18.03 18.31,18.03
GND on IN3 (solid shape): 204.69,43.7 204.69,39.55 204.52,39.39 201.42,39.39 200.23,40.57 200.23,41.07 199.69,41.62 199.69,41.91 199.03,42.57 199.03,43.56 199.33,43.86 204.52,43.86
GND on IN3 (solid shape): 14.23,15.48 14.23,12.96 12.83,11.56 8.77,11.56 8.52,11.81 8.52,13.54 8.7,13.72 9.25,13.72 10.92,15.4 12.89,15.4 13.17,15.68 14.04,15.68
GND on IN3 (solid shape): 115.17,67.99 115.44,67.99 116.29,67.14 116.29,62.62 116.11,62.44 115.6,62.44 115.26,62.78 115.26,64.87 115.31,64.92 115.31,65.64 115.26,65.69 115.26,66.04 110.1,71.2 110.1,71.59 110.4,71.88 111.28,71.88
GND on IN3 (solid shape): 189.32,14.44 189.32,10.89 188.81,10.38 184.37,10.38 184.24,10.5 184.24,11.72 184.52,12.01 185.83,12.01 185.97,12.16 185.97,13.26 186.27,13.55 186.27,13.57 186.61,13.91 187.82,13.91 188.61,14.7 189.06,14.7
GND on IN3 (solid shape): 197.8,25.12 197.8,22.55 197.67,22.41 195.05,22.41 195.04,22.45 194.95,22.59 194.79,22.67 194.77,22.67 194.73,22.71 194.73,25.13 194.95,25.34 197.57,25.34
GND on IN3 (solid shape): 191.77,72.31 191.82,72.09 191.99,71.93 191.99,68.67 191.86,68.54 190.59,68.54 190.46,68.67 190.46,69.47 191.24,70.25 191.24,72.35 191.37,72.48 191.6,72.48
GND on IN3 (solid shape): 181.11,14.95 181.11,14.62 181.04,14.54 181.04,14.23 181.44,13.82 181.44,13.4 181.37,13.33 181.37,10.63 181.08,10.34 178.97,10.34 178.1,11.21 178.1,12.8 178.08,12.92 178.02,13.03 178.02,14.82 178.27,15.08 180.99,15.08
GND on IN3 (solid shape): 173.57,15.33 173.57,10.94 173.38,10.75 170.91,10.75 170.65,11.01 170.65,12.69 169.68,13.66 169.68,13.69 169.6,13.95 169.34,14.04 169.31,14.03 169.08,14.26 169.08,15.23 169.56,15.71 173.19,15.71
GND on IN3 (solid shape): 139.48,29.22 139.48,28.61 138.74,27.86 138.1,27.86 138.01,27.95 138.01,28.28 138.23,28.5 138.37,28.58 138.46,28.73 138.7,28.97 138.92,29.05 139.04,29.25 139.46,29.25
GND on IN3 (solid shape): 131.68,79.74 131.68,76.92 129.93,75.17 129.93,73.71 129.92,73.65 129.93,73.58 129.93,72.02 130.24,71.71 131.11,71.71 131.2,71.62 131.2,65.62 131.09,65.52 124.94,65.52 124.34,66.12 124.34,68.59 124.39,68.63 124.39,68.87 124.34,68.91 124.34,71.59 124.39,71.63 124.39,71.87 124.34,71.91 124.34,76.16 123.58,76.92 123.58,79.32 124.26,79.99 131.43,79.99
GND on IN3 (solid shape): 130.39,19.6 130.39,19.51 130.25,19.08 130.69,18.97 130.79,18.97 130.87,18.89 130.87,18.68 130.77,18.58 128.72,18.58 128.46,18.84 128.46,19.31 128.76,19.61 128.77,19.61 128.88,19.73 130.26,19.73
GND on IN3 (solid shape): 56.98,65.01 56.98,62.2 56.85,62.06 51.71,62.06 51.4,62.38 51.4,63.59 51.57,63.76 51.64,63.82 51.7,63.9 52.39,64.58 52.79,64.64 52.84,65.04 53.24,65.43 56.56,65.43
GND on IN3 (solid shape): 179.51,30.79 179.6,30.77 179.7,30.79 179.71,30.79 180.38,30.79 180.39,30.79 180.52,30.75 180.65,30.79 180.66,30.79 182.09,30.79 182.1,30.79 182.21,30.76 182.32,30.79 182.34,30.79 182.89,30.79 182.9,30.79 183,30.77 183.1,30.79 183.11,30.79 183.75,30.79 186.7,27.84 186.7,27.18 186.03,26.5 174.6,26.5 173.44,27.66 170.31,27.66 169.77,28.2 169.77,30.17 170.39,30.79 179.49,30.79
GND on IN3 (solid shape): 204.61,9.46 204.61,5.98 203.72,5.09 191.66,5.09 191.38,5.37 191.38,5.86 191.88,6.36 194.5,6.36 195.47,7.33 197.5,7.33 197.5,7.28 197.51,7.23 197.52,7.18 197.55,7.13 197.58,7.09 197.61,7.05 197.65,7.02 197.7,7 197.75,6.98 197.8,6.97 197.85,6.97 197.91,6.98 197.95,7 198,7.02 198.04,7.05 198.08,7.09 198.11,7.13 198.13,7.18 198.15,7.23 198.16,7.28 198.16,7.33 198.15,7.38 198.13,7.43 198.11,7.48 198.08,7.52 198.04,7.56 198,7.59 197.95,7.61 197.91,7.63 197.85,7.63 197.8,7.63 197.75,7.63 197.7,7.61 197.65,7.59 197.61,7.56 197.58,7.52 197.55,7.48 197.52,7.43 197.51,7.38 197.5,7.33 195.47,7.33 197.85,9.72 201.59,9.72 201.61,9.74 204.33,9.74
GND on IN3 (solid shape): 19.02,66.22 20.24,66.22 20.37,66.09 20.37,64.95 20.32,64.9 19.08,64.9 18.54,64.36 18.01,64.36 18.01,64.56 18.01,64.59 18.03,64.61 18.03,65.02 17.63,65.04 17.23,65.02 17.22,64.62 17.22,64.36 15.79,64.36 15.6,64.55 15.6,66.48 15.77,66.65 18.59,66.65
GND on IN3 (solid shape): 131.85,16.47 131.84,16.44 131.82,16.39 131.81,16.34 131.81,16.29 131.82,16.24 131.84,16.19 131.86,16.15 131.89,16.11 131.93,16.07 131.97,16.04 132.01,16.02 132.06,16 132.11,15.99 132.17,15.99 132.22,16 132.27,16.01 132.29,16.02 132.32,15.99 132.32,15.25 132.27,15.2 130.26,15.2 129.71,15.76 131.38,15.76 131.38,15.74 131.39,15.69 131.4,15.64 131.43,15.6 131.46,15.56 131.49,15.53 131.53,15.5 131.58,15.48 131.63,15.46 131.67,15.46 131.72,15.46 131.77,15.47 131.82,15.49 131.86,15.51 131.9,15.54 131.93,15.58 131.96,15.62 131.98,15.67 131.99,15.71 131.99,15.76 131.99,15.81 131.98,15.86 131.96,15.9 131.93,15.95 131.9,15.98 131.86,16.01 131.82,16.04 131.77,16.06 131.72,16.07 131.67,16.07 131.63,16.06 131.58,16.05 131.53,16.03 131.49,16 131.46,15.97 131.43,15.93 131.4,15.88 131.39,15.84 131.38,15.79 131.38,15.76 129.71,15.76 129.25,16.22 129.25,16.47 129.38,16.61 131.7,16.61
GND on IN3 (solid shape): 13.93,69.95 13.93,69.27 13.46,69.27 13.19,69.11 13.23,68.79 13.25,68.38 13.66,68.39 13.72,68.44 13.8,68.47 13.89,68.46 13.93,68.38 13.93,62.17 13.52,61.76 12.73,61.76 12.59,61.9 12.59,62.09 12.59,62.1 12.62,62.21 12.59,62.31 12.59,62.32 12.59,62.5 12.68,62.7 12.61,62.91 12.68,63.11 12.59,63.31 12.59,63.46 12.6,63.47 12.63,63.59 12.6,63.71 12.59,63.72 12.59,66.5 12.59,66.52 12.63,66.65 12.59,66.78 12.59,66.8 12.59,66.89 12.63,67.03 12.59,67.18 12.59,70.09 12.64,70.14 13.73,70.14
GND on IN3 (solid shape): 8.43,62.42 8.43,61.73 8.47,61.68 9.55,61.68 9.82,61.41 9.82,60.7 9.33,60.21 7.95,60.21 7.41,59.67 4.66,59.67 4.3,59.31 4.3,53.98 4.74,53.54 6.21,53.54 7.21,52.54 13.77,52.54 14.35,51.96 14.35,50.06 13.51,49.22 10.6,49.22 10.51,49.31 10.51,50.08 11.01,50.85 10.31,51.45 1.7,51.45 1.7,52.15 1.56,52.51 1.2,52.65 0.6,52.65 0.53,52.68 0.5,52.75 0.5,53.85 0.53,53.92 0.6,53.95 1.45,53.95 1.81,54.09 1.95,54.45 1.95,58.65 1.75,59.15 1.25,59.35 0.4,59.35 0.33,59.38 0.3,59.45 0.3,59.75 0.33,59.82 0.4,59.85 0.52,59.85 0.86,59.98 1.02,60.3 1.15,60.76 1.44,61.15 5.79,61.15 6.56,60.66 7.16,61.35 7.16,62.76 8.08,62.76
GND on IN3 (solid shape): outline of 285 points within 0.2,0.2 215.51,81.6
GND on TOP: 15.43,34.87 20.28,34.87 20.29,34.87 20.46,34.87 20.74,34.58 20.74,28.77 20.31,28.34 19.55,28.34 19.32,28.56 19.32,30.52 18.85,30.99 15.7,30.99 15.26,31.43 15.26,34.71
GND on TOP: 75.19,22.78 75.19,23.76 75.41,23.97 80.36,23.97 80.73,24.34 80.73,27.39 82.75,29.41 85.64,29.41 87.61,27.44 87.61,23.12 87.58,23.09 87.58,21.84 87.59,21.83 87.59,21.7 87.59,21.69 87.59,21.13 83.46,21.13 83.12,20.79 83.12,13.92 82.86,13.66 80.58,13.66 80.41,13.83 80.41,18.9 77.79,21.53 76.44,21.53
GND on BOTTOM: 78.58,16.89 77.99,17.48 77.99,20.47 77.99,20.47 72.64,25.82 71.77,25.82 59.09,38.5 59.09,38.72 59.42,39.05 61.21,39.05 71.06,29.2 73.77,29.2 73.93,29.37 85.96,29.37 87.2,28.12 87.2,26.74 87.35,25.78 87.2,24.82 87.2,18.4 85.7,16.89
GND on BOTTOM: 146.84,15.94 154.19,15.94 154.77,15.36 154.77,14.23 154.67,14.13 145.88,14.13 145.68,14.33 145.68,15.07 145.85,15.24 146.15,15.24
GND on GND1: outline of 129 points within 0.2,0.2 215.51,81.6
GND on GND2: outline of 127 points within 0.2,0.2 215.51,81.6
GND on VCC: 7.16,70.28 7.16,70.65 6.56,71.34 5.79,70.85 3.46,70.85 0.8,70.85 0.8,77.79 20.68,77.79 21.55,78.66 23.08,77.13 23.08,76.38 23.06,76.31 22.99,76.28 22.7,75.97 22.99,75.67 23.06,75.63 23.08,75.56 23.08,74.16 23.04,74.08 22.95,74.07 22.54,73.78 22.95,73.49 23.04,73.48 23.08,73.4 23.08,71.24 22.66,70.82 10.03,70.82 9.96,70.85 9.72,71.44 9.21,71.65 7.97,71.65 7.8,71.66 7.64,71.62 7.64,70.28
GND on VCC: outline of 105 points within 0.2,0.2 23.4,61.64
GND on VCC: outline of 236 points within 122.62,19.94 202.26,81.6
GND on IN2: 19.01,34.53 19.01,29.5 19.42,29.1 22.21,29.1 22.21,34.51 22.11,34.61 19.09,34.61
GND on IN2: 74.33,60.8 70.83,60.8 69.34,59.31 68.36,59.31 67.35,58.3 65.88,58.3 63.05,55.47 63.05,50.76 63.61,50.19 66.67,50.19 67.69,51.22 73.82,51.22 74.56,51.96 74.56,60.56
GND on GND3: outline of 126 points within 0.2,0.2 215.51,81.6
GND on IN3: 52.88,74.47 54.77,74.47 54.95,74.29 54.95,70.32 54.39,69.76 54.34,69.76 53.76,69.18 51.65,69.18 51.4,69.43 51.4,71.46 51.78,71.85 51.78,73.37
GND on IN3: 20.81,30.06 20.81,31.13 19.6,31.13 19.6,34.58 19.82,34.81 21.96,34.81 22.09,34.69 22.09,30.29 21.86,30.06
GND on GND4: outline of 132 points within 0.2,0.2 215.51,81.6
VCC33_GPU on TOP (solid shape): 41.11,67.43 41.11,66.29 40.64,65.82 40.64,64.78 40.59,64.73 40.45,64.73 40.37,64.8 40.37,65.99 39.88,66.48 39.2,66.48 39.08,66.61 39.08,67.34 39.2,67.46 41.09,67.46
VCC_GT on BOTTOM (solid shape): 200.9,37.04 200.9,36.27 200.87,36.24 200.87,35.63 200.92,35.59 201.38,35.59 201.5,35.47 201.5,34.85 201.39,34.74 200.88,34.74 200.61,35.01 200.18,35.01 200.1,35.1 200.1,35.61 200.62,36.14 200.62,37.02 200.69,37.09 200.85,37.09
VCC_IA1 on BOTTOM (solid shape): 167.13,14.1 167.13,13.77 167.28,13.62 168.22,13.62 168.31,13.53 168.31,13.43 168.23,13.34 167.04,13.34 166.74,13.04 166.13,13.04 166.08,13.09 166.08,13.49 166.4,13.81 166.4,14.19 166.44,14.24 166.99,14.24
VCC_IA2 on BOTTOM (solid shape): 174.78,14.15 174.78,13.85 175.05,13.59 176.01,13.59 176.04,13.55 176.04,13.42 175.99,13.37 174.8,13.37 174.79,13.39 174.53,13.39 174.41,13.26 174.41,13.08 174.37,13.04 173.78,13.04 173.73,13.09 173.73,13.61 173.83,13.71 174.19,13.71 174.27,13.78 174.27,14.21 174.31,14.26 174.67,14.26
VCC_IA3 on BOTTOM (solid shape): 182.47,14.27 182.47,13.9 182.77,13.6 183.74,13.6 183.78,13.56 183.78,13.42 183.73,13.37 182.56,13.37 182.35,13.15 181.52,13.15 181.46,13.21 181.46,13.7 181.53,13.77 181.87,13.77 181.96,13.87 181.96,14.32 182.01,14.37 182.37,14.37
VCCDPHY_1P24 on IN1 (solid shape): 136.03,51.11 136.31,50.94 136.58,51.11 136.6,51.14 139.02,51.14 139.27,51.01 139.52,51.14 139.83,51.14 139.98,51 139.97,50.98 140.04,50.74 140.26,50.63 140.32,50.6 140.35,50.54 140.47,50.35 140.68,50.34 140.69,50.35 140.82,50.35 140.83,50.3 140.98,50.07 141.25,50.06 141.28,50.07 141.39,49.96 141.39,49.94 141.39,49.86 141.41,49.78 141.42,49.77 141.42,49.7 141.31,49.59 140.07,49.59 140.05,49.61 139.79,49.87 139.32,49.87 139.31,49.9 139.03,50.07 138.76,49.9 138.74,49.87 138.64,49.87 138.32,50.18 138.32,50.2 138.24,50.37 138.08,50.44 138.06,50.44 138.04,50.46 137.75,50.46 137.74,50.49 137.58,50.63 137.38,50.58 137.36,50.57 137.31,50.57 137.29,50.59 137,50.71 136.75,50.5 136.74,50.46 136.34,50.46 136.33,50.46 136.22,50.48 136.11,50.46 136.1,50.46 135.17,50.46 135.1,50.54 135.1,51.01 135.15,51.07 135.18,51.06 135.36,51.05 135.51,51.14 136.02,51.14
VCCGT_B+ on TOP (solid shape): 205.76,38.02 205.76,37.06 205.5,36.79 204.09,36.79 203.92,36.96 203.92,37.99 204.03,38.1 205.67,38.1
VCCGT_B+ on BOTTOM (solid shape): 205.57,37.82 205.57,36.78 204.91,36.13 204.91,34.99 205.29,34.62 206.2,34.62 207.05,33.77 207.09,33.64 207.09,32.42 206.88,32.21 203.33,32.21 202.81,31.69 202.81,31 202.75,30.94 201.27,30.94 201.18,31.03 201.18,34.08 201.43,34.33 202.73,34.33 203.5,35.1 203.5,37.23 203.41,37.32 199.63,37.32 199.28,36.97 199.28,36.31 199.15,36.18 198.44,36.18 198.38,36.24 198.38,36.93 199.15,37.7 201.6,37.7 201.95,38.05 205.34,38.05
VCCSA_B+ on TOP (solid shape): 144.93,18 144.93,17.49 144.81,17.36 144.49,17.36 144.3,17.17 144.3,16.41 144.04,16.16 142.17,16.16 141.95,16.38 141.95,17.74 142.27,18.06 144.87,18.06
VCCSA_B+ on BOTTOM (solid shape): 142.9,22.09 142.9,21.9 142.91,21.89 142.91,21.33 142.91,21.33 142.91,19.71 143.27,19.35 143.27,17.65 143.89,17.02 143.89,16.48 143.62,16.2 140.7,16.2 140.06,16.83 139.61,16.83 139.6,16.84 138.84,16.84 138.73,16.96 138.73,17.11 141.24,17.11 141.24,17.06 141.24,17.01 141.26,16.96 141.28,16.91 141.31,16.87 141.35,16.83 141.39,16.8 141.44,16.78 141.49,16.76 141.54,16.75 141.59,16.75 141.64,16.76 141.69,16.78 141.74,16.8 141.78,16.83 141.82,16.87 141.85,16.91 141.87,16.96 141.89,17.01 141.9,17.06 141.9,17.11 141.89,17.16 141.87,17.21 141.85,17.26 141.82,17.3 141.78,17.34 141.74,17.37 141.69,17.39 141.64,17.41 141.59,17.41 141.54,17.41 141.49,17.41 141.44,17.39 141.39,17.37 141.35,17.34 141.31,17.3 141.28,17.26 141.26,17.21 141.24,17.16 141.24,17.11 138.73,17.11 138.73,18.11 138.94,18.33 139.64,18.33 140.03,17.94 140.64,17.94 141.08,17.5 142.43,17.5 142.56,17.62 142.56,21.47 142.31,21.73 141.21,21.73 141.15,21.79 141.15,22.52 141.18,22.55 142.44,22.55
VCCSTG_IO_EN_UZ7 on TOP (solid shape): 152.78,61.36 152.78,60.27 152.69,60.18 151.33,60.18 151.31,60.2 151.31,61.41 151.41,61.51 152.63,61.51
VDDP_CHG on BOTTOM (solid shape): 198.85,22.45 198.85,22.07 199.74,21.18 200.36,21.18 200.46,21.08 200.46,19.7 200.41,19.64 199.89,19.64 199.77,19.76 199.77,20.61 198.05,22.33 198.05,22.33 197.96,22.41 197.96,22.52 198.04,22.6 198.7,22.6
+CHARGER_SRC on TOP (solid shape): 190.69,14.16 190.69,7.46 190.63,7.4 188.8,7.4 187.45,8.75 187.45,9.65 187.46,9.66 187.98,9.66 188,9.68 188,10.39 187.98,10.4 187.46,10.4 187.45,10.42 187.45,10.85 187.46,10.86 187.97,10.86 187.99,10.86 188,10.86 188,11.6 187.99,11.61 187.45,11.61 187.45,13.09 188.67,14.32 190.53,14.32
+CHARGER_SRC on BOTTOM (solid shape): 193.46,14.93 193.46,12.77 193.6,12.63 194.31,12.63 194.59,12.35 194.59,10.65 194.16,10.22 190.16,10.22 190.11,10.28 190.11,10.81 190.32,11.02 190.67,11.02 190.92,11.27 190.92,12.13 191.3,12.52 191.3,14.97 191.52,15.18 193.2,15.18
+CHARGER_SRC on IN1 (solid shape): 192.24,13.93 192.24,10.76 192.11,10.63 190.57,10.63 189.57,11.63 189.57,14.44 189.83,14.7 191.48,14.7
+CHARGER_SRC on IN2 (solid shape): 192.35,14.6 192.35,10.69 192.03,10.36 190.31,10.36 189.97,10.7 189.97,14.56 190.31,14.9 192.05,14.9
+CHARGER_SRC on IN3 (solid shape): outline of 85 points within 189.54,10.47 193.49,14.71
+DCBAT_LCD on TOP (solid shape): 37.52,74.57 38.5,74.57 38.85,74.22 38.85,74.01 38.96,73.91 39.39,73.91 40.07,73.24 42.17,73.24 43.01,72.4 43.01,71.99 42.95,71.93 41.18,71.93 40.99,71.74 40.99,70.17 40.63,69.82 40.63,69.4 40.27,69.04 40.05,69.04 40.05,69.05 39.64,69.05 39.57,69.12 39.57,69.35 40,69.78 40,71.83 39.36,72.47 39.36,73.1 39.12,73.34 37.19,73.34 36.53,74 36.53,74.69 36.6,74.77 37.33,74.77
+DCBAT_LCD on BOTTOM (solid shape): 41.81,72.81 42.1,72.81 42.18,72.72 42.18,72.07 42.11,72 41.86,72 41.83,71.97 40.27,71.97 40.18,72.06 40.18,72.11 40.18,72.54 40.18,72.59 40.18,72.77 40.21,72.81 41.81,72.81
+DCBAT_LCD_DV13 on TOP (solid shape): 37.64,77.9 37.64,76.53 37.49,76.38 37.49,75.49 37.44,75.44 36.54,75.44 36.5,75.48 36.5,76.11 36.55,76.16 36.99,76.16 37.1,76.27 37.1,76.46 37.11,76.48 37.11,77.87 37.2,77.96 37.58,77.96
+DCIN_JACK on TOP (solid shape): 86.12,20.87 86.12,13.61 85.29,12.77 84.49,12.77 83.31,11.59 82.14,11.59 82.13,11.58 79.87,11.58 78.49,12.96 78.49,15.12 77.7,15.12 77.65,15.17 77.65,15.88 77.65,15.9 77.63,15.92 77.11,15.92 77.1,15.93 77.1,16.38 77.12,16.39 77.63,16.39 77.66,16.42 77.66,17.11 77.64,17.13 77.11,17.13 77.1,17.14 77.1,17.58 77.11,17.59 77.64,17.59 77.65,17.61 77.65,18.77 79.28,18.77 80.19,17.86 80.19,13.75 80.52,13.41 82.86,13.41 83.41,13.96 83.41,20.75 83.64,20.98 86.02,20.98
+DTH_VDD12 on BOTTOM (solid shape): 19.94,43.31 19.94,42.33 19.98,42.29 19.98,41.04 20.11,40.91 20.11,39.18 20.02,39.09 18.96,39.09 18.87,39.18 18.87,39.65 19.2,39.98 19.2,40.04 19.25,40.09 19.25,43.25 19.34,43.35 19.9,43.35
+DTH_VDD12 on IN3 (solid shape): 19.93,42.21 19.93,40.2 19.88,40.14 19.18,40.14 19.14,40.18 19.14,42.19 19.21,42.26 19.89,42.26
+DTH_VDD12 on IN2: 21.79,40.28 21.79,38.79 21.42,38.42 20.79,38.42 20.78,38.46 20.49,38.7 20.19,38.46 20.18,38.42 19.41,38.42 19.25,38.58 19.25,39.38 19.31,39.44 20.39,39.44 20.46,39.51 20.56,39.52 20.62,39.43 20.72,39.2 20.96,39.11 21.29,39.43 20.97,39.77 20.85,39.75 20.74,39.7 20.64,39.68 20.58,39.76 20.58,40.05 20.2,40.43 20.18,40.43 20.14,40.47 19.32,40.47 19.16,40.63 19.16,41.93 19.27,42.04 19.66,42.04 19.78,41.92 20.14,41.92 20.15,41.92 20.25,41.9 20.36,41.92 20.37,41.92 20.63,41.92 20.64,41.89 20.76,41.73 20.95,41.67 21.2,41.78 21.29,42.05 21.28,42.08 21.64,42.43 21.64,43.45 21.7,43.55 21.81,43.53 22.34,43.73 21.81,43.94 21.7,43.92 21.64,44.01 21.64,44.37 21.09,44.92 21.09,45.13 21.22,45.27 21.87,45.27 21.87,45.22 22.17,44.93 22.48,45.22 22.48,45.27 22.95,45.27 23.15,45.06 23.15,41.64
+DTH_VDD33 on IN3 (solid shape): outline of 165 points within 21.97,38.49 25.16,45.4
+DTH_VDD33 on BOTTOM: 23.85,42.07 23.84,42.1 23.72,42.27 23.52,42.34 23.32,42.27 23.2,42.1 23.19,42.07 22.55,42.07 22.31,42.31 22.31,43.34 22.34,43.37 23.09,43.37 23.18,43.45 23.18,43.49 23.18,43.49 23.18,44.11 23.13,44.16 22.67,44.16 22.47,44.36 22.47,45.37 22.61,45.51 24.85,45.51 25.08,45.29 25.08,42.92 24.49,42.33 24.23,42.07
+DTH_VDDA12 on BOTTOM (solid shape): 17.07,43.95 17.67,43.95 17.67,43.94 18.13,43.94 18.2,43.86 18.2,43.51 18.02,43.32 17.53,43.32 17,42.79 17,41.39 16.67,41.06 16.67,39.98 16.73,39.92 17.07,39.92 17.17,39.82 17.17,39.31 16.96,39.1 16.05,39.1 15.9,39.25 15.9,43.63 15.92,43.65 15.92,43.91 15.98,43.97 17.07,43.97
+DTH_VDDA12 on IN1 (solid shape): 20.38,44.73 20.38,44.31 20.21,44.15 20.21,44.04 19.78,43.6 19.73,43.57 19.7,43.52 19.63,43.46 19.63,43.28 19.56,43.2 19.01,43.2 18.92,43.29 18.92,44.21 19.57,44.86 20.25,44.86
+DTH_VDDA12 on IN3 (solid shape): 18.75,43.77 19.45,43.77 19.54,43.67 19.54,42.93 19.32,42.71 16.67,42.71 16.57,42.81 16.57,43.6 16.58,43.6 16.58,43.68 16.67,43.77 18.74,43.77
+DTH_VDDRX12 on IN1 (solid shape): 27.11,44.91 27.42,44.91 27.5,44.82 27.5,44.52 26.61,43.63 25.38,43.63 25.25,43.76 25.25,44.76 25.41,44.91 27.11,44.91
+DTH_VDDRX12 on IN3 (solid shape): 23.31,40.3 23.31,39.79 23.15,39.64 21.83,39.64 21.7,39.77 21.7,40.35 21.84,40.49 23.12,40.49
+DTH_VDDRX12 on BOTTOM: 25.06,40 25.16,40 25.25,39.9 25.25,38.66 25.24,38.64 24.98,38.64 24.98,38.8 24.94,38.84 23.74,38.84 23.59,38.68 23.59,37.8 23.41,37.62 22.73,37.62 22.65,37.7 22.65,38.51 22.27,38.9 21.4,38.9 21.32,38.98 21.32,39.78 21.55,40.01 21.55,40.39 21.63,40.48 23.18,40.48 23.28,40.37 24.07,40.37 24.41,40.03 24.49,40.03 24.69,39.82 24.88,39.82
+DTH_VDDRX12 on IN1: 26.34,39.66 26.22,39.74 26.09,39.77 25.95,39.74 25.84,39.66 25.43,39.66 25.23,39.85 25.23,40.56 25.39,40.72 25.77,40.72 25.86,40.68 25.86,40.58 25.83,40.47 25.83,40.35 26,40.15 26.26,40.15 26.41,40.3 26.43,40.5 26.65,40.72 27.15,40.72 27.31,40.57 27.31,39.7 27.26,39.66
+DTH_VDDRX12 on IN2: 23.95,39.29 23.88,39.32 23.85,39.38 23.78,39.65 23.52,39.77 23.27,39.66 23.16,39.33 23.09,39.3 22.16,39.3 22.08,39.37 22.08,40.09 23.61,41.62 24.75,41.62 25.32,42.19 25.32,44.9 26.13,45.7 26.95,45.7 27.07,45.59 27.07,40.22 27.08,40.21 27.08,39.52 26.97,39.41 26.9,39.38 26.83,39.4 26.8,39.42 26.77,39.44 26.65,39.47 26.53,39.46 26.46,39.46 26.41,39.5 26.3,39.69 26.1,39.77 25.84,39.67 25.75,39.41 25.73,39.33 25.65,39.29
+DTH_VDDTX12 on BOTTOM (solid shape): 19.08,43.26 19.08,40.04 18.74,39.7 18.74,39.2 18.59,39.06 17.6,39.06 17.42,39.23 17.42,39.74 17.66,39.98 17.68,39.98 17.68,39.99 17.93,40.25 17.93,41.12 17.94,41.12 17.94,42.31 17.98,42.31 17.98,43.14 18.03,43.19 18.07,43.19 18.26,43.38 18.95,43.38
+DTH_VDDTX12 on IN1 (solid shape): 21.05,45.85 21.05,45.24 20.86,45.04 19.79,45.04 19.66,45.17 19.66,45.89 19.72,45.95 20.95,45.95
+DTH_VDDTX12 on IN2 (solid shape): 20.25,45.88 20.25,45.1 19.03,43.88 19.03,43.76 18.88,43.49 19.03,43.23 19.03,40.55 19.28,40.3 20.14,40.3 20.45,39.99 20.45,39.68 20.34,39.57 17.92,39.57 17.56,39.93 17.56,46 17.8,46.24 19.89,46.24
+DTH_VDDTX12 on IN3 (solid shape): 19.01,42.15 19.01,40.19 18.87,40.05 18.08,40.05 17.98,40.15 17.98,42.21 18.03,42.27 18.9,42.27
+EC_DEBUG_VCC on TOP (solid shape): 32.22,7.56 32.22,6.24 32.51,5.96 32.51,5.18 32.35,5.02 31.33,5.02 31.23,5.12 31.23,6.95 31.24,6.96 31.24,7.49 31.35,7.6 32.18,7.6
+FB_PLLAVDD on TOP (solid shape): outline of 297 points within 95.8,52.3 104.6,64.27
+FBA_VREFC0 on TOP (solid shape): 92.74,65.88 92.74,65.33 93.1,64.97 93.54,64.97 93.69,65.11 95.1,65.11 95.26,65.27 95.64,65.27 95.69,65.22 95.69,64.62 95.61,64.54 94.52,64.54 94.49,64.51 94.46,64.51 94.46,64.48 94.45,64.47 93.74,64.47 93.65,64.38 92.53,64.38 92.24,64.67 92.24,65.89 92.42,66.07 92.54,66.07
+GPU_CORE on TOP (solid shape): 68.07,76.82 68.07,62.86 67.82,62.61 63.04,62.61 62.95,62.7 62.95,63.34 63.46,63.84 63.46,66.27 62.26,67.47 62.26,76.67 62.92,77.33 67.56,77.33
+GPU_CORE on TOP (solid shape): outline of 813 points within 101.21,54.06 117.38,72.32
+GPU_CORE on BOTTOM (solid shape): 67.91,76.46 67.91,62.32 67.65,62.07 63.84,62.07 63.23,62.68 63.23,74.46 62.26,75.43 62.26,76.26 62.51,76.51 67.85,76.51
+GPU_CORE on IN1 (solid shape): 68.1,76.26 68.1,64.99 66.26,63.15 60.67,63.15 60.22,63.59 60.22,75.96 60.76,76.5 67.87,76.5
+GPU_CORE on IN1 (solid shape): outline of 997 points within 96.89,52.41 114.89,72.38
+GPU_CORE on IN2 (solid shape): 68.43,76.17 68.43,74.88 68.39,74.87 68.12,74.57 68.39,74.27 68.43,74.26 68.43,63.99 67.55,63.11 62.89,63.11 62.28,63.72 62.28,76.42 62.51,76.64 67.97,76.64
+GPU_CORE on IN2 (solid shape): outline of 2669 points within 97.21,49.91 117.58,73.26
+GPU_CORE on IN3 (solid shape): 67.97,76.24 67.97,62.59 67.57,62.19 62.95,62.19 62.32,62.83 62.32,76.16 62.57,76.42 67.79,76.42
+GPU_CORE on IN3 (solid shape): 115.19,65.59 115.19,64.97 114.81,64.6 114.35,64.6 111.1,67.85 111.04,67.85 111.01,67.88 107.69,67.88 107.51,68.06 107.51,69.77 108.45,70.71 108.67,70.71 108.85,70.9 109.87,70.9
+GPU_CORE on IN3 (solid shape): outline of 1046 points within 97.03,51.98 110.12,62.57
+GPU_CORE on BOTTOM: outline of 153 points within 96.45,51.48 117.4,71.56
+GPU_CORE on VCC: 72.47,41.19 72.06,41.61 72.06,49.96 69.42,52.6 65.11,52.6 63.72,54 63.72,60.35 63.27,60.8 62.88,60.8 62.05,61.62 62.05,80.54 62.29,80.78 71.65,80.78 72.16,79.85 73.15,79.48 74.95,79.48 75.94,79.85 76.45,80.78 115.52,80.78 116.96,80.78 116.99,80.78 116.99,78.21 116.92,78.28 116.71,78.28 116.56,78.13 116.56,77.9 116.99,77.48 116.99,56.06 116.97,56.05 116.97,55.84 116.99,55.82 116.99,54.99 103.19,41.19
+GPU_PLLVDD on TOP (solid shape): outline of 104 points within 103.39,63.03 106.62,67.78
+IR_B+ on TOP (solid shape): 43.02,71.57 43.02,70.22 42.9,70.1 42.01,70.1 41.92,70.19 41.92,70.53 41.76,70.69 41.76,71.71 41.85,71.79 42.79,71.79
+IR_B+ on BOTTOM (solid shape): 40.35,73.65 40.35,73.08 40.21,72.93 40.16,72.93 40.05,72.82 40.05,71.95 39.82,71.95 39.77,72.01 39.78,72.07 39.78,72.11 39.78,72.54 39.78,72.58 39.76,72.63 39.76,73.73 39.87,73.84 40.17,73.84
+IR_B+ on IN1 (solid shape): 41.13,73.07 41.13,72.54 41.1,72.53 40.93,72.05 41.43,71.96 41.5,71.99 41.56,71.96 41.7,71.82 42.48,71.82 42.58,71.72 42.58,71.31 42.42,71.15 41.05,71.15 40.13,72.07 40.13,73.36 40.36,73.59 40.6,73.59
+IR_B+ on IN3 (solid shape): 41.17,73.81 41.17,73.01 41.01,72.85 39.62,72.85 39.49,72.98 39.49,73.89 39.53,73.94 41.05,73.94
+LCDVDD on TOP (solid shape): 37.84,69.55 37.84,68.59 37.71,68.45 37.06,68.45 37.06,68.45 36.65,68.45 36.58,68.52 36.58,69.45 36.78,69.65 37.74,69.65
+LCDVDD on IN1 (solid shape): 37.96,69.63 37.96,68.58 37.88,68.5 36.95,68.5 36.66,68.78 36.66,69.61 36.77,69.72 37.87,69.72
+LCDVDD on IN2: 37.22,60 38.65,60 39.19,60.54 39.19,69.1 38.75,69.55 37.43,69.55 37.02,69.14 37.02,60.2
+LCDVDD on IN3: 42.29,55.55 43.51,55.55 43.59,55.63 43.59,56.61 43.48,56.71 42.98,56.71 41.31,58.37 41.31,58.57 38.85,61.04 37.26,61.04 37.1,60.87 37.1,59.79 37.26,59.63 38.3,59.63 38.58,59.35 38.58,58.24 40.16,56.67 41.17,56.67
+LCDVDD_LCD on TOP (solid shape): 36.35,74.41 36.35,73.97 36.42,73.9 36.42,73.64 36.68,73.64 37.12,73.21 39.07,73.21 39.19,73.08 39.19,72.09 38.68,71.57 38.68,69.81 38.74,69.75 39.23,69.75 39.28,69.69 39.28,68.54 39.2,68.47 38.44,68.47 38.44,68.47 38.11,68.47 37.98,68.6 37.98,69.59 37.65,69.92 37.65,71.46 37.79,71.6 37.79,71.84 37.61,72.01 36.09,72.01 35.84,72.26 35.84,73.41 35.57,73.68 34.85,73.68 34.67,73.85 34.67,74.33 34.72,74.37 35.12,74.37 35.19,74.44 36.32,74.44
+LCDVDD_LCD on BOTTOM (solid shape): 39.28,73.22 39.28,72.03 39.19,71.95 38.69,71.95 38.64,72 38.64,72.62 38.52,72.75 38.44,72.75 38.43,72.75 38.35,72.77 38.27,72.75 38.27,72.75 38.14,72.75 38.04,72.84 38.04,73.18 38.16,73.3 39.2,73.3
+LCDVDD_LCD_DV14 on TOP (solid shape): 36.37,77.87 36.37,75.47 36.33,75.43 35.35,75.43 35.35,76.26 35.38,76.29 35.78,76.29 35.83,76.35 35.83,77.9 35.88,77.95 36.3,77.95
+MIC_VCC on TOP (solid shape): 31.74,73.23 31.74,72.91 31.9,72.76 32.21,72.76 32.3,72.67 32.3,72.24 32.27,72.2 31.79,72.2 31.72,72.13 31.72,71.88 31.53,71.69 29.1,71.69 28.97,71.82 28.97,73.13 29.11,73.26 31.71,73.26
+PEX_IOVDDQ on TOP (solid shape): 112.61,53.17 113.22,53.17 113.28,53.11 113.28,52.38 113.23,52.33 111.77,52.33 111.75,52.33 109.64,50.22 109.44,50.22 108.3,51.36 108.3,51.45 108.3,51.45 108.3,51.68 108.01,51.97 107.82,51.97 106.99,51.14 106.99,51.1 106.97,51.08 106.99,51.06 106.99,50.77 105.72,49.5 105.54,49.5 105.18,49.87 105.18,50.98 105,51.16 104.25,51.16 104.03,51.38 104.03,53.15 104.09,53.21 105.21,53.21 105.48,52.94 109.89,52.94 110.75,53.8 111.99,53.8
+PEX_IOVDDQ on BOTTOM (solid shape): outline of 934 points within 101.67,43.18 109.15,56.7
+PEX_PLL_HVDD on TOP (solid shape): 112.94,56.96 112.94,56.87 113.63,56.18 113.63,54.65 113.43,54.46 112.56,54.46 112.48,54.54 112.48,55.26 112.52,55.27 112.71,55.79 112.17,55.88 112.08,55.96 112.07,56.42 111.61,56.43 110.74,57.3 110.08,57.3 109.79,57.01 109.41,57.01 109.25,57.18 109.25,57.6 110.14,58.49 111.41,58.49
+PWR_SRC_AC on TOP (solid shape): 184.31,13.42 184.67,13.06 185.03,13.42 185.03,13.97 186.78,13.97 187.32,13.44 187.32,11.48 187.87,11.48 187.87,10.99 187.4,10.99 187.4,10.98 187.33,10.98 187.33,10.91 187.32,10.9 187.32,10.36 187.33,10.35 187.33,10.28 187.4,10.28 187.4,10.28 187.87,10.28 187.87,9.79 187.6,9.79 187.41,9.79 187.4,9.78 187.33,9.78 187.33,9.71 187.32,9.7 187.32,9.02 187.26,8.96 186,8.96 185.58,9.37 183.85,9.37 183.69,9.54 183.69,13.88 183.77,13.97 184.31,13.97
+RTC_CELL on TOP (solid shape): 59.16,20.08 59.61,20.08 59.8,19.89 59.8,19.09 59.68,18.96 58.05,18.96 57.84,19.18 57.84,19.89 58.03,20.08 59.16,20.08
+RTC_CELL on BOTTOM (solid shape): 26.52,8.06 26.52,6.61 26.02,6.1 26.02,5.64 26,5.62 25.56,5.62 25.49,5.54 25.43,5.54 25.15,5.26 25.15,4.5 25.36,4.28 25.87,4.28 25.93,4.22 25.93,3.9 25.87,3.84 24.31,3.84 24.03,4.13 24.03,5.1 25.2,6.27 25.2,8.07 25.39,8.26 26.32,8.26
+RTC_CELL on IN1 (solid shape): 57.61,19.94 57.89,19.94 58.12,19.71 58.52,19.71 58.55,19.68 63.11,19.68 63.25,19.54 63.25,19.2 63.15,19.09 57.04,19.09 56.55,19.59 56.55,20.18 56.65,20.27 57.28,20.27
+SDC_IN on TOP (solid shape): 77.53,21.01 77.53,17.73 77.52,17.72 77,17.72 76.97,17.69 76.97,17.01 77,16.98 77.52,16.98 77.52,16.98 77.52,16.53 77.51,16.52 76.98,16.52 76.97,16.51 76.97,15.81 76.99,15.79 77.51,15.79 77.52,15.78 77.52,15.3 77.38,15.16 76.56,15.16 75.64,16.08 75.64,21.07 75.88,21.31 77.22,21.31
+SDC_IN on TOP (solid shape): outline of 92 points within 179.11,14.92 193.56,21.6
+SDC_IN on BOTTOM (solid shape): 25.62,30.48 25.71,30.47 25.78,30.48 27.23,30.48 27.45,30.25 27.45,29.93 27.55,29.83 27.55,29.08 27.7,28.93 28.14,28.93 28.17,28.96 29.13,28.96 29.24,29.07 29.24,29.78 29.84,30.38 32.05,30.38 32.15,30.28 32.15,29.58 30.03,27.09 30.29,23.84 30.31,23.8 30.05,23.54 27.73,23.54 27.62,23.64 27.62,26.61 27.41,26.83 27.41,26.96 27.27,26.96 26.72,27.52 26.72,28.8 25.77,29.75 24.51,29.75 24.4,29.86 24.4,30.41 24.47,30.47 24.52,30.47 25.31,30.47 25.35,30.47 25.39,30.48 25.61,30.48
+SDC_IN on IN2 (solid shape): 30.23,29.96 30.23,27.92 29.82,27.52 29.81,27.52 29.05,26.76 28.03,26.76 26.86,27.93 26.63,27.93 26.47,28.09 26.21,28.09 26.08,28.22 26.1,28.25 26.12,28.33 26.11,28.43 26.13,28.49 26.18,28.54 26.4,28.87 26.13,29.17 26.07,29.21 26.05,29.28 26.05,29.34 26.03,29.41 26.03,29.91 26.37,30.25 29.94,30.25
+SDC_IN on IN3 (solid shape): 25.66,30.45 25.71,30.44 26.12,30.44 26.37,30.19 27.58,30.19 27.77,30 27.77,29.86 27.69,29.69 27.76,29.5 27.77,29.49 27.77,29.48 27.86,29.4 29.78,29.4 29.91,29.27 29.91,28.31 28.31,26.71 26.92,26.71 26.84,26.74 26.82,26.81 26.7,27.08 26.41,27.12 26.32,27.13 26.27,27.22 26.27,27.63 26.23,27.68 26.23,28.56 26.39,28.91 26.12,29.18 26.1,29.18 26.07,29.22 26.07,29.45 25.76,29.76 25.56,29.76 25.4,29.92 25.4,30.35 25.52,30.47 25.59,30.47
+SDC_IN on VCC: 21.09,13.9 19.65,15.34 19.65,21.98 18.14,23.5 18.14,26.25 18.42,26.53 19.64,26.53 19.96,26.85 19.96,28.71 20.65,29.4 32.45,29.4 32.57,29.27 32.57,28.91 32.57,28.91 32.57,28.89 28.5,24.82 28.5,20.38 29.3,19.58 32.71,19.58 32.74,19.62 73.94,19.62 75.11,20.79 77.58,20.79 78.76,19.62 147.88,19.62 148.59,18.91 154.1,18.91 154.81,19.62 164.36,19.62 165.16,20.41 182.32,20.41 182.53,20.63 187.64,20.63 188.35,21.34 188.35,21.85 188.73,22.23 189.56,22.23 192.36,19.43 196.47,19.43 196.75,19.15 196.76,19.13 196.76,17.19 195,15.42 192.4,15.42 190.45,17.37 187.7,17.37 184.25,13.91 143.02,13.91 142.17,14.76 137.07,14.76 136.22,13.91 100,13.91 98.6,15.31 88.13,15.31 86.72,13.9
+SIM_PWR on TOP (solid shape): 56.53,49.93 56.53,49.54 56.42,49.43 55.63,49.43 55.63,49.44 54.48,49.44 54.42,49.51 54.42,49.91 54.5,49.99 54.69,49.99 54.86,49.93 55.01,50.01 56.45,50.01
+SIM_PWR on IN3 (solid shape): 56.8,50.75 56.8,49.74 56.66,49.6 56.52,49.73 55.84,49.73 55.84,50.7 56.03,50.9 56.65,50.9
+TBT_SVR_IND on TOP (solid shape): 34.68,68.71 34.68,63.77 34.48,63.56 32.82,63.56 32.72,63.67 32.72,68.59 33.02,68.89 34.5,68.89
+TBT_SVR_IND on BOTTOM (solid shape): 33.05,57.75 33.05,57.24 32.85,57.05 32.66,57.05 32.6,56.98 32.32,56.98 32.26,56.92 32.08,56.75 31.9,56.57 31.04,56.57 31.02,56.59 30.86,56.59 30.82,56.63 30.82,56.77 30.82,57.21 30.82,57.31 30.83,57.32 30.86,57.32 30.9,57.34 30.94,57.35 30.99,57.34 31.03,57.32 31.72,57.32 31.96,57.56 32.22,57.56 32.54,57.88 32.92,57.88
+TBT_SVR_IND on IN1 (solid shape): 33.43,64.82 33.43,63.91 33.35,63.83 31.65,63.83 31.41,64.07 31.41,64.73 31.59,64.91 33.33,64.91
+TBT_SVR_IND on IN3 (solid shape): outline of 248 points within 30.49,56.42 33.74,64.83

# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3VS on IN2 (solid shape): 114.78,49.57 114.78,49.41 114.79,49.39 114.79,49.05 114.78,49.04 114.78,47.89 114.74,47.88 114.46,47.56 114.74,47.23 114.78,47.22 114.78,45.86 114.59,45.56 114.78,45.26 114.78,45.17 115.05,44.9 116.26,44.9 117.42,46.07 118.4,46.07 118.59,46.26 118.83,46.26 119.03,46.06 119.03,45.76 118.27,45.01 117.36,45.01 116.59,44.24 116.59,42.96 116.83,42.73 117.38,42.73 117.54,42.57 117.54,42.41 117.17,42.03 116.24,42.03 114.25,44.02 114.24,44.05 114.25,44.09 114.25,44.52 113.82,44.52 113.78,44.51 113.75,44.52 113.66,44.6 113.66,44.78 113.74,44.86 113.74,45.77 113.66,45.85 113.66,47.27 113.75,47.49 113.66,47.71 113.66,49.06 114.32,49.71 114.63,49.71
+3VS on BOTTOM: 61.75,15.38 61.33,15.8 61.33,16.46 60.21,17.58 55.17,17.58 54.36,18.38 54.36,19.54 55.2,20.38 63.78,20.38 65.59,18.57 66.97,18.57 67.37,18.97 68.2,18.97 68.55,18.62 68.55,13.72 67.86,13.03 63.04,13.03 61.69,14.39 61.69,14.53 61.75,14.59
+3VS on VCC: 63.53,41.19 57.41,47.32 32.42,47.32 32.16,47.57 32.16,47.58 32.13,47.61 32.13,48.62 30.79,49.96 24.94,49.96 23.59,51.31 23.59,70.36 23.67,70.44 23.67,70.65 23.59,70.73 23.59,77.34 22.49,78.45 24.82,80.78 42.27,80.78 42.38,80.66 42.38,57.74 44.41,55.71 61.28,55.71 61.54,55.45 61.54,55.44 61.69,55.3 61.7,55.3 64.9,52.1 69.21,52.1 71.55,49.75 71.55,41.66 71.2,41.31 71.19,41.31 71.07,41.19
+3VS_CAM on TOP (solid shape): 41.54,51.57 41.54,50.81 41.03,50.31 41.03,49.57 40.98,49.52 40.18,49.52 40.07,49.63 40.07,51.53 40.15,51.61 41.5,51.61
+3VS_CAM on TOP (solid shape): 31.71,73.89 32.39,73.89 32.42,73.86 32.42,72.99 32.35,72.91 31.98,72.91 31.89,73 31.89,73.31 31.74,73.46 30.23,73.46 30.17,73.51 30.17,73.84 30.23,73.89 31.71,73.89
+3VS_CAM on IN1: 41.5,52.66 41.69,52.66 41.87,52.49 41.9,52.42 41.88,52.35 41.81,52.13 41.91,51.93 41.88,51.82 41.91,51.71 41.72,51.53 41.72,50.96 41.69,50.93 41.02,50.93 41,50.95 41,51.44 41.36,51.81 41.36,52.16 41.31,52.21 41.31,52.47
+3VS_CR on TOP (solid shape): 6.58,31.07 8.42,31.07 8.45,31.04 8.45,30.37 8.45,30.37 8.45,29.78 8.42,29.74 8.38,29.73 8.37,29.74 6.03,29.74 5.92,29.84 5.92,31.28 5.96,31.31 6.34,31.31
+3VS_CR on IN1 (solid shape): 6.99,30.77 6.99,29.71 6.85,29.57 6.1,29.57 5.95,29.72 5.95,30.65 6.16,30.86 6.9,30.86
+3VS_CR on IN3 (solid shape): 6.69,30.83 7.25,30.83 7.3,30.77 7.3,28.87 7.07,28.63 6.18,28.63 6,28.81 6,30.7 6.13,30.83 6.69,30.83
+3VS_CR_R on TOP (solid shape): 10.49,31.11 10.49,29.77 10.4,29.68 8.78,29.68 8.78,30.39 8.67,30.39 8.67,31.1 8.81,31.25 10.35,31.25
+3VS_DTH on TOP (solid shape): 15.02,55.48 15.02,55.46 15.06,55.42 16.97,55.42 17.21,55.18 17.21,54.35 16.97,54.11 16.26,54.11 16.16,54.11 15.28,53.23 15.28,52.64 14.95,52.31 14.06,52.31 13.69,52.67 13.69,55.06 13.84,55.2 14.41,55.2 14.48,55.27 14.48,55.4 14.58,55.5 15.01,55.5
+3VS_DTH on IN3 (solid shape): 21.78,45.21 21.84,45.15 21.86,45.09 21.86,44.05 21.56,43.75 20.35,43.75 20.2,43.9 20.2,44.12 20.46,44.38 20.5,44.4 20.61,44.42 20.67,44.38 21.06,44.26 21.28,44.6 21.3,44.67 21.36,44.71 21.61,44.98 21.42,45.3 21.43,45.33 21.45,45.37 21.48,45.4 21.78,45.4
+3VS_DTH on BOTTOM: 21.48,44.02 21.48,43.7 21.47,43.69 21.25,43.69 20.96,43.98 19.86,43.98 19.76,44.08 19.76,45.36 19.89,45.49 21.94,45.49 22.03,45.4 22.03,44.35 21.89,44.21 21.56,44.21 21.48,44.12 21.48,44.03
+3VS_DTH on IN1: 24.76,40.91 24.76,39.03 23.78,38.05 23.75,38.02 23.72,38 23.57,37.85 23.56,37.84 23.48,37.79 23.43,37.71 23.43,37.7 23.13,37.41 23.13,36.75 23.5,36.38 23.56,36.38 23.58,36.36 23.79,36.36 23.81,36.38 23.94,36.38 24.02,36.3 24.02,36.04 23.99,36.01 22.74,36.01 21.53,37.21 21.53,40.07 21.5,40.1 21.5,41.72 21.28,41.94 21.29,41.96 21.2,42.23 20.95,42.33 20.89,42.33 20.34,42.88 20.34,43.11 20.36,43.13 20.54,43.4 20.37,43.68 20.34,43.69 20.34,44.09 20.46,44.21 21.46,44.21 21.77,43.89 21.76,43.86 21.79,43.55 22.08,43.43 22.11,43.43 22.3,43.25 22.42,43.25 23.28,42.38 23.31,42.31 23.28,42.24 23.21,41.87 23.52,41.67 23.66,41.7 23.77,41.79 23.84,41.8 23.9,41.77
+3VS_DTH on IN2: 21.32,44.46 21.39,44.43 21.51,44.32 21.51,43.79 21.47,43.75 19.94,43.75 19.82,43.86 19.82,44.49 20.38,45.04 20.38,45.93 19.94,46.37 19.94,46.37 19.82,46.48 19.82,50.24 17.53,52.53 13.8,52.53 13.41,52.92 13.41,53.52 13.51,53.62 18.1,53.62 21.6,50.13 21.6,49.75 21.57,49.74 21.39,49.47 21.51,49.18 21.51,45.46 21.44,45.4 21.15,45.4 20.96,45.21 20.96,44.9 20.91,44.9 20.62,44.54 20.96,44.24 21.14,44.29 21.26,44.43
+3VS_SSD on TOP (solid shape): 112.23,19.46 112.23,19.01 112.42,18.82 112.42,18.12 112.42,18.12 111.85,18.12 111.72,18.25 111.72,18.71 111.51,18.91 108.65,18.91 108.43,19.13 108.43,19.34 108.61,19.52 112.17,19.52
+3VS_SSD on TOP (solid shape): 105.58,35.75 106.04,35.75 106.18,35.61 109.26,35.61 109.34,35.53 109.34,33.82 108.1,32.58 104.36,32.58 104.11,32.83 104.11,33.43 104.65,33.43 104.65,34.37 104.2,34.37 104.11,34.46 104.11,34.74 104.11,34.74 104.11,35.69 104.17,35.75 105.58,35.75
+3VS_SSD on BOTTOM (solid shape): outline of 209 points within 107.83,16.42 115.68,35.88
+3VS_UN5 on TOP (solid shape): 54.17,46.75 54.17,46.04 54.5,45.71 54.5,45.3 54.62,45.18 54.62,44.47 54.56,44.41 54.56,43.74 54.5,43.68 54.5,43.19 54.44,43.14 54.11,43.14 53.87,43.38 53.87,45.7 53.63,45.94 53.63,46.75 53.68,46.8 54.11,46.8
+5V_KB_BL on BOTTOM (solid shape): 40.8,10.72 40.8,8.88 40.68,8.75 38.42,8.75 38.32,8.85 38.32,10.55 38.52,10.75 40.77,10.75
+5VALW on TOP (solid shape): 153.44,62.62 153.44,60.3 153.34,60.21 152.98,60.21 152.91,60.28 152.91,62.64 153.01,62.74 153.32,62.74
+5VALW on TOP (solid shape): 90.51,24.82 90.51,23.69 91.24,22.96 91.24,21.45 91.14,21.36 89.9,21.36 89.3,21.96 89.3,24.58 89.56,24.84 90.49,24.84
+5VALW on TOP (solid shape): 118.64,47.78 118.64,47.28 118.74,47.18 119.21,47.18 119.28,47.11 119.28,46.65 119.26,46.63 118,46.63 117.9,46.73 117.9,46.91 118.22,47.24 118.22,47.75 118.27,47.8 118.62,47.8
+5VALW on TOP (solid shape): 30.26,23.6 30.26,23.04 31.09,22.21 31.09,19.77 30.71,19.39 28.56,19.39 27.36,20.6 27.36,22.62 27.36,22.62 27.9,22.62 27.91,22.64 27.91,23.37 27.9,23.39 27.37,23.39 27.36,23.4 27.36,23.81 27.37,23.83 27.89,23.83 27.9,23.84 27.9,24.57 27.89,24.58 27.37,24.58 27.36,24.59 27.36,25.13 27.49,25.26 28.6,25.26
+5VALW on TOP (solid shape): outline of 389 points within 115.24,54.6 136.09,71.14
+5VALW on BOTTOM (solid shape): 98.63,37.74 98.63,36.27 98.26,35.9 96.47,35.9 96.27,36.1 96.27,37.83 96.35,37.91 98.46,37.91
+5VALW on BOTTOM (solid shape): 91.45,24.88 91.45,22.04 91.15,21.74 90.21,21.74 90.03,21.92 90.03,24.68 90.48,25.12 90.91,25.12 90.92,25.13 91.2,25.13
+5VALW on BOTTOM (solid shape): outline of 495 points within 27.87,18.67 43.5,43.19
+5VALW on IN1 (solid shape): 115.71,60.23 115.71,59.62 115.41,59.32 115.22,59.32 114.61,59.94 114.61,60.23 114.87,60.49 115.45,60.49
+5VALW on IN1 (solid shape): 98.62,37.96 98.62,37.49 97.18,36.06 96.79,36.06 96.59,36.25 96.59,36.58 96.71,36.69 96.71,36.92 98.03,38.24 98.34,38.24
+5VALW on IN1 (solid shape): 119.8,53.18 119.8,52.58 119.58,52.37 118.69,52.37 117.39,53.67 117.39,54.9 117.39,54.9 117.39,55.06 117.53,55.2 117.78,55.2
+5VALW on IN2 (solid shape): outline of 273 points within 117.77,43.61 123.08,52.81
+5VALW on VCC: 29.51,20.09 29.01,20.59 29.01,24.61 36.22,31.83 36.22,33.72 35.09,34.86 34.38,34.86 33.95,35.28 33.95,40.05 34.46,40.56 50,40.56 50.3,40.26 50.3,38.75 48.37,36.82 48.37,32.85 52.75,28.48 85.5,28.48 90.97,23.01 95.94,23.01 106.25,33.32 106.25,35.82 117.99,47.56 118.77,47.56 119.91,46.43 119.91,45.86 119.9,45.86 119.9,45.72 118.07,43.89 118.07,42.41 120.46,40.02 120.46,39.53 120.46,39.52 120.46,39.31 120.46,39.31 110.22,29.07 105.1,29.07 103.21,27.18 103.21,20.57 102.89,20.24 102.88,20.24 102.76,20.12 78.97,20.12 77.79,21.3 74.9,21.3 73.72,20.12 32.53,20.12 32.5,20.09
+5VALW_L_TBT on BOTTOM (solid shape): 29.72,36.86 29.72,34.82 29.69,34.79 27.68,34.79 27.13,34.24 25.86,34.24 25.41,33.79 24.43,33.79 24.37,33.85 24.37,35.21 24.49,35.33 25.45,35.33 25.89,35.78 25.89,36.64 26.11,36.86 27.41,36.86 27.49,36.94 29.64,36.94
+5VALW_L_TBT on IN1 (solid shape): 25.16,35.43 25.3,35.4 25.43,35.43 25.44,35.43 26.83,35.43 26.94,35.32 26.94,34.43 26.79,34.28 25.97,34.28 25.52,33.83 24.59,33.83 24.45,33.97 24.45,34.53 24.28,34.7 23.65,34.7 23.52,34.83 23.52,35.27 23.68,35.43 25.15,35.43
+5VALW_L_TBT on IN2 (solid shape): 27.14,35.65 27.14,34.53 26.94,34.32 26.04,34.32 25.69,33.97 25.69,29.68 25.57,29.68 25.34,29.44 25.34,29.24 24.76,28.66 24.75,28.66 24.58,28.57 24.49,28.4 24.48,28.38 24.08,27.98 20.62,27.98 20.57,27.92 19.98,27.92 19.9,28 19.9,28.6 19.97,28.68 23.94,28.68 24.46,29.2 24.46,34.32 24.8,34.66 24.8,35.53 24.85,35.58 24.94,35.61 25.01,35.56 25.38,35.41 25.63,35.72 25.63,35.77 27.02,35.77
+5VALW_L_TBT on IN3 (solid shape): 28.35,35.41 29.09,35.41 29.18,35.32 29.18,34.76 29.1,34.68 28.47,34.68 28.45,34.69 28.3,34.72 28.15,34.69 28.14,34.68 27.97,34.68 27.46,34.17 26.79,34.17 26.71,34.17 26.64,34.17 25.84,34.17 25.47,33.79 24.43,33.79 24.37,33.85 24.37,35.21 24.56,35.39 25.25,35.39 25.26,35.4 25.29,35.4 25.35,35.4 25.42,35.42 28.33,35.42
+5VALWP on TOP (solid shape): 27.22,25.7 27.22,24.47 27.24,24.45 27.77,24.45 27.77,24.44 27.77,24 27.76,23.99 27.23,23.99 27.22,23.98 27.22,23.25 27.23,23.24 27.77,23.24 27.78,23.23 27.78,22.79 27.77,22.78 27.26,22.78 27.25,22.78 27.22,22.76 27.22,20.17 27.01,19.96 21.13,19.96 21,20.09 21,20.84 21.6,21.45 21.6,25.44 22.18,26.02 26.9,26.02
+5VALWP on BOTTOM (solid shape): 25.76,24.4 25.76,18.75 25.38,18.38 22.42,18.38 21.9,18.89 21.9,24.73 22.31,25.13 25.02,25.13
+5VS on TOP (solid shape): 90.75,27.8 90.75,27.43 90.49,27.17 90.49,26.16 90.43,26.09 89.76,26.09 89.76,26.09 88.92,26.09 88.87,26.14 88.66,26.14 88.48,26.32 88.48,26.76 88.37,26.87 88.37,27.66 88.58,27.87 88.89,27.87 88.89,27.87 90.69,27.87
+5VS on BOTTOM (solid shape): 90.64,28.87 90.64,26.12 89.91,25.39 89.91,20.07 91.16,18.82 91.16,16.53 90.92,16.29 87.97,16.29 87.66,16.6 87.66,20.47 88.56,20.47 88.56,20.42 88.57,20.37 88.58,20.32 88.61,20.27 88.64,20.23 88.67,20.19 88.72,20.16 88.76,20.14 88.81,20.12 88.86,20.12 88.92,20.12 88.97,20.12 89.02,20.14 89.06,20.16 89.1,20.19 89.14,20.23 89.17,20.27 89.2,20.32 89.21,20.37 89.22,20.42 89.22,20.47 89.21,20.52 89.2,20.57 89.17,20.62 89.14,20.66 89.1,20.7 89.06,20.73 89.02,20.75 88.97,20.77 88.92,20.78 88.86,20.78 88.81,20.77 88.76,20.75 88.72,20.73 88.67,20.7 88.64,20.66 88.61,20.62 88.58,20.57 88.57,20.52 88.56,20.47 87.66,20.47 87.66,22.59 88.66,23.59 88.66,27.54 88.09,28.1 88.09,29.13 88.38,29.41 90.09,29.41
+5VS on IN1 (solid shape): 111.14,16.86 111.48,16.86 111.62,16.71 111.62,16.67 111.09,16.14 108.86,16.14 108.73,16.27 108.73,16.67 108.92,16.86 111.14,16.86
+5VS on IN1 (solid shape): 195.05,9.82 195.05,9.48 194.91,9.33 193.29,9.33 193.28,9.35 193.2,9.35 192.92,9.62 192.92,9.81 192.98,9.87 195,9.87
+5VS on IN1 (solid shape): 124.16,21.23 124.16,20.85 123.6,20.28 123.56,20.31 123.15,20.29 123.13,19.88 123.16,19.85 122.29,18.97 120.19,18.97 120.09,19.07 120.09,19.44 120.43,19.78 121.87,19.78 122.38,20.29 122.41,20.29 122.72,20.37 122.8,20.68 122.8,20.71 123.35,21.26 124.13,21.26
+5VS on IN2 (solid shape): 91.05,16.87 110.16,16.87 110.19,16.84 110.19,16.51 110.07,16.39 92.33,16.39 92.28,16.34 89.95,16.34 89.76,16.53 89.76,16.63 90,16.87 91.05,16.87
+8.4V_BATT on TOP (solid shape): 97.4,12.98 97.67,12.84 97.94,12.98 98.5,12.98 98.94,12.55 98.94,11.39 99.27,11.05 106.17,11.05 106.33,10.89 106.33,10.33 106.29,10.29 106.08,10.29 105.36,9.58 103.18,9.58 102.8,9.2 102.8,7.81 102.71,7.72 100.99,7.72 100.7,8.01 98.74,8.01 98.36,8.39 97.35,8.39 96.87,8.87 96.87,9.66 96.52,10.01 96.41,10.01 96.23,10.2 96.23,12.79 96.42,12.98
+8.4V_BATT+ on TOP (solid shape): 107.9,12.68 108.11,12.68 108.31,12.48 108.31,12.27 108.19,12.15 108.19,11.27 101.01,11.27 100.83,11.45 100.83,12.56 100.95,12.68 104.12,12.68 104.48,13.04 107.53,13.04
+8.4V_BATT+ on BOTTOM (solid shape): 107.4,12.8 107.4,11.06 106.34,10 101.33,10 101.05,10.28 101.05,10.28 101.03,10.31 101.03,12.89 101.18,13.04 107.15,13.04
+8.4V_BATT+ on IN1 (solid shape): 108.32,12.38 108.32,11.91 108.26,11.84 107.18,11.84 107.02,11.69 107.02,11.01 106.77,10.76 101.32,10.76 101.16,10.92 101.16,12.13 101.56,12.54 108.17,12.54
+8.4V_BATT+ on IN2 (solid shape): 107.02,11.9 107.02,10.92 106.91,10.8 101.51,10.8 101.24,11.07 101.24,11.62 101.63,12.02 106.91,12.02
+8.4V_BATT+ on IN3 (solid shape): 107.02,12.54 107.02,11.98 107.01,11.97 107.01,11.73 107.02,11.72 107.02,11.14 106.86,10.98 101.36,10.98 100.64,11.7 100.64,12.7 100.81,12.86 106.7,12.86
+VCC3V3_TBT_L_LDO on TOP (solid shape): 16.7,38.1 16.7,37.61 16.43,37.34 16.43,35.31 16.34,35.22 15.35,35.22 15.13,35.44 15.13,38.19 15.36,38.42 16.38,38.42
+VCC3V3_TBT_L_LDO on TOP (solid shape): 18.24,27.71 19.16,27.71 19.25,27.62 19.25,27.13 19.23,27.11 19.11,27.11 18.88,27.33 18.72,27.33 18.72,27.33 18.64,27.35 18.56,27.33 18.55,27.33 17.81,27.33 17.33,26.85 16.37,26.85 15.76,27.46 15.76,27.72 15.81,27.77 16.11,27.77 16.6,27.27 16.91,27.27 16.92,27.28 17.03,27.28 17.14,27.39 17.14,27.74 17.53,27.74 17.53,27.75 17.58,27.75 17.63,27.8 18.16,27.8
+VCC3V3_TBT_L_LDO on BOTTOM (solid shape): 27.96,32.36 28.38,32.36 28.41,32.33 28.41,30.16 28.56,30.02 28.56,29.56 28.54,29.54 28.3,29.54 28.28,29.55 28.28,29.95 28.25,29.99 27.7,29.99 27.65,30.04 27.65,31.92 27.65,31.92 27.65,32.18 27.83,32.36 27.88,32.37 27.96,32.37
+VCC_CORE on TOP (solid shape): 167.33,20.81 161.33,20.81 161.33,26.81 167.33,26.81
+VCC_CORE on TOP (solid shape): outline of 984 points within 150.9,18.99 187.87,52.52
+VCC_CORE on BOTTOM (solid shape): 181.46,30.21 181.74,29.94 181.74,25.84 181.83,25.75 184.38,25.75 184.44,25.81 184.44,26.74 184.53,26.83 187.3,26.83 187.31,26.82 187.95,26.82 188.18,26.59 188.18,25.69 187.64,25.15 187.64,21.37 187.42,21.14 182.31,21.14 182.1,20.93 167.76,20.93 167.55,21.14 167.55,29.17 167.73,29.34 168.66,29.34 169.38,28.63 172.93,28.63 173.13,28.83 173.13,29.52 173.45,29.84 175.41,29.84 175.68,29.57 175.68,28.26 175.79,28.16 175.79,25.89 176.07,25.61 177.79,25.61 177.96,25.77 177.96,29.27 177.96,29.28 177.96,29.87 178.31,30.22 181.46,30.22
+VCC_CORE on BOTTOM (solid shape): outline of 982 points within 151.32,49.79 160.29,52.55
+VCC_CORE on BOTTOM (solid shape): outline of 2791 points within 151.71,37.96 168.12,42.02
+VCC_CORE on IN1 (solid shape): 173.35,26.51 176.13,26.51 176.13,26.5 176.24,26.49 176.34,26.5 176.35,26.51 176.54,26.51 176.71,26.45 176.89,26.51 177.1,26.51 177.27,26.45 177.45,26.51 177.65,26.51 177.86,26.42 178.08,26.51 182.99,26.51 183.17,26.45 183.34,26.51 185.45,26.51 187.55,24.4 187.55,22.18 185.68,20.31 167.9,20.31 167.3,20.9 167.3,25.71 167.6,26 167.6,26.96 167.98,27.33 172.52,27.33
+VCC_CORE on IN1 (solid shape): outline of 309 points within 161.45,39.78 167.89,48.87
+VCC_CORE on IN1 (solid shape): outline of 1665 points within 151.26,37.21 161.69,52.75
+VCC_CORE on IN2 (solid shape): outline of 3041 points within 151.51,20.93 187.66,52.59
+VCC_CORE on IN3 (solid shape): 174.26,26.27 186.47,26.27 187.5,25.24 187.5,21.04 187.4,20.93 167.63,20.93 166.98,21.59 166.98,26.39 167.49,26.9 173.62,26.9
+VCC_CORE on IN3 (solid shape): outline of 2108 points within 151.71,35.67 168.15,50.64
+VCC_CORE on VCC: 152.02,19.42 151.67,19.77 151.67,51.19 153.12,52.64 159.7,52.64 160.04,52.31 160.04,49.75 160.79,49 168.22,49 168.58,48.64 168.58,48.64 168.64,48.58 168.64,42.74 168.12,42.22 168.12,35.42 169.92,33.62 182.27,33.62 182.64,33.26 182.64,33.25 182.71,33.17 182.71,29.98 182.87,29.98 187.84,25.01 187.84,21.54 187.44,21.14 182.3,21.14 182.08,20.92 164.95,20.92 164.16,20.12 154.6,20.12 153.89,19.42
+VCC_CORE on IN3: 152.62,52.59 152.75,52.59 152.91,52.74 152.95,52.76 153.03,52.75 153.08,52.68 153.29,52.49 153.53,52.66 153.58,52.72 153.66,52.73 153.83,52.72 153.98,52.79 154.8,52.79 154.87,52.77 154.9,52.7 155.13,52.49 155.36,52.71 155.38,52.75 155.43,52.75 156.61,52.75 156.84,52.52 156.84,51.84 156.7,51.7 156.7,51.31 156.43,51.03 155.05,51.03 154.62,51.46 153.85,51.46 153.43,51.04 153.26,51.04 152.77,51.53 151.86,51.53 151.86,51.58 151.73,51.82 151.46,51.86 151.43,51.85 151.33,51.95 151.33,52.39 151.37,52.47 151.45,52.49 151.61,52.53 151.7,52.66 151.75,52.72 151.83,52.73 151.93,52.71 152.02,52.72 152.1,52.71 152.15,52.65 152.33,52.47 152.57,52.54
+VCC_GT on TOP (solid shape): outline of 742 points within 169.09,35.23 194.12,51.84
+VCC_GT on BOTTOM (solid shape): outline of 2342 points within 168.24,35.96 192.9,47.92
+VCC_GT on IN2 (solid shape): 193.34,44.21 193.97,44.21 194.29,43.9 194.29,38.5 193.58,37.8 184.75,37.8 183.75,38.8 183.75,44.04 183.92,44.22 193.34,44.22
+VCC_GT on IN2 (solid shape): outline of 1795 points within 168.64,34.76 181.32,47.09
+VCC_GT on IN1: outline of 124 points within 169.02,35 194.55,47.45
+VCC_GT on VCC: 170.13,34.13 168.63,35.63 168.63,42.02 169.14,42.54 169.14,59.14 169.43,59.42 169.44,59.42 169.49,59.47 175.41,59.47 180.35,54.54 180.35,36.93 180.89,36.39 180.94,36.39 182.71,34.61 182.71,34.5 182.35,34.13
+VCC_GT on IN3: outline of 110 points within 168.37,34.48 194.62,47.69
+VCC_SA on TOP (solid shape): outline of 173 points within 141.11,23.76 151.04,50.02
+VCC_SA on BOTTOM (solid shape): 148.28,27.04 148.28,23.28 148.11,23.1 145.96,23.1 145.73,23.34 145.73,25.26 144.74,26.25 144.74,27.27 144.84,27.37 147.95,27.37
+VCC_SA on BOTTOM (solid shape): outline of 799 points within 147.26,39.94 151.58,52.46
+VCC_SA on IN1 (solid shape): outline of 98 points within 147.39,39.86 151.13,52.52
+VCC_SA on IN2 (solid shape): outline of 346 points within 147.39,39.86 151.42,52.83
+VCC_SA on IN3 (solid shape): 149.5,52.56 149.53,52.53 149.8,52.26 149.8,52.26 149.8,51.08 149.11,50.4 149.11,50.11 149.07,50.04 148.99,50.02 148.62,49.72 148.99,49.42 149.07,49.4 149.11,49.32 149.11,48.48 148.93,48.29 147.94,48.29 147.42,48.81 147.42,49.23 147.8,49.61 147.81,49.63 147.81,50.57 147.66,50.72 147.66,51.23 147.76,51.34 148.91,51.34 149.07,51.51 149.07,52.46 149.22,52.61 149.45,52.61
+VCC_SA on IN3 (solid shape): outline of 100 points within 147.63,39.88 151.59,44
+VCC_SA on VCC: 148.8,19.42 148.1,20.12 142.81,20.12 142.43,20.5 142.43,27.51 147.57,32.65 147.57,48.76 147.14,49.19 147.14,49.83 147.14,49.84 147.14,49.92 147.6,50.38 150.7,50.38 151.12,49.97 151.12,49.96 151.16,49.91 151.16,19.79 150.82,19.46 150.82,19.46 150.78,19.42
+VCCIO on TOP (solid shape): 162.2,52.19 162.2,50.2 162.35,50.04 162.35,49.33 162.25,49.22 160.84,49.22 160.72,49.34 160.72,50.07 160.85,50.2 160.85,51.42 160.93,51.5 161.52,51.5 161.64,51.61 161.64,52.14 161.69,52.2 162.19,52.2
+VCCIO on TOP (solid shape): 109.6,24.75 111.24,24.75 111.4,24.59 111.4,24.13 111.47,24.07 111.47,23.14 111.79,22.82 112.23,22.82 112.23,22.25 113.63,22.25 113.63,22.76 114.07,22.76 114.45,22.38 114.45,19.97 114.2,19.71 107.47,19.71 107.02,20.16 107.02,24.41 107.91,25.3 109.05,25.3
+VCCIO on TOP (solid shape): 149.03,49.11 149.03,45.92 149.51,45.44 149.51,45.02 149.48,45 147.21,45 147.01,45.2 147.01,46.21 147.31,46.52 148.29,46.52 148.51,46.74 148.51,47.43 148.41,47.53 148.19,47.53 147.99,47.73 147.99,49.15 148.13,49.28 148.86,49.28
+VCCIO on BOTTOM (solid shape): outline of 226 points within 149.93,49.82 151.35,52.33
+VCCIO on BOTTOM (solid shape): outline of 265 points within 160.43,50.27 162.12,52.36
+VCCIO on IN1 (solid shape): 149.14,47.16 149.14,45.66 149.4,45.39 149.4,45.2 149.3,45.09 147.46,45.09 147.38,45.17 147.38,47 147.67,47.28 149.01,47.28
+VCCIO on IN1 (solid shape): 162.18,51.35 162.18,50.61 162.12,50.55 162.12,49.37 162.06,49.31 161.9,49.31 161.83,49.38 161.83,49.91 161.42,50.32 161.02,50.32 160.45,50.89 160.45,51.71 160.57,51.83 161.69,51.83
+VCCIO on IN1 (solid shape): 151.25,51.5 151.25,50.74 151.24,50.68 151.25,50.55 151.45,50.34 151.45,49.86 151.33,49.74 151.28,49.73 151.23,49.71 149.93,49.71 149.56,50.07 149.56,50.33 149.63,50.4 149.95,50.4 149.98,50.37 149.99,50.36 150.14,50.21 150.35,50.26 150.74,50.26 150.92,50.44 150.92,50.47 150.93,50.48 150.96,50.59 150.93,50.71 150.92,50.72 150.92,50.78 150.78,50.92 150.63,50.92 150.53,51.03 150.53,51.33 149.99,51.86 149.99,52.12 150.18,52.31 150.44,52.31
+VCCIO on IN2 (solid shape): 151.27,52.62 151.27,51.67 151.27,51.67 151.25,51.57 151.27,51.47 151.27,51.46 151.27,50.81 151.27,50.8 151.24,50.68 151.27,50.56 151.27,50.55 151.27,50.08 151.11,49.93 149.68,49.93 149.55,50.06 149.55,50.73 149.75,50.94 149.75,52.63 149.8,52.68 151.2,52.68
+VCCIO on VCC: 104.16,20.12 103.72,20.57 103.72,26.97 105.31,28.56 110.43,28.56 131.12,49.25 131.12,57.09 133.95,59.92 134.5,59.92 134.95,59.47 168.22,59.47 168.64,59.06 168.64,49.86 168.28,49.51 161,49.51 160.55,49.96 160.55,52.52 159.91,53.15 152.91,53.15 151.16,51.4 151.16,51.17 150.88,50.89 147.39,50.89 145.89,49.38 136.8,49.38 135.15,47.74 135.15,42.76 122.65,30.26 117.76,30.26 114.64,27.15 114.64,20.59 114.28,20.23 114.28,20.23 114.17,20.12
+VCCIO on IN3: 156.72,51.15 157.15,51.03 156.83,51.34 156.83,51.64 156.97,51.78 156.97,52.44 161.99,52.44 162.16,52.27 162.16,51.82 162.16,51.81 162.11,51.65 162.16,51.5 162.16,51.49 162.16,49.34 161.87,49.05 153.7,49.05 153.65,49.1 153.64,49.11 153.29,49.31 153.05,48.99 153.02,48.91 152.95,48.88 152.9,48.88 152.41,48.39 152.38,48.41 152.03,48.35 151.97,48 151.99,47.97 151.57,47.55 151.54,47.56 151.27,47.47 151.19,47.2 151.19,47.18 151.18,47.16 151.18,44.61 150.7,44.13 148.07,44.13 147.02,45.19 147.02,46.14 148.22,47.35 148.22,47.36 149.24,48.38 149.24,49.32 149.24,49.33 149.24,50.11 149.24,50.34 149.93,51.03 149.93,52.21 150.11,52.39 150.78,52.39 151.2,51.97 151.2,51.9 151.7,51.4 152.7,51.4 152.74,51.38 153.2,50.91 153.48,50.91 153.9,51.33 154.02,51.33 154.02,51.27 154.02,51.26 154.19,50.91 154.44,51.2 154.45,51.29 154.52,51.33 154.57,51.33 155,50.9 155.95,50.9 156.04,50.89 156.13,50.9 156.48,50.9
+VCCIO_OUT on TOP (solid shape): 115.28,25.6 115.28,23.71 114.58,23.01 111.79,23.01 111.66,23.14 111.66,23.52 112.1,23.97 112.1,24.73 112.17,24.79 112.54,24.79 113.14,25.39 113.14,26.05 113.16,26.08 114.8,26.08
+VCCLDOSRAM_1P24 on BOTTOM (solid shape): 142.97,50.54 143.32,50.54 143.4,50.44 143.5,50.37 143.5,49.47 143.33,49.3 143.01,49.3 143,49.3 142.88,49.34 142.77,49.3 142.76,49.3 142.55,49.3 142.28,49.57 142.28,50.39 142.43,50.54 142.96,50.54
+VCCPLL_OC on TOP (solid shape): 149.36,51.97 149.36,51.74 149.2,51.58 149.2,50.48 149.04,50.32 148.82,50.32 148.65,50.15 148.65,49.54 148.59,49.47 148.13,49.47 148.04,49.56 148.04,50.22 148.62,50.8 148.62,50.98 148.63,50.98 148.63,51.93 148.69,51.99 149.33,51.99
+VCCPLL_OC_R on TOP (solid shape): 154.74,57.93 154.74,56.52 154.51,56.29 151.25,56.29 151.16,56.38 151.16,56.99 151.28,57.1 152.69,57.1 153.05,57.46 153.05,57.91 153.21,58.07 154.59,58.07
+VCCST on TOP (solid shape): 143.34,42.79 143.34,42.56 143.59,42.31 145.37,42.31 145.81,42.75 145.96,42.75 145.96,42.74 146.57,42.74 146.57,42.75 147.15,42.75 147.15,42.89 148.25,42.89 148.3,42.84 148.3,42.13 148.17,42 147.43,42 147.26,42 147.15,41.9 147.15,41.54 147.1,41.49 146.59,41.49 146.58,41.48 146.58,41.44 146.58,41.44 146.58,41.37 146.54,41.34 146.54,40.43 146.42,40.3 146.29,40.33 146.17,40.3 146,40.3 145.88,40.42 145.88,40.81 146.03,40.81 146.03,41.45 145.8,41.45 145.76,41.49 145.02,41.49 145.01,41.48 144.9,41.48 144.88,41.46 144.86,41.46 144.86,41.05 144.72,40.91 144.69,40.94 144.44,40.98 144.23,40.83 143.93,40.83 143.88,40.9 143.8,40.95 143.8,40.95 143.64,41.56 143.4,40.98 143.41,40.96 143.42,40.94 143.34,40.86 143.29,40.76 142.66,40.76 142.33,41.08 142.33,42.92 142.41,42.99 143.14,42.99
+VCCST on BOTTOM (solid shape): 150.33,31.26 150.33,30.88 149.34,29.89 148.6,29.89 148.53,29.95 148.53,30.39 148.62,30.48 148.62,31.33 148.71,31.41 150.18,31.41
+VCCST on BOTTOM (solid shape): 164.24,21.89 164.24,21.07 164.16,20.99 163.39,20.99 163.09,21.29 162.68,21.29 162.6,21.38 162.6,21.97 162.61,21.98 164.15,21.98
+VCCST on BOTTOM (solid shape): 147.35,42.3 147.35,42.08 146.93,41.99 147.19,41.65 146.8,41.26 146.78,41.26 146.52,41.05 146.64,40.74 146.67,40.73 146.67,40.59 146.64,40.57 146.57,40.51 146.52,40.42 146.52,40.41 146.48,40.37 146.14,40.37 146.13,40.41 146.09,40.5 146.01,40.57 145.96,40.66 146.01,40.74 146.12,41.09 145.79,41.25 145.7,41.27 145.67,41.35 145.67,42.25 145.77,42.35 147.3,42.35
+VCCST on IN2 (solid shape): 150.65,33.91 150.65,33.05 150.39,32.79 150.3,32.79 150.29,32.82 150.17,32.98 149.98,33.04 149.96,33.04 149.77,33.23 149.77,33.88 150.08,34.18 150.38,34.18
+VCCST on IN3 (solid shape): 146.89,41.63 146.89,40.94 146.96,40.87 146.96,40.55 146.79,40.38 146.16,40.38 145.73,40.81 145.73,41.61 145.76,41.65 146.87,41.65
+VCCST on IN3 (solid shape): 150.46,33.27 150.71,33.27 150.71,33.28 150.77,33.22 150.77,32.48 150.91,32.34 150.91,31.12 151.48,30.55 151.48,29.03 151.39,28.94 151.21,28.94 150.58,29.57 150.58,30.22 150.58,30.22 150.58,30.29 149.77,31.1 149.77,32.03 149.8,32.1 149.86,32.13 149.88,32.11 150.12,32.11 150.28,32.28 150.28,32.63 150.29,32.64 150.3,32.74 150.29,32.83 150.24,32.93 150.19,32.97 150.15,33.04 150.17,33.11 150.17,33.36 150.16,33.37 150.19,33.43 150.31,33.43
+VCCST_OUT on BOTTOM (solid shape): 148.23,31.24 148.23,30.49 148.17,30.43 147.81,30.43 147.54,30.7 147.06,30.7 146.9,30.54 146.9,30.24 146.85,30.19 145.02,30.19 144.97,30.24 144.97,30.72 145.04,30.78 146.71,30.78 147.21,31.29 148.18,31.29
+VCCSTG on BOTTOM (solid shape): 151.88,37.23 151.88,36.87 151.79,36.67 151.88,36.46 151.88,36.23 151.83,36.15 151.81,36.05 151.81,35.97 151.88,35.79 152.12,35.68 152.15,35.61 152.15,35.49 151.97,35.31 151.55,35.31 151.23,35.63 151.23,37.1 151.16,37.17 151.16,37.26 151.25,37.35 151.76,37.35
+VCCSTG_OUT on BOTTOM (solid shape): 146.93,28.77 146.93,27.62 146.88,27.57 145.1,27.57 144.97,27.7 144.97,28.72 145.05,28.79 146.11,28.79 146.22,28.89 146.8,28.89
+VIN_3V3_L_TBT on BOTTOM (solid shape): 28.53,34.59 28.53,33.98 28.69,33.82 28.69,33.11 28.61,33.03 27.75,33.03 27.65,33.14 27.65,34.53 27.72,34.61 28.51,34.61
GND on TOP (solid shape): 74.45,30.2 73.65,30.2 73.65,43.15 74.45,43.15
GND on TOP (solid shape): 100.95,70.44 100.15,70.44 100.15,73.34 100.95,73.34
GND on TOP (solid shape): 100.95,49.43 100.15,49.43 100.15,62.53 100.95,62.53
GND on TOP (solid shape): 100.95,44.42 100.15,44.42 100.15,47.22 100.95,47.22
GND on TOP (solid shape): 209.48,3.87 199.48,3.87 199.48,15.87 209.48,15.87
GND on TOP (solid shape): 150.95,2.31 148.66,2.31 148.66,2 115.95,2 115.95,3.3 150.95,3.3
GND on TOP (solid shape): 64.45,50.99 64.45,47.19 64.38,47.12 63.85,47.12 63.76,47.21 63.76,50.85 63.92,51.01 64.43,51.01
GND on TOP (solid shape): 76.35,55.37 76.35,55.05 75.66,54.36 75.35,54.36 75.01,54.7 75.01,55.03 75.67,55.69 76.03,55.69
GND on TOP (solid shape): 100.58,7.71 100.58,6.87 100.42,6.71 99.08,6.71 98.78,7.01 98.78,7.73 98.83,7.78 100.51,7.78
GND on TOP (solid shape): 100.95,30.2 100.15,30.2 79.1,30.2 79.1,31 100.15,31 100.15,42.02 100.95,42.02
GND on TOP (solid shape): 108.16,11.07 108.16,10.5 108.1,10.44 106.58,10.44 106.51,10.5 106.51,10.98 106.64,11.1 108.13,11.1
GND on TOP (solid shape): 115.61,71.29 115.61,63.34 115.45,63.19 114.75,63.19 114.64,63.3 114.64,71.37 114.66,71.39 115.51,71.39
GND on TOP (solid shape): 124.3,77.36 124.3,74.99 124.14,74.83 122.87,74.83 122.81,74.89 122.81,77.31 122.97,77.47 124.19,77.47
GND on TOP (solid shape): 136.56,76.86 136.56,74.59 136.46,74.49 135.56,74.49 135.46,74.58 135.46,76.83 135.56,76.93 136.49,76.93
GND on TOP (solid shape): 137.31,72.57 137.31,70.78 137.23,70.7 136.34,70.7 136.26,70.78 136.26,72.56 136.32,72.61 137.27,72.61
GND on TOP (solid shape): 137.4,27.41 137.4,26.53 137.12,26.25 133.9,26.25 133.41,26.74 133.41,28.37 133.63,28.59 136.23,28.59
GND on TOP (solid shape): 151.4,37.53 151.4,35.5 151.3,35.4 150.56,35.4 150.48,35.47 150.48,37.61 150.53,37.66 151.27,37.66
GND on TOP (solid shape): 162.66,44.07 162.66,41.99 162.56,41.89 161.06,41.89 160.97,41.97 160.97,44.11 161,44.13 162.6,44.13
GND on TOP (solid shape): 165,43.76 165,41.65 164.99,41.64 164.37,41.64 164.3,41.71 164.3,43.78 164.33,43.8 164.95,43.8
GND on TOP (solid shape): 172.4,49.67 172.4,42.56 172.27,42.44 171.51,42.44 171.38,42.56 171.38,49.67 171.51,49.8 172.27,49.8
GND on TOP (solid shape): 180.33,44.41 180.33,43.82 180.28,43.77 175.94,43.77 175.91,43.81 175.91,44.41 175.97,44.47 180.27,44.47
GND on TOP (solid shape): 185.42,9.17 185.42,7.87 185.36,7.81 183.89,7.81 183.82,7.88 183.82,9.14 183.89,9.21 185.38,9.21
GND on TOP (solid shape): 198.67,59.98 198.67,59.33 198.57,59.23 193.9,59.23 193.82,59.31 193.82,59.97 193.91,60.05 198.6,60.05
GND on TOP (solid shape): 205.71,39.04 205.71,38.45 205.64,38.39 204.03,38.39 203.91,38.5 203.91,39.01 204.02,39.12 205.63,39.12
GND on TOP (solid shape): 39.87,71.6 39.87,69.94 39.81,69.88 38.82,69.88 38.82,71.42 39.07,71.66 39.81,71.66
GND on TOP (solid shape): 32.42,74.29 32.42,74.09 32.34,74.02 31.77,74.02 31.76,74.02 30.23,74.02 30.18,74.07 30.18,74.53 30.23,74.58 32.12,74.58
GND on TOP (solid shape): 38.08,27.39 38.08,24.39 35.59,21.9 32.55,21.9 29.34,25.1 29.34,28.61 29.88,29.15 31.03,29.15 31.22,29.34 36.13,29.34
GND on TOP (solid shape): 100.95,76.92 100.15,76.92 100.15,80.4 78.98,80.4 74.45,75.87 74.45,50.4 73.65,50.4 73.65,76.2 78.65,81.2 100.95,81.2
GND on TOP (solid shape): 192.43,13.19 192.43,7.68 192.18,7.43 190.91,7.43 190.87,7.47 190.87,12.92 191.19,13.24 192.17,13.24 192.18,13.25 192.36,13.25
GND on TOP (solid shape): 199.06,74.27 199.06,73.36 199,73.3 198.1,73.3 197.87,73.52 197.87,74.29 198.03,74.45 198.88,74.45
GND on TOP (solid shape): 28.63,69.52 28.63,66.39 27.36,65.12 24.6,65.12 24.18,64.7 22.26,64.7 22,64.96 22,68.24 22.27,68.51 22.27,68.57 24.52,70.82 27.32,70.82
GND on TOP (solid shape): 44.54,50.59 44.54,47.63 43.71,46.8 43.7,46.8 43.62,46.73 42.86,46.73 42.64,46.95 42.64,48.78 43.93,50.07 43.93,50.54 44.03,50.64 44.49,50.64
GND on TOP (solid shape): 69.21,21.39 70.44,21.39 70.51,21.32 70.51,21.13 70.44,21.06 69.37,21.06 69.08,20.77 68.53,20.77 68.46,20.84 68.46,21.36 68.54,21.44 69.16,21.44
GND on TOP (solid shape): 172.11,40.4 172.11,38.69 171.98,38.55 170.98,38.55 170.71,38.82 170.71,40.43 170.73,40.45 172.07,40.45
GND on TOP (solid shape): 101.13,29.26 101.13,28.74 100.98,28.58 97.55,28.58 97.43,28.47 97.01,28.47 96.52,27.98 93.7,27.98 93.46,28.23 93.46,29.24 93.67,29.45 100.95,29.45
GND on TOP (solid shape): 109.26,37.33 109.26,35.85 109.17,35.76 106.34,35.76 106.22,35.88 104.18,35.88 104.18,35.88 104.06,35.88 103.84,36.1 103.84,37.3 104,37.46 109.14,37.46
GND on TOP (solid shape): 180.29,48.49 177.46,48.49 177.19,48.22 176.78,48.22 176.77,48.22 176.53,48.22 176.3,48 175.73,48 175.56,48.17 175.56,49.17 175.65,49.26 180.29,49.26
GND on TOP (solid shape): 48.35,69.43 48.35,60.56 48.11,60.33 46.02,60.33 45.68,60.67 45.68,64.55 45.24,64.98 45.24,69.63 45.35,69.73 45.58,69.73 45.58,69.74 48.04,69.74
GND on TOP (solid shape): 74.26,20.68 74.26,15.85 74.24,15.84 74.24,14.04 73.93,13.73 72.64,13.73 72.36,14 72.36,14.64 72.19,14.82 71.84,14.82 71.72,14.95 71.72,21.3 71.84,21.43 73.51,21.43
GND on TOP (solid shape): 147.84,49.16 147.84,47.61 148.04,47.41 148.13,47.41 148.14,47.4 148.31,47.4 148.35,47.36 148.35,46.83 148.22,46.7 147.05,46.7 146.95,46.8 146.95,49.16 147.05,49.27 147.74,49.27
GND on TOP (solid shape): 154.65,51.43 155.06,51.43 155.09,51.4 155.09,50.5 155.05,50.46 154.66,50.46 154.63,50.49 154.63,50.98 154.6,51.01 154.07,51.01 154.05,51.03 154.05,51.41 154.08,51.44 154.65,51.44
GND on TOP (solid shape): 84.68,79.48 84.68,79.25 81.42,75.98 81.42,75.88 81.5,75.81 81.5,75.75 81.28,75.53 81.19,75.53 81.11,75.61 81.04,75.61 77.58,72.14 77.05,72.14 76.61,72.58 76.61,73.34 83.15,79.87 84.29,79.87
GND on TOP (solid shape): 148.96,44.64 148.96,42.28 148.91,42.23 148.55,42.23 148.45,42.33 148.45,43.14 148.09,43.5 146.09,43.5 146.01,43.58 146.01,43.8 146.09,43.88 147.13,43.88 147.21,43.96 147.21,44.76 147.28,44.83 148.77,44.83
GND on TOP (solid shape): 157.15,51.43 157.86,51.43 157.89,51.41 157.89,51.07 157.87,51.05 157.26,51.05 157.18,50.96 157.18,50.5 157.14,50.46 156.75,50.46 156.72,50.49 156.72,51.41 156.74,51.43 157.15,51.43
GND on TOP (solid shape): 48.27,50.06 48.27,50.02 48.43,49.85 48.43,49.4 48.76,49.07 48.96,49.07 49.02,49.01 49.02,48.83 49.21,48.83 49.26,48.78 49.26,46.83 49.09,46.65 47.97,46.65 47.87,46.75 47.87,50.08 47.92,50.13 48.2,50.13
GND on TOP (solid shape): 94.83,9.81 94.83,7.6 95.85,6.58 96.84,6.58 96.93,6.48 96.93,5.89 96.88,5.85 89.93,5.85 89.55,6.23 89.55,8.69 89.75,8.9 91.49,8.9 91.63,9.05 91.63,10.45 91.79,10.61 94.03,10.61
GND on TOP (solid shape): 155.85,19.85 159.29,19.85 159.32,19.82 161.43,19.82 162.8,18.46 167.47,18.46 167.65,18.28 167.65,16.07 166.92,15.35 163.93,15.35 160.51,18.76 156,18.76 155.94,18.82 154.61,18.82 151.31,22.12 151.31,23.22 151.6,23.51 152.19,23.51
GND on TOP (solid shape): 54.58,70.87 54.58,70.01 54.94,69.65 56.17,69.65 56.27,69.56 56.27,66.75 56.39,66.62 56.39,60.59 56.15,60.34 54.82,60.34 54.37,60.79 54.37,69.52 53.72,70.17 51.71,70.17 51.56,70.32 51.56,71.71 51.77,71.92 53.53,71.92
GND on TOP (solid shape): 158.57,38.57 158.73,38.4 158.73,38.04 158.59,37.9 158.12,37.9 158.12,37.92 157.49,37.92 157.49,37.82 157.46,37.79 157.46,36.84 157.45,36.83 156.42,36.83 156.37,36.88 156.37,37.78 156.47,37.88 156.97,37.88 157.12,38.03 157.12,41.39 157.13,41.4 158.57,41.4
GND on TOP (solid shape): 101.18,19.43 101.18,17.61 101.56,17.22 103.53,17.22 103.61,17.14 103.61,15.66 103.58,15.62 99.58,15.62 99.39,15.81 99.39,16.77 99.09,17.07 97.72,17.07 97.47,17.31 94.73,17.31 94.42,17.62 94.42,19.42 94.59,19.59 101.02,19.59
GND on TOP (solid shape): 153.71,41.39 154.19,41.39 154.23,41.35 154.23,36.9 154.15,36.83 153.56,36.83 153.56,36.83 153.36,36.83 153.3,36.77 153.3,36.39 153.27,36.36 152.85,36.36 152.8,36.41 152.8,38.45 153.5,39.15 153.5,41.39
GND on TOP (solid shape): 41.62,71.65 41.62,70.55 41.64,70.54 41.64,70 41.1,69.46 41.1,67.76 40.98,67.64 40.03,67.64 39.84,67.83 39.84,68.78 39.95,68.88 40.32,68.88 40.76,69.33 40.76,69.74 41.12,70.1 41.12,71.67 41.15,71.7 41.57,71.7
GND on TOP (solid shape): 170.93,8.56 171.54,8.56 171.54,8.59 179.76,8.59 180.14,8.22 180.14,7.33 180.14,7.33 180.98,6.49 186.39,6.49 186.62,6.26 186.62,5.33 186.45,5.15 171.22,5.15 170.95,5.42 169.7,5.42 169.44,5.17 165.42,5.17 165.28,5.3 163.19,5.3 163.03,5.46 163.03,8.59 170.93,8.59
GND on TOP (solid shape): 21.19,24.48 21.19,21.31 20.82,20.94 20.82,20.04 21.11,19.76 25.67,19.76 25.71,19.8 26.97,19.8 27.03,19.74 27.03,19.06 26.61,18.65 20,18.65 19.73,18.92 19.73,22.95 19.32,23.36 19.06,23.36 18.96,23.46 18.96,24.5 19.14,24.68 20.99,24.68
GND on TOP (solid shape): 25.21,18.16 25.21,17.23 25.17,17.19 23.72,17.19 23.59,17.32 23.59,17.66 23.35,17.9 22.86,17.9 22.58,17.63 22.58,17.22 22.58,17.22 22.58,13.18 22,12.59 21.34,12.59 21.16,12.76 21.16,15.85 20.91,16.1 19.38,16.1 19.16,16.32 19.16,17.97 19.59,18.4 24.97,18.4
GND on TOP (solid shape): 80.62,47.35 80.62,46.88 76.99,43.25 76.54,43.25 75.88,42.59 75.06,42.59 75.03,42.61 75.03,43.04 75.06,43.07 75.46,43.07 75.56,43.16 75.56,43.8 75.51,43.85 75.51,43.88 76.24,44.62 76.24,44.67 79.34,47.77 79.5,47.77 79.82,48.08 79.88,48.08
GND on TOP (solid shape): 110.05,55.56 110.05,55.55 110.07,55.5 110.1,55.45 110.1,53.55 109.67,53.12 105.56,53.12 105.33,53.35 102.58,53.35 102.48,53.45 102.48,53.9 102.52,53.95 103.95,53.95 104.02,54.02 106.39,54.02 106.52,53.89 109.17,53.89 109.42,54.13 109.42,55.53 109.52,55.63 109.98,55.63
GND on TOP (solid shape): 180.31,41.68 180.31,40.61 180.27,40.58 178.04,40.58 177.92,40.46 175.72,40.46 175.64,40.37 175.64,40.17 175.55,40.08 175.22,40.08 175.15,40.15 175.15,40.41 175.15,40.51 175.02,40.64 174.95,40.64 174.5,41.09 174.5,41.47 174.58,41.54 175.65,41.54 175.83,41.72 180.26,41.72
GND on TOP (solid shape): 114.74,52.17 114.74,52.15 112.92,50.33 111.89,50.33 110.33,48.77 109.86,48.77 109.09,48.01 109.07,48.01 107.44,46.38 107.34,46.38 106.56,47.15 106.56,47.39 105.58,48.37 105.58,48.97 107.13,50.52 107.13,51.08 107.82,51.77 107.95,51.77 108.16,51.56 108.16,51.28 109.39,50.05 109.66,50.05 111.8,52.2 114.17,52.2 114.43,52.47 114.45,52.47
GND on TOP (solid shape): 59.01,74.97 60.67,74.97 61.1,74.54 61.1,67.29 60.57,66.77 57.62,66.77 57.38,66.53 57.38,64.77 57.29,64.68 56.76,64.68 56.54,64.9 56.54,69.51 56.2,69.86 55.02,69.86 54.72,70.16 54.72,71.06 54.7,71.06 54.57,71.18 54.57,71.19 53.8,71.96 53.8,74.76 54.01,74.98 59,74.98
GND on TOP (solid shape): 113.26,78.99 113.26,77.54 112.39,76.66 112.39,75.29 112.3,75.2 106.87,75.2 106.59,75.36 106.31,75.2 104.92,75.2 104.71,75.41 103.87,75.41 103.3,75.97 103.3,78.94 103.8,79.43 112.81,79.43
GND on TOP (solid shape): 123.17,55.87 123.23,55.96 123.34,55.94 124.08,55.2 124.08,54.19 124.5,53.76 124.52,53.74 124.52,53.52 124.46,53.43 124.35,53.45 123.76,54.04 123.76,55.17 123.7,55.23 123.7,55.25 123.17,55.78
GND on TOP (solid shape): 166.4,40.65 166.47,40.65 166.5,40.62 166.5,40.25 166.41,40.15 165.03,40.15 165.03,36.61 164.96,36.54 164.41,36.54 164.28,36.67 164.28,40.17 164.23,40.22 163.32,40.22 163.25,40.29 162.73,40.29 162.57,40.13 162.57,37.64 162.7,37.51 162.7,36.56 162.66,36.52 161.85,36.52 161.75,36.62 161.75,37.61 161.69,37.68 160.89,37.68 160.79,37.78 160.79,39.88 160.78,39.88 160.53,40.14 159.35,40.14 159.29,40.2 159.29,40.63 159.31,40.66 166.39,40.66
GND on TOP (solid shape): 158.71,47.72 158.71,46.89 158.65,46.83 158.24,46.83 158.13,46.72 158.13,46.2 157.89,45.96 157.89,44.91 158.13,44.67 158.13,44.36 158.32,44.17 159.32,44.17 159.42,44.08 159.42,43.42 159.27,43.27 153.5,43.27 153.44,43.33 153.44,45.24 155.6,45.24 155.74,45.1 155.74,45.04 155.75,45.03 155.75,44.86 155.8,44.81 156.42,44.81 156.53,44.92 156.53,46.07 156.42,46.18 155.98,46.18 155.98,46.57 155.85,46.7 154.2,46.7 154.14,46.76 154.14,47.65 154.27,47.78 158.65,47.78
GND on TOP (solid shape): 152.56,50.18 152.56,49.83 152.66,49.73 152.66,43.53 152.6,43.53 152.6,42.36 152.66,42.36 152.66,40.34 152.51,40.07 152.66,39.79 152.66,39.2 152.44,38.98 151.92,38.98 151.92,39.01 151.54,39.01 151.41,39.14 151.41,39.46 151.3,39.57 151.3,41.98 151.13,42.15 151.13,49.13 151.14,49.15 151.17,49.18 151.17,49.68 151.2,49.71 151.63,49.71 151.69,49.77 151.69,50.23 151.74,50.28 152.46,50.28
GND on TOP (solid shape): 69.05,59.65 69.05,58.72 68.77,58.44 68.77,57.74 68.78,57.73 68.78,57.71 68.99,57.5 68.99,57.35 68.87,57.22 68.82,57.22 68.64,57.05 68.64,54.43 68.18,53.97 68.18,52.33 67.58,51.73 67.58,50.64 67.37,50.43 66.59,50.43 66.41,50.61 66.41,51.02 66.84,51.45 66.84,52.15 66.36,52.63 64.92,52.63 64.85,52.7 64.85,53.18 64.87,53.19 66.63,53.19 67,52.83 67.68,52.83 67.91,53.06 67.91,53.08 67.91,54.04 67.42,54.52 67.42,55.79 67.85,56.22 67.85,57.06 67.68,57.22 67.59,57.22 66.96,57.86 66.96,58.71 67.97,59.72 68.99,59.72
GND on TOP (solid shape): 79.77,37.06 79.79,37.06 79.84,37.03 79.83,36.97 79.59,36.74 79.53,36.74 79.48,36.69 79.43,36.74 79.07,36.38 79.41,36.04 79.77,36.4 79.76,36.41 80.21,36.87 80.26,36.81 80.26,36.57 83.76,33.07 83.76,32.83 83.61,32.67 83.22,32.67 83.22,32.48 82.94,32.48 80.1,35.32 79.72,35.32 77.81,37.24 77.81,37.61 75.38,40.04 75.37,40.06 75.31,40.18 75.19,40.24 75.18,40.24 75.13,40.29 75.13,40.55 75.57,40.99 75.84,40.99
GND on TOP (solid shape): 169.95,49.85 169.95,42.83 168.92,41.8 168.92,38.71 168.76,38.55 168.34,38.55 168.33,38.59 168.06,38.83 167.78,38.59 167.77,38.55 166.7,38.55 166.65,38.6 166.65,39 166.69,39.04 167.44,39.04 167.87,39.46 167.87,41.23 168.07,41.44 168.07,41.91 167.58,42.4 167.58,44.69 167.44,44.83 165.98,44.83 165.87,44.94 165.87,48.25 166.15,48.53 167.41,48.53 167.41,49.58 167.85,50.03 169.77,50.03
GND on TOP (solid shape): 128.73,32.63 130.15,31.64 130.69,30 130.55,29.13 130.14,28.34 130.14,27.17 129.68,26.71 128.21,26.71 127.04,25.54 127.04,22.82 127.93,21.93 127.93,17.9 127.53,17.5 124.97,17.5 124.74,17.74 124.74,27.84 124.94,28.05 124.94,32.68 125.53,33.28 128.08,33.28
GND on TOP (solid shape): 23.5,64.43 25.57,64.43 25.84,64.16 25.84,62.6 26.56,61.89 28.63,61.89 28.75,61.77 28.75,61.13 28.59,60.97 28.34,60.97 28.26,60.9 27.99,60.9 27.61,60.73 27.99,60.56 28.14,60.56 28.19,60.5 28.19,60.26 28.16,60.23 27.84,60.23 27.69,60.38 26.04,60.38 25.99,60.43 25.99,60.8 25.74,61.05 23.7,61.05 23.64,61.11 23.64,61.82 23.63,61.82 23.63,61.87 23.44,62.05 23.19,62.05 22.9,62.33 22.83,62.47 22.7,62.54 22.09,63.15 22.09,64.41 22.25,64.56 23.37,64.56
GND on TOP (solid shape): 122.41,61.75 122.41,61.36 122.39,61.32 122.26,61.07 122.15,60.8 121.69,60.34 121.69,59.11 121.99,58.81 122.03,58.63 122.09,58.38 122.05,58.27 121.92,58.28 121.41,58.8 121.41,60.5 121.98,61.08 121.99,61.08 122.03,61.55 121.56,61.51 121.56,61.5 120.81,60.75 120.81,58.8 120.75,58.71 120.63,58.73 120.59,58.78 120.59,60.8 120.92,61.13 120.92,61.25 121.53,61.85 122.3,61.85
GND on TOP (solid shape): 66.3,44.68 66.3,42.53 67.31,41.52 72.78,41.52 73.47,42.2 73.47,43.19 73.56,43.29 74.45,43.29 74.47,43.27 74.47,30.2 74.43,30.16 73.59,30.16 73.47,30.28 73.47,31.94 72.52,31.94 71.88,31.31 68.25,31.31 68.25,31.33 67.47,32.12 67.11,32.12 66.53,32.7 66.53,35.45 67.72,35.45 67.72,34.24 68.64,33.32 69.45,33.32 73.34,37.21 73.34,40.28 72.9,40.72 71.88,40.72 71.85,40.73 71.79,40.74 71.74,40.75 71.69,40.74 71.64,40.73 71.61,40.72 70.73,40.72 70.7,40.73 70.65,40.73 70.6,40.73 70.55,40.73 70.52,40.72 70.45,40.72 70.45,40.69 70.43,40.67 70.39,40.64 70.35,40.6 70.33,40.55 70.31,40.5 70.29,40.45 70.29,40.39 70.3,40.34 70.3,40.31 70.3,38.04 67.72,35.45 66.53,35.45 66.53,35.83 64.99,37.37 64.99,38.53 65.49,39.03 65.49,42.38 65.03,42.84 63.27,42.84 62.87,43.23 62.87,43.46 62.46,43.87 62.2,43.87 62.14,43.93 62.14,44.69 62.19,44.74 64.45,44.74 64.71,45 65.98,45
GND on TOP (solid shape): 98.38,41.33 98.38,36.01 98.38,34.2 98.2,34.02 97.02,34.02 96.84,34.2 96.84,35.98 96.94,35.98 97.03,36.07 97.04,36.07 97.25,36.18 97.33,36.39 97.36,36.46 97.43,36.49 97.66,37.05 97.1,36.83 97.07,36.75 97,36.73 96.96,36.72 96.88,36.75 96.84,36.82 96.84,39.78 96.85,39.79 96.85,41.1 97.16,41.41 98.31,41.41
GND on TOP (solid shape): 111.95,67.86 111.95,65.71 111.76,65.41 111.95,65.11 111.95,64.49 111.78,64.2 111.95,63.91 111.95,63.04 111.85,62.95 111.45,62.95 111.21,63.03 110.98,62.95 110.3,62.95 110.19,63.03 110.05,63.06 109.98,63.09 109.95,63.16 109.95,65.4 110.1,65.69 109.95,65.97 109.95,66.33 110.11,66.62 109.95,66.9 109.95,67.93 109.99,67.97 111.84,67.97
GND on TOP (solid shape): outline of 96 points within 142.14,32.2 145.33,36.27
GND on TOP (solid shape): outline of 104 points within 52.45,6.85 64.74,14.94
GND on TOP (solid shape): outline of 111 points within 123.92,33.72 128.45,50.94
GND on TOP (solid shape): outline of 121 points within 53,4.53 86.67,15.57
GND on TOP (solid shape): 205.06,51.1 203.75,51.1 201.65,49 203.75,46.9 206.19,46.9 206.49,45.75 203.75,45.75 200.5,49 203.75,52.25 204.75,52.25
GND on TOP (solid shape): 135.44,81.49 146.13,81.49 146.13,81.8 162.55,81.8 162.55,81 162.7,80.65 163.05,80.5 164.85,80.5 165.2,80.65 165.35,81 165.35,81.8 178.34,81.8 178.34,81.49 189,81.49 189,81.8 200.1,81.8 200.1,80.5 166.58,80.5 165.93,79.56 164.85,79.2 163.05,79.2 161.97,79.56 161.32,80.5 121.05,80.5 121.05,79.9 119.42,77.49 116.57,78.1 116.57,79.54 116.24,79.87 115.85,79.87 115.85,79.9 115.85,80.5 101.45,80.5 101.45,81.8 135.44,81.8
GND on TOP (solid shape): outline of 143 points within 144.86,37.76 148.5,41.87
GND on TOP (solid shape): 30.58,81.49 40.92,81.49 40.92,81.8 47.15,81.8 47.15,81 47.3,80.65 47.65,80.5 49.45,80.5 49.8,80.65 49.95,81 49.95,81.8 72.65,81.8 72.65,81 72.8,80.65 73.15,80.5 74.95,80.5 75.3,80.65 75.45,81 75.45,81.8 76.75,81.8 76.75,81 76.22,79.73 74.95,79.2 73.15,79.2 72.07,79.56 71.42,80.5 51.18,80.5 50.53,79.56 49.45,79.2 47.65,79.2 46.57,79.56 45.92,80.5 23.1,80.5 24.4,81.8 30.58,81.8
GND on TOP (solid shape): outline of 141 points within 14.77,55.31 31.08,63
GND on TOP (solid shape): outline of 84 points within 0.3,49.46 24.05,62.74
GND on TOP (solid shape): outline of 1943 points within 0.2,0.2 215.51,81.6
GND on BOTTOM (solid shape): 15.35,43 14.55,43 14.55,63.7 15.35,63.7
GND on BOTTOM (solid shape): 26.83,63.7 24.65,63.7 24.65,64.5 26.83,64.5
GND on BOTTOM (solid shape): 39.56,43.75 39.56,40.75 38.76,40.75 38.76,43.75
GND on BOTTOM (solid shape): 90.07,39.2 85.7,39.2 85.7,40 90.07,40
GND on BOTTOM (solid shape): 146.92,14.7 134.15,14.7 134.15,15.5 146.92,15.5
GND on BOTTOM (solid shape): 151.43,14.7 149.76,14.7 149.76,15.5 151.43,15.5
GND on BOTTOM (solid shape): 76.25,40 82.3,40 82.3,39.2 75.45,39.2 75.45,60.49 76.25,60.49
GND on BOTTOM (solid shape): 146.52,15.39 146.52,14.83 146.39,14.7 134.15,14.7 134.15,15.5 146.41,15.5
GND on BOTTOM (solid shape): 30.58,81.49 40.92,81.49 40.92,81.5 41.95,81.5 41.95,78.5 24.95,78.5 24.95,81.5 30.58,81.5
GND on BOTTOM (solid shape): 119.24,36.74 119.24,33.91 119.18,33.85 115.1,33.85 114.92,34.03 114.92,36.46 115.38,36.92 119.05,36.92
GND on BOTTOM (solid shape): 151.35,15.45 151.35,14.76 151.3,14.71 149.89,14.71 149.8,14.8 149.8,15.5 149.9,15.61 151.19,15.61
GND on BOTTOM (solid shape): 190.99,14.9 190.99,12.78 190.97,12.76 190.08,12.76 190,12.85 190,14.85 190.12,14.97 190.91,14.97
GND on BOTTOM (solid shape): 194.69,15.03 194.69,12.8 194.67,12.78 193.78,12.78 193.7,12.87 193.7,14.97 193.81,15.09 194.62,15.09
GND on BOTTOM (solid shape): 202.42,16.79 202.42,15.55 202.31,15.45 200.84,15.45 200.71,15.57 200.71,16.77 200.81,16.87 202.34,16.87
GND on BOTTOM (solid shape): 8.93,13.54 8.93,11.46 8.84,11.37 8,11.37 7.87,11.51 7.87,13.53 7.96,13.62 8.84,13.62
GND on BOTTOM (solid shape): 120.3,13.52 111.29,13.52 111.29,14.22 111.3,14.22 111.3,14.33 119.5,14.33 119.5,25.77 120.3,25.77
GND on BOTTOM (solid shape): 125.91,51.41 125.91,50.45 125.77,50.3 124.77,50.3 124.18,50.9 124.18,51.27 124.26,51.36 125.26,51.36 125.42,51.51 125.81,51.51
GND on BOTTOM (solid shape): 165.25,5 210.15,5 210.15,5.47 210.95,5.47 210.95,4.2 164.45,4.2 164.45,14.7 154.26,14.7 154.26,15.5 165.25,15.5
GND on BOTTOM (solid shape): 18.25,44.71 18.25,44.15 18.18,44.07 18.15,44.1 15.92,44.1 15.87,44.04 15.8,44.04 15.71,44.13 15.71,44.71 15.83,44.83 18.13,44.83
GND on BOTTOM (solid shape): 55.65,68.06 55.65,67.3 55.53,67.18 55.53,65.96 55.48,65.9 55.36,65.9 55.29,65.97 55.29,67.16 54.98,67.48 54.98,68.07 55.03,68.13 55.59,68.13
GND on BOTTOM (solid shape): 68.27,53.55 73.27,53.55 73.27,40.75 72.47,40.75 72.47,52.75 67.46,52.75 67.46,58.95 44.57,58.95 44.57,52.75 43.77,52.75 43.77,59.75 68.27,59.75
GND on BOTTOM (solid shape): 120.3,28.09 119.5,28.09 119.5,28.55 119.02,29.02 119.02,29.27 119.12,29.37 119.41,29.37 119.5,29.45 119.5,37.23 111.3,37.23 111.3,38.03 120.3,38.03
GND on BOTTOM (solid shape): 123.65,15.5 128.66,15.5 128.66,14.7 122.85,14.7 122.85,39.2 108.6,39.2 105.38,39.2 95.61,39.2 95.61,40 123.65,40
GND on BOTTOM (solid shape): 139.46,29.1 139.46,26.35 139.41,26.3 138.8,26.3 138.75,26.35 138.75,28.39 139.03,28.67 139.03,29.15 139.1,29.22 139.33,29.22
GND on BOTTOM (solid shape): 69.45,60.3 50.25,60.3 50.25,61.1 68.65,61.1 68.65,77.1 51.05,77.1 51.05,61.1 50.25,61.1 50.25,77.9 69.45,77.9
GND on BOTTOM (solid shape): 189.06,14.7 189.06,10.09 188.33,9.36 185.16,9.36 184.99,9.54 184.99,12.4 185.15,12.57 186.6,12.57 186.89,12.86 186.89,14.72 187.05,14.88 188.88,14.88
GND on BOTTOM (solid shape): 203.22,25.69 203.22,23.77 202.91,23.46 202.15,23.46 201.93,23.68 201.93,24.93 201.82,25.03 201.46,25.03 201.38,25.11 201.38,25.68 201.44,25.74 203.17,25.74
GND on BOTTOM (solid shape): 13.47,30.07 13.47,29.4 13.36,29.29 12.65,29.29 12.63,29.31 11.48,29.31 11.4,29.23 11.4,28.47 11.34,28.41 8.69,28.41 8.38,28.73 8.38,30.01 8.51,30.14 13.4,30.14
GND on BOTTOM (solid shape): 17.8,43.17 17.8,41.14 17.6,40.94 17.6,40.12 17.55,40.06 16.9,40.06 16.83,40.13 16.83,41.01 17.09,41.28 17.09,41.3 17.13,41.34 17.13,42.74 17.58,43.19 17.78,43.19
GND on BOTTOM (solid shape): 23.2,41.81 23.2,41.78 23.38,41.6 23.38,40.69 23.27,40.58 23.25,40.58 23.23,40.6 21.67,40.6 21.61,40.66 21.61,41.72 22.12,41.72 22.33,41.93 23.07,41.93
GND on BOTTOM (solid shape): 55.65,75.57 55.65,74.7 55.5,74.55 55.5,73.55 55.45,73.5 55.34,73.5 55.27,73.56 55.27,74.38 55.26,74.38 55.26,74.73 55.05,74.94 55.05,75.57 55.1,75.62 55.61,75.62
GND on BOTTOM (solid shape): 198.6,68.94 202.69,53.66 199.75,52.84 199.75,44 205.41,44 210.95,23.33 210.95,8.32 210.15,8.32 210.15,23.22 204.8,43.2 198.95,43.2 198.95,53.45 201.86,54.26 197.91,69.01 197.91,75.48 198.6,75.48
GND on BOTTOM (solid shape): 54.8,72.25 54.8,70.58 55.05,70.32 56.78,70.32 56.91,70.19 56.91,69.61 56.35,69.05 51.78,69.05 51.63,69.2 51.63,71.16 51.63,71.17 51.63,71.76 51.79,71.92 52.87,71.92 53.25,72.3 54.75,72.3
GND on BOTTOM (solid shape): 54.88,64.59 54.88,62.98 55.18,62.68 57.01,62.68 57.14,62.55 57.14,61.76 57.01,61.64 51.8,61.64 51.63,61.81 51.63,63.54 51.63,63.54 51.63,64.38 51.75,64.49 52.96,64.49 53.16,64.7 54.77,64.7
GND on BOTTOM (solid shape): 168.31,13.12 168.31,13.03 168.24,12.96 167.24,12.96 166.87,12.59 166.87,11.27 166.81,11.21 165.93,11.21 165.79,11.34 165.79,12.53 166.01,12.74 166.62,12.74 167.07,13.19 168.25,13.19
GND on BOTTOM (solid shape): 24.85,38.67 24.85,38.6 24.86,38.6 24.86,38.04 24.94,37.96 25.72,37.96 25.8,37.88 25.8,36.88 25.72,36.8 25.72,36.8 25.65,36.87 23.51,36.87 23.49,36.89 23.49,37.28 23.7,37.49 23.7,37.73 23.71,37.75 23.71,38.5 23.93,38.71 24.81,38.71
GND on BOTTOM (solid shape): 15.35,41.5 15.35,31.44 15.35,31.44 15.35,30.99 15.35,30.99 15.35,30.7 5.65,30.7 5.65,10.8 7.85,10.8 26.35,10.8 26.35,26.7 27.15,26.7 27.15,10 4.85,10 4.85,31.5 14.55,31.5 14.55,41.5
GND on BOTTOM (solid shape): 38.55,59.01 36.05,55.01 36.05,48.5 31.98,48.5 27.15,40.77 27.15,37.15 26.35,37.15 26.35,41 31.54,49.3 35.25,49.3 35.25,55.24 35.42,55.51 37.75,59.24 37.75,63.7 28.83,63.7 28.83,64.5 38.55,64.5
GND on BOTTOM (solid shape): 185.38,46.37 187.66,46.37 187.89,46.6 187.89,46.85 187.92,46.88 194.03,46.88 194.13,46.77 194.15,46.77 194.15,46.55 193.44,45.84 191.27,45.84 189.43,43.99 188.57,43.99 188.31,43.74 188.31,43.18 188.2,43.07 182.66,43.07 182.36,43.37 182.36,47.74 182.66,48.05 183.71,48.05

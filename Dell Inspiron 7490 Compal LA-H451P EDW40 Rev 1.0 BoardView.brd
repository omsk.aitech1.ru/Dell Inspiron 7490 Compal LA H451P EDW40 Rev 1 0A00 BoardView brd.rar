# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_L_FORCE_PWR: length 1.1
  BOTTOM w0.081: UPD1.43 RPD130.2
TBT_PCIE_RBIAS: length 1.1
  TOP w0.203: RT34.1 24.27,55.52 v2(24.4,55.65)
  IN1 w0.203: v2(24.4,55.65) 24.39,55.65 v4(24.15,55.89)
  IN3 w0.203: v5(24.39,55.65) v4(24.15,55.89)
TBT_PERST#: length 5.3
  TOP w0.081: RT287.2 RT190.1 29.92,54.16 30.33,54.57 v1(30.33,54.99) 30.33,56.03 30.39,56.09 v2(30.39,56.1)
  IN1 w0.064: v4(30.33,55.78) 30.33,56.04 v2(30.39,56.1)
  IN3 w0.064: v4(30.33,55.78) 30.33,55.78 30.44,55.67 30.44,54.94 30.24,54.74 v5(30.24,54.35)
TBT_PERST#_R: length 10.9
  TOP w0.081: RT287.1 30.35,52.93 30.95,53.52 30.95,55.52 31.92,56.49 31.92,57.13 v1(31.97,57.18) 31.97,57.38 32.68,58.09 32.68,58.4 32.69,58.41 32.69,58.43 32.98,58.73 33.01,58.73 33.22,58.94 33.22,59.64 33.81,60.23 RT288.1 33.81,61.28 34.14,61.61 UT14.4
TBT_RBIAS: length 1.8
  IN1 w0.064: v2(29.32,55.96) 29.32,56.56 v4(29.27,56.62)
  IN3 w0.064: v5(28.94,57.6) 29.3,57.24 29.3,56.64 v4(29.27,56.62)
TBT_RESET_N: length 57.4
  TOP w0.081: RT121.1 28.48,60.46 28.21,60.73 v2(27.84,60.73)
  IN1 w0.064: v4(28.12,60.28) 27.9,60.28 27.84,60.34 v2(27.84,60.73) 27.78,60.67 27.37,60.67 26.72,60.02 23.37,60.02 22.64,60.75 19.83,60.75 19.25,60.17 19.25,45.15 18.06,43.96 18.06,39.8 22.22,35.64 22.22,33.81 21.86,33.45 21.5,33.45 21.28,33.24 21.28,32.51 21.5,32.3 21.82,32.3 22.24,31.88 22.24,31.87 22.31,31.8 22.31,31.56 22.14,31.38 22.14,31.27 21.68,30.82 21.68,30.82 21.45,30.59 21.45,30.59 21.42,30.56 21.42,30.06 v4(21.91,29.58)
  IN3 w0.064: v4(28.12,60.28) 28.17,60.23 28.3,60.23 28.37,60.16 28.98,60.16 v5(29.59,59.55) ; v5(22.4,26.94) 23.91,26.94 24.84,26.01 25.06,26.01 25.22,26.18 25.22,26.59 23.24,28.57 22.66,28.57 21.91,29.33 v4(21.91,29.58)
  BOTTOM w0.081: RPD124.1 RPD169.1 RPD170.1 22.52,26.48 22.4,26.6 v5(22.4,26.94)
TBT_RESET_N_EC: length 65
  TOP w0.081: UE1.A51 40.34,27.68 v2(40.34,27.69) ; v2(28.27,59.61) 28.02,59.86 RT605.1 RT121.2
  IN1 w0.064: v2(28.27,59.61) 28.2,59.69 28.2,59.69 28.07,59.81 28.07,59.81 28.04,59.84 26.81,59.84 26.8,59.83 23.29,59.83 23.28,59.84 23.18,59.84 22.52,60.5 20.08,60.5 19.47,59.9 19.47,45.07 18.25,43.85 18.25,39.91 22.38,35.78 24.27,35.78 24.61,36.12 25.55,36.12 25.6,36.08 27.04,36.08 27.32,35.8 27.32,34.27 v4(28.25,33.34) ; v2(40.34,27.69) 40.34,27.93 40.18,28.08 39.9,28.08 v4(39.88,28.09)
  IN3 w0.064: v4(39.88,28.09) 39.83,28.14 39.83,29.39 37.29,31.93 36.28,31.93 36.07,31.71 36.07,29.88 35.03,28.84 30.84,28.84 29.79,29.89 29.79,31.79 v4(28.25,33.34)
TBT_ROM_CLK: length 16.3
  TOP w0.081: RT610.1 37.69,52.88 34.92,52.88 v1(33.37,51.33) 32.72,50.68 31.37,50.68 30.67,49.98 28.22,49.98 26.29,51.91 24.78,51.91 24.74,51.96 v2(24.63,51.96)
  IN1 w0.064: v2(24.63,51.96) 24.73,52.05 v4(24.73,52.57)
  IN3 w0.064: v4(24.73,52.57) 24.57,52.57 v5(24.39,52.4)
TBT_ROM_CLK_R: length 4.7
  TOP w0.081: UT2.6 39.87,55.69 40.03,55.52 40.03,54.16 39.55,53.68 38.13,53.68 RT610.2
TBT_ROM_CS#: length 16.6
  TOP w0.081: v2(23.76,53.1) 23.76,53.21 23.97,53.41 24.81,53.41 25.66,52.56 26.73,52.56 26.95,52.34 27.24,52.34 27.59,52.68 27.94,52.68 28.43,53.17 29.19,53.17 29.77,52.59 30.34,52.59 30.43,52.5 30.95,52.5 31.17,52.72 31.17,53.18 31.31,53.32 RT2.1 31.63,55.01 v1(31.93,55.31) 32.25,55.62 32.25,55.96 32.58,56.29 32.58,57.6 33.21,58.23 UT2.1
  IN1 w0.064: v4(23.22,53.05) 23.27,53.1 v2(23.76,53.1)
  IN3 w0.064: v5(23.74,53.05) v4(23.22,53.05)
TBT_ROM_DI: length 19.5
  TOP w0.081: v2(23.6,52.73) 23.64,52.69 23.77,52.69 24.17,52.29 25.01,52.29 25.17,52.13 26.38,52.13 28.31,50.2 30.54,50.2 31.29,50.95 32.54,50.95 v1(34.57,52.99) 34.69,53.11 36.79,53.11 37.63,53.95 39.22,53.95 39.31,54.04 UT2.5
  IN1 w0.064: v4(23.98,52.64) 23.88,52.74 23.61,52.74 v2(23.6,52.73)
  IN3 w0.064: v5(23.74,52.4) v4(23.98,52.64)
TBT_ROM_DO: length 15.3
  TOP w0.081: UT2.2 32.92,56.96 32.8,56.84 32.8,56.12 32.6,55.91 32.6,55.52 32.42,55.34 RT3.1 32.21,53.32 32.11,53.22 32.11,52.38 31.83,52.09 v1(30.67,52.09) 29.97,52.09 29.1,52.96 28.51,52.96 28.02,52.47 27.67,52.47 27.32,52.12 26.69,52.12 26.47,52.35 25.57,52.35 25.36,52.56 24.77,52.56 v2(24.35,52.98)
  IN1 w0.064: v2(24.35,52.98) 24.63,52.98 v4(24.77,53.12)
  IN3 w0.064: v5(24.39,53.05) 24.42,53.08 24.72,53.08 v4(24.77,53.12)
TBT_ROM_HOLD#: length 5.6
  TOP w0.081: RT1.1 39.57,53.37 40.28,54.08 40.28,56.26 39.58,56.96 UT2.7
TBT_ROM_WP#: length 20.6
  TOP w0.081: UT2.3 33.2,55.69 32.66,55.15 32.66,53.61 RT4.1 33.49,53.32 33.86,53.69 36.19,53.69 36.38,53.5 v2(36.39,53.5)
  IN1 w0.064: v4(33.88,57.57) 33.88,57.78 34.53,58.43 35.79,58.43 36.85,57.37 36.85,55.47 36.47,55.09 36.47,53.81 36.38,53.72 36.38,53.5 v2(36.39,53.5)
  IN3 w0.064: v5(30.53,53.41) 30.53,53.43 30.59,53.49 30.59,54.09 33.88,57.38 v4(33.88,57.57)
  BOTTOM w0.081: v5(30.53,53.41) 30.24,53.13 UT1.W4
TBT_RSENSE: length 1.8
  IN1 w0.064: v2(29.91,55.96) 29.91,56.24 v4(29.78,56.37)
  IN3 w0.064: v5(29.84,57.35) 29.84,56.63 29.78,56.58 v4(29.78,56.37)
  BOTTOM w0.081: UT1.J5 v5(29.84,57.35)
TBT_RTD3_WAKE#: length 162
  IN2 w0.066: v4(137.38,60.56) 137.33,60.52 137.33,60.03 137.11,59.8 135.56,59.8 130.9,55.15 130.9,55.09 130.82,55.02 130.82,52.47 130.73,52.38 128.52,52.38 127.92,52.99 126.5,52.99 126.12,53.37 125.31,53.37 124.4,52.46 124.4,51.86 123.53,50.98 123.53,47.21 121.45,45.13 121.45,44.44 120.46,43.45 119.77,43.45 116.9,40.58 116.9,39.1 116.43,38.64 115.09,38.64 114.81,38.36 109.86,38.36 109.63,38.13 109.42,38.13 106.68,35.39 106.68,35.14 106.48,34.94 106.48,34.86 105.74,34.11 105.59,34.11 105.34,33.86 105.08,33.86 104.23,33.02 101.85,33.02 101.36,33.51 101.36,34.13 100.86,34.62 93.02,34.62 92.11,33.71 81.53,33.71 76.64,38.6 71.21,38.6 68.95,40.86 68.26,40.86 60.64,48.48 55.44,48.48 54.27,49.65 52.04,49.65 51.67,50.02 51.67,50.6 51.15,51.12 50.97,51.12 50.59,51.49 50.59,51.86 50.76,52.03 50.76,52.93 48.6,55.09 48.6,59.98 48.15,60.42 48.15,63.4 v4(48.03,63.52) ; v4(41.22,62.26) 40.91,62.26 40.21,61.56 40.21,60.94 38.18,58.91 36.02,58.91 35.35,58.24 35.35,56.36 35.73,55.98 35.73,55.37 36.27,54.83 36.27,53.2 36.34,53.12 v4(36.34,53.02)
  IN3 w0.064: v5(137.51,61.1) 137.38,60.97 v4(137.38,60.56) ; v4(41.22,62.26) 41.61,62.65 43.24,62.65 43.76,63.17 46.21,63.17 46.59,63.54 48.01,63.54 v4(48.03,63.52) ; v5(34.24,51.3) 34.47,51.3 34.75,51.58 35.24,51.58 35.93,52.26 35.93,52.68 36.09,52.84 36.17,52.84 v4(36.34,53.02)
  BOTTOM w0.081: v5(137.51,61.1) 137.6,61.02 137.6,60.66 137.69,60.57 RC58.2 138,60.48 138.67,60.48 138.93,60.22 139.32,60.22 139.5,60.4 140.27,60.4 140.5,60.17 140.5,59.15 140.65,58.99 141.77,58.99 142.07,58.69 143.9,58.69 144.04,58.55 144.04,58.14 144.03,58.13 144.03,57.85 144.04,57.84 144.04,57.77 144.37,57.44 UC1.BV35 ; RT188.2 34.36,51.17 v5(34.24,51.3)
TBT_SRC_HPD: length 34.6
  TOP w0.081: CM52.1 29.05,54.82 RT184.1 29.23,54.53 29.31,54.45 v2(29.52,54.45) ; RM10.2 21.07,36.01 v2(21.11,35.96)
  IN1 w0.064: v2(21.11,35.96) v4(21.11,35.62) ; v4(29.19,54.6) 29.34,54.45 v2(29.52,54.45)
  IN2 w0.066: v4(21.11,35.62) 23.82,35.62 24.9,36.7 31.02,36.7 32.01,37.69 32.01,38.91 29.15,41.76 29.15,48.58 27,50.73 27,52.4 v4(29.19,54.6)
  IN3 w0.064: v4(29.19,54.6) v5(29.59,55)
TBT_SRC_HPD_R: length 2.3
  TOP w0.081: RM10.1 21.07,37.18 21.7,37.81 21.85,37.81 22.11,38.08 UM1.46
TBTA_CC1: length 62.1
  TOP w0.254: 13,67.64 DT40.6 v2(14.75,67.64)
  TOP w0.305: v2(12.49,67.14) 13,67.64
  IN1 w0.305: v2(14.75,67.64) 14.88,67.64 15.19,67.34 15.19,66.91 14.74,66.46 13.94,66.46 12.6,65.12 12.6,64.49 13.65,63.44 13.65,60.37 14.39,59.63 14.39,57.01 15.08,56.32 15.08,47.16 14.53,46.61 14.53,44.42 14.93,44.03 15.53,44.03 16.01,43.54 16.01,36.05 15.33,35.37 14.92,35.37 14.17,34.62 14.17,31.45 14.55,31.08 14.55,29.63 v4(15.83,28.35) ; v2(12.49,67.14) 12.56,67.08 12.56,66.32 11.81,65.57 10.62,65.57 10.42,65.38 v6(10.21,65.38)
  IN3 w0.305: v5(20.6,27.49) 20.91,27.8 20.91,28.23 20.45,28.69 20.1,28.69 19.52,29.26 17.75,29.26 16.84,28.35 v4(15.83,28.35)
  BOTTOM w0.203: UPD1.24 20.42,27.68
  BOTTOM w0.254: CPD3.1 22.02,26.09 22.02,26.76 21.64,27.13 20.96,27.13 v5(20.6,27.49) 20.42,27.68 ; v6(10.21,65.38) JUSBC1.A5
TBTA_CC2: length 63.5
  TOP w0.203: v2(14.75,67.14) v1(15.77,67.14)
  TOP w0.254: v2(13.11,67.14) DT40.7 v2(14.75,67.14)
  IN1 w0.305: v6(8.5,66.79) 8.8,66.79 10.03,68.01 12.76,68.01 13.07,67.71 13.07,67.19 v2(13.11,67.14) ; v4(15.82,27.59) 13.92,29.49 13.92,31.04 13.72,31.24 13.72,34.83 14.73,35.84 15.14,35.84 15.57,36.27 15.57,43.23 15.24,43.57 14.74,43.57 14.04,44.27 14.04,47.01 14.65,47.62 14.65,56.14 13.96,56.83 13.96,58.12 12.69,59.39 12.69,59.79 13.22,60.32 13.22,63.16 12.09,64.28 12.09,65.24 12.28,65.43 12.28,65.43 13.99,67.14 v2(14.75,67.14)
  IN3 w0.305: v5(19.48,27.43) 19.65,27.59 19.65,28.43 19.25,28.83 18.47,28.83 17.23,27.59 v4(15.82,27.59)
  BOTTOM w0.203: UPD1.26 19.62,27.58
  BOTTOM w0.254: 19.62,27.58 19.48,27.45 v5(19.48,27.43) 19.4,27.35 19.4,26.25 18.99,25.84 CPD2.1 ; JUSBC1.B5 8.3,66.62 8.47,66.79 v6(8.5,66.79)
TBTA_HPD: length 50.2
  IN2 w0.066: v4(28.31,51.67) 28.31,50.64 29.73,49.22 29.73,42 32.77,38.97 32.77,37.44 31.45,36.12 25.14,36.12 23.65,34.63 21.35,34.63 19.8,33.08 19.8,32.36 17.12,29.68 v4(16.57,29.68)
  IN3 w0.064: v4(28.31,51.67) 28.36,51.67 28.61,51.43 28.98,51.43 29.23,51.67 29.69,51.67 29.91,51.89 31.01,51.89 31.63,52.51 32.49,52.51 33.11,53.12 33.69,53.12 33.86,52.95 34.76,52.95 34.86,53.05 v5(34.86,53.06) ; v4(16.57,29.68) 16.29,29.4 v5(16.12,29.4)
  BOTTOM w0.081: v5(34.86,53.06) 34.98,53.18 34.98,53.91 34.89,54 34.13,54 34.01,53.87 RT23.1 34.01,53.53 33.87,53.39 32.81,53.39 31.98,54.22 31.09,54.22 30.94,54.37 UT1.T2 ; RPD126.1 16.17,29.34 v5(16.12,29.4)
TBTA_HPD_R: length 1.2
  BOTTOM w0.081: RPD126.2 17.05,29.34 17.2,29.49 UPD1.30
TBTA_I2C_INT#: length 55.7
  TOP w0.081: v2(20.23,59.58) 20.68,59.58 20.69,59.57 20.7,59.57 20.71,59.56 RT16.1
  IN1 w0.064: v4(19.9,59.58) v2(20.23,59.58)
  IN2 w0.066: 25.97,53.49 26.22,53.74 27.11,53.74 29.29,55.91 29.86,55.91 30.38,56.43 30.38,56.54 v4(30.29,56.62) ; 25.97,53.49 26.77,52.69 26.77,50.49 28.96,48.3 28.96,41.68 31.02,39.62 31.02,37.37 30.54,36.89 24.82,36.89 23.91,35.98 20.69,35.98 20.56,35.85 19.5,35.85 19.1,35.46 19.1,32.97 18.88,32.75 16.56,32.75 16.27,32.46 v4(16.27,32.22) ; 25.97,53.49 25.74,53.72 24.43,53.72 24.23,53.53 23.57,53.53 22.71,54.39 21.66,54.39 19.78,56.26 19.78,59.52 19.85,59.58 v4(19.9,59.58)
  IN3 w0.064: v5(30.24,56.3) 30.24,56.57 v4(30.29,56.62) ; v4(16.27,32.22) v5(16.27,31.88)
  BOTTOM w0.081: RPD112.2 16.07,31.67 v5(16.27,31.88)
TBTA_USB2_RBIAS: length 2.4
  TOP w0.081: RT41.2 21.16,58.1 21.59,58.1 v2(21.73,58.23)
  IN1 w0.064: v2(21.73,58.23) 21.95,58.45 v4(22.01,58.45)
  IN3 w0.064: v5(23.09,58.25) 22.77,58.57 22.13,58.57 v4(22.01,58.45)
TBTB_HPD: length 1.9
  BOTTOM w0.081: UT1.T1 32.03,54.46 32.79,53.7 RT33.1
TDOCK_BATLOW#: length 2.5
  BOTTOM w0.081: RT20.1 32.82,52.86 31.91,53.78 31.12,53.78 30.94,53.96 UT1.U2
TEMP: length 35.3
  TOP w0.254: PUV01.8 40.11,61.41 40.77,60.75 40.86,60.75 41.09,60.52 PCV46.1 v2(41.91,60.34)
  IN1 w0.254: v4(42.5,61.88) 42.42,61.8 42.42,60.85 v2(41.91,60.34)
  IN3 w0.254: v4(42.5,61.88) 43.31,61.88 43.38,61.95 45.86,61.95 45.91,62 48.73,62 49.81,63.08 49.81,66.46 50.06,66.72 53.4,66.72 54.9,68.22 54.9,69.51 ; 54.9,69.51 56.34,69.51 56.92,70.1 56.92,74.79 56.34,75.37 54.57,75.37 53.91,76.02 v5(53.82,76.02) ; 54.9,69.51 54.45,69.51 53.73,68.79 v5(53.73,68.67)
TEMP_CPU: length 4
  BOTTOM w0.203: PRZ34.1 155.75,17.3 ; 155.75,17.3 155.34,17.3 PCZ07.1 154.77,18.13 155.25,18.62 PUZ01.45 ; 155.75,17.3 PRZ33.1
TEST_PWRGD: length 2.7
  TOP w0.081: v1(28.62,52.58) 28.59,52.54 v2(28.59,52.2) 28.59,51.59 RT36.1
  IN1 w0.064: v4(29.3,52.9) 28.99,52.9 28.72,52.62 28.72,52.59 28.59,52.46 v2(28.59,52.2)
  IN3 w0.064: v4(29.3,52.9) 29.44,52.9 v5(29.59,53.05)
THM_SML1_CLK: length 146.4
  TOP w0.081: Q11.4 36.1,69.58 R50.2 36.31,69.61 36.73,70.03 36.73,71.47 36.98,71.72 v2(37.49,71.72) ; v1(134.53,42.88) 133.78,43.63 v2(133.78,44.44)
  IN1 w0.064: v2(37.49,71.72) 38.01,71.2 39.11,71.2 40.39,69.92 40.39,68.77 41.72,67.44 41.72,66.41 42.88,65.25 45.95,65.25 46.38,64.82 46.38,64.07 47.76,62.69 47.76,55.18 44.87,52.29 44.87,49.17 46.51,47.53 46.51,41.9 49.07,39.33 49.67,39.33 51.9,37.1 57.77,37.1 58.52,36.35 70.21,36.35 71.01,35.55 74.26,35.55 74.69,35.98 79.53,35.98 83.29,32.22 86.07,32.22 86.78,31.51 91.53,31.51 91.96,31.93 97.18,31.93 98.87,33.62 v4(99.12,33.62) ; v4(133.56,44.18) 133.78,44.4 v2(133.78,44.44)
  IN3 w0.064: v4(99.12,33.62) 99.63,34.13 100.99,34.13 101.26,33.86 101.26,32.9 101.69,32.48 105.02,32.48 105.66,31.84 106.77,31.84 107.67,32.75 108.47,32.75 109.37,31.84 110.77,31.84 113.89,34.97 113.89,36.81 114.67,37.59 115.48,37.59 116.18,38.29 116.59,38.29 116.88,38.58 117.58,38.58 118.61,39.61 118.61,40.16 119.49,41.04 120.05,41.04 121.35,42.35 124.27,42.35 125.07,43.15 129.39,43.15 129.4,43.15 129.65,43.15 129.94,43.44 132.82,43.44 v4(133.56,44.18)
THM_SML1_DATA: length 142.8
  TOP w0.081: v2(34.34,71.62) 34.34,71.12 34.09,70.88 Q11.1 32.96,70.88 31.7,69.61 R49.2 31.1,69.34 v1(30.85,69.6)
  IN1 w0.064: v4(132.89,44.2) v2(133.13,44.44) ; v2(34.34,71.62) 34.34,72.01 v4(34.46,72.13) ; v4(117.45,38.99) 117.45,39.21 116.51,40.15 115.74,40.15 115.56,39.97 113.51,39.97 113.39,40.09 112.84,40.09 112.66,40.27 112.59,40.27 112.13,40.73 110,40.73 109.54,41.19 108.98,41.19 108.8,41.01 105.11,41.01 101.94,37.84 101.94,37.48 99.34,34.87 99.34,34.54 97.05,32.25 91.43,32.25 91.31,32.13 90.6,32.13 90.3,31.82 86.92,31.82 86.2,32.54 85.94,32.54 85.94,32.54 83.53,32.54 79.74,36.33 74.55,36.33 74.25,36.64 70.55,36.64 70.36,36.83 60.46,36.83 59.52,37.77 53.49,37.77 48.11,43.16 48.11,46.51 47.52,47.1 47.52,52.74 48.39,53.61 48.39,63.71 46.34,65.76 45.42,65.76 42.57,68.61 41.62,68.61 41.22,69 41.22,69.81 38.78,72.25 37.26,72.25 37.21,72.2 v4(37.2,72.2)
  IN3 w0.064: v4(37.2,72.2) 36.83,72.57 35.52,72.57 35.07,72.13 v4(34.46,72.13) ; v4(132.89,44.2) 132.87,44.2 132.57,43.89 129.81,43.89 129.38,43.47 129.27,43.47 129.26,43.47 124.93,43.47 124.81,43.34 124.71,43.34 124.03,42.67 121.22,42.67 119.91,41.36 119.36,41.36 118.29,40.29 118.29,39.75 117.53,38.99 v4(117.45,38.99)
TMDS_CFG0: length 1.2
  IN1 w0.064: v2(19.89,42.2) v4(20.25,42.2)
  BOTTOM w0.081: RM44.2 21.36,41.92 RM46.1 21.33,41.52 v5(21.04,41.52)
TMDS_CFG1: length 8.4
  TOP w0.081: UM1.50 23.71,37.69 v2(23.64,37.63) 23.23,37.22 RM47.1 23.23,37.05 RM45.2 ; RM60.1 19.23,38.67 v2(20.02,38.67)
  IN1 w0.064: v2(20.02,38.67) 20.21,38.67 v4(20.49,38.39) ; v4(24,37.61) 23.98,37.63 v2(23.64,37.63)
  IN3 w0.064: v4(24,37.61) 22.74,37.61 22.55,37.8 21.08,37.8 v4(20.49,38.39)
TMDS_T_TX0N: length 2.4
  TOP w0.066: LI2.2 18.04,42.61 18.66,42.61 18.96,42.91 19.32,42.91 19.42,43 UM1.33
TMDS_T_TX0N_R: length 17.4
  TOP w0.066: LI2.1 16.49,42.61 15.76,42.61 RI4.1 14.7,42.25 14.58,42.25 v6(14.4,42.43)
  BOTTOM w0.066: JHDMI1.9 11.72,42.59 11.82,42.59 12.05,42.82 12.05,48.15 12.32,48.43 13.09,48.43 13.68,47.84 13.68,42.45 13.88,42.24 14.21,42.24 v6(14.4,42.43)
TMDS_T_TX0P: length 2.4
  TOP w0.066: LI2.3 18.04,42.41 18.75,42.41 19.04,42.7 19.33,42.7 19.43,42.6 UM1.34
TMDS_T_TX0P_R: length 17.3
  TOP w0.066: LI2.4 16.49,42.41 15.76,42.41 RI4.2 14.6,42.05 v6(14.4,41.85)
  BOTTOM w0.066: JHDMI1.7 11.31,42.3 11.39,42.38 11.9,42.38 12.25,42.74 12.25,48.07 12.41,48.22 13.01,48.22 13.47,47.76 13.47,42.36 13.8,42.04 14.21,42.04 v6(14.4,41.85)
TMDS_T_TX1N: length 2.5
  TOP w0.066: UM1.36 19.45,41.8 19.35,41.71 18.98,41.71 18.26,40.98 18.04,40.98 LI4.2
TMDS_T_TX1N_R: length 4.4
  TOP w0.066: LI4.1 16.49,40.98 15.76,40.98 RI10.1 15.03,40.96 13.67,40.96 13.53,41.1 13.26,41.1 JHDMI1.6
TMDS_T_TX1P: length 2.5
  TOP w0.066: UM1.37 19.43,41.4 19.33,41.5 19.06,41.5 18.34,40.78 18.04,40.78 LI4.3
TMDS_T_TX1P_R: length 4.3
  TOP w0.066: JHDMI1.4 13.26,40.9 13.45,40.9 13.59,40.76 v7(14.12,40.76) 15.08,40.76 RI10.2 15.76,40.78 16.49,40.78 LI4.4
TMDS_T_TX2N: length 3.2
  TOP w0.066: LI3.2 18.08,39.32 18.34,39.32 18.44,39.42 18.44,40.1 18.84,40.51 19.36,40.51 19.45,40.6 UM1.39
TMDS_T_TX2N_R: length 6.3
  TOP w0.066: LI3.1 16.5,39.36 15.76,39.36 RI9.1 15.05,39.36 14.36,39.36 v7(14.14,39.15) 13.87,38.88 12.66,38.88 11.93,39.61 11.7,39.61 JHDMI1.3
TMDS_T_TX2P: length 3.1
  TOP w0.066: LI3.3 18,39.12 18.42,39.12 18.64,39.34 18.64,40.02 18.93,40.3 19.33,40.3 19.42,40.2 UM1.40
TMDS_T_TX2P_R: length 6.4
  TOP w0.066: JHDMI1.1 11.72,39.41 11.85,39.41 12.58,38.67 13.96,38.67 14.44,39.16 15.05,39.16 RI9.2 15.77,39.16 16.49,39.16 LI3.4
TMDS_T_TXCN: length 2.3
  TOP w0.066: UM1.30 19.43,44.2 19.34,44.11 18.84,44.11 18.71,44.24 18.04,44.24 LI1.2
TMDS_T_TXCN_R: length 4.4
  TOP w0.066: LI1.1 16.49,44.24 15.76,44.24 RI3.1 15.05,44.24 14.79,44.24 14.65,44.1 v7(14,44.1) 13.26,44.1 JHDMI1.12
TMDS_T_TXCP: length 2.3
  TOP w0.066: UM1.31 19.41,43.8 19.31,43.9 18.75,43.9 18.62,44.03 18.04,44.03 LI1.3
TMDS_T_TXCP_R: length 4.4
  TOP w0.066: JHDMI1.10 13.26,43.9 14.74,43.9 14.87,44.03 15.05,44.03 RI3.2 15.76,44.03 16.49,44.03 LI1.4
TOUCH_PAD_INT#: length 10
  TOP w0.081: RC5.2 135.56,56.19 DZ1.2 135.12,56.19 v2(135.12,56.63)
  IN1 w0.064: v4(142.19,56.44) 142.19,56.38 142.11,56.3 140.67,56.3 139.75,57.22 138.61,57.22 138.41,57.03 137.56,57.03 137.04,56.5 135.25,56.5 v2(135.12,56.63)
  IN3 w0.064: v5(141.85,56.69) 141.97,56.69 142.19,56.47 v4(142.19,56.44)
TOUCH_PANEL_PD#: length 204.3
  TOP w0.081: v2(13.87,70.31) R6908.2 ; v2(135.33,36.91) 135.02,36.91 RC6.2 ; v2(50.63,48.28) 50.73,48.28 51.9,47.11 v1(51.9,46.83) 51.9,46.23 52.83,45.3 52.83,42.39 51.85,41.41 51.85,41.12 51.55,40.82 49.89,40.82 49.79,40.71 49.79,39.76 48.84,38.81 v6(47.51,38.81)
  IN1 w0.064: v4(50.99,48.62) 50.66,48.28 v2(50.63,48.28) ; v4(135.63,36.78) 135.5,36.91 v2(135.33,36.91) ; v2(13.87,70.31) 15.36,70.31 v4(16.03,69.64)
  IN2 w0.066: v6(47.51,38.81) 47.68,38.98 50.48,38.98 52.1,37.36 55.36,37.36 64.15,28.56 64.15,27.37 64.15,27.36 64.15,27.35 64.08,27.28 64.08,26.82 64.09,26.81 64.09,25.54 64.39,25.24 64.39,25.23 64.54,25.08 64.54,22.41 67.08,19.88 67.3,19.88 72.44,14.73 75.35,14.73 76.07,14.01 83.79,14.01 85.13,12.67 95.34,12.67 95.52,12.85 96.37,12.85 96.71,13.19 96.71,13.46 97.22,13.97 98.6,13.97 99.32,14.68 111.17,14.68 111.61,14.25 119.08,14.25 122.5,17.66 123.12,17.66 123.23,17.78 124.89,19.44 124.89,21.27 126.38,22.76 127.94,22.76 128.16,22.54 129.78,22.54 130.01,22.78 130.01,25.1 131.93,27.02 135.39,27.02 136.44,28.07 136.44,29.94 136.33,30.05 136.33,35.51 135.63,36.21 v4(135.63,36.78) ; v4(16.03,69.64) 18.63,69.64 19.22,69.05 20.2,69.05 20.53,69.38 20.53,70.23 20.28,70.47 20.28,73.19 22.01,74.92 24.94,74.92 25.4,74.46 26.03,74.46 26.61,73.88 29.07,73.88 31.45,76.25 40.09,76.25 44.3,72.05 44.3,68.66 46.77,66.18 47.03,65.93 47.03,63.46 47.39,63.1 47.39,60.11 48.02,59.49 48.02,54.85 49.48,53.4 49.48,51.79 50.49,50.78 50.49,50.08 50.99,49.58 v4(50.99,48.62)
  IN3 w0.064: v5(136,36.99) 135.85,36.99 v4(135.63,36.78)
TOUCH_PANEL_PD#_R: length 20.1
  TOP w0.081: D465.2 15.06,69.8 D464.2 ; D464.2 15.22,70.51 v1(16.18,69.55) ; D464.2 15.06,70.7 v2(14.45,71.31)
  IN1 w0.064: v2(14.45,71.31) v4(14.45,70.78)
  IN3 w0.064: v5(2.39,74.45) 3.9,72.94 7.11,72.94 8.17,71.88 11.52,71.88 12.62,70.78 v4(14.45,70.78) 15.05,70.18 v5(15.05,70)
TOUCH_SCREEN_INT#: length 192.1
  TOP w0.081: v2(88.87,25.86) v1(88.87,24.86) 88.87,24.11 88.29,23.53 88.29,15.12 v2(88.39,15.02) ; RC203.2 137.35,42.12 v2(137.35,41.95)
  IN1 w0.064: v2(88.39,15.02) 88.46,14.95 88.74,14.95 v4(88.8,14.89) ; v2(137.35,41.95) v4(136.95,41.95) ; v2(88.87,25.86) 88.55,25.86 85.47,28.94 79.92,28.94 79.21,29.65 79.21,31.37 v4(79.86,32.03)
  IN2 w0.066: v4(22.85,73.78) 23.33,73.78 24.52,72.58 28.78,72.58 29.37,73.18 30.17,73.18 31.1,74.11 31.1,74.56 31.64,75.1 32.12,75.1 32.78,75.76 40.04,75.76 43.91,71.89 43.91,68.5 46.64,65.77 46.64,63.3 47.01,62.94 47.01,58.98 47.63,58.35 47.63,54.41 49.09,52.95 49.09,51.63 50.1,50.62 50.1,49.92 50.61,49.42 50.61,49.02 50.44,48.85 50.44,47.97 50.76,47.65 51.23,47.65 52.62,46.25 60.95,46.25 61.13,46.07 61.24,45.96 61.35,45.96 64.93,42.38 64.93,41.18 67.55,38.56 69.14,38.56 71.15,36.55 75.85,36.55 77.33,35.07 77.33,32.9 78.01,32.21 79.68,32.21 v4(79.86,32.03) ; v4(88.8,14.89) 88.8,14.86 88.76,14.82 88.76,14.09 89.21,13.64 91.72,13.64 92.96,14.88 111.25,14.88 111.69,14.44 118.32,14.44 118.37,14.49 118.62,14.49 121.99,17.86 123.04,17.86 124.7,19.52 124.7,21.35 126.3,22.95 128.02,22.95 128.24,22.74 129.64,22.74 129.82,22.91 129.82,25.18 131.85,27.22 135.31,27.22 136.25,28.15 136.25,29.86 136.12,29.99 136.12,35.45 134.7,36.87 134.7,39.61 135.67,40.58 135.67,41.49 136.08,41.9 136.73,41.9 136.78,41.95 v4(136.95,41.95)
  IN3 w0.064: v4(22.85,73.78) 21.07,73.78 v5(20.85,74) ; v4(136.95,41.95) 136.78,41.95 v5(136.65,42.09)
  BOTTOM w0.081: UC1.CM12 136.63,42.47 136.63,42.12 136.65,42.11 v5(136.65,42.09)
TOUCH_SCREEN_RST#: length 185.4
  TOP w0.081: R88.2 41.85,51.93 41.97,51.81 42.1,51.81 v2(42.11,51.82) ; v2(119.53,37.55) v1(119.13,37.95) 118.76,38.32 110.94,38.32 110.69,38.57 v2(110.3,38.57)
  IN1 w0.064: v4(123.23,37.01) 123.14,36.92 120.16,36.92 v2(119.53,37.55) ; v2(42.11,51.82) 42.15,51.86 v4(42.15,52.25) ; v2(110.3,38.57) 109.6,38.57 108.94,37.91 v4(108.49,37.91)
  IN2 w0.066: v4(15.13,71.67) 15.13,70.47 15.51,70.09 18.68,70.09 19.67,71.08 19.67,73.86 24.05,78.23 29.74,78.23 30.98,76.99 40.17,76.99 44.88,72.29 44.88,68.9 47.61,66.17 47.61,64.5 48.39,63.71 48.39,60.69 49.53,59.55 49.53,57.84 48.86,57.16 48.86,55.11 50.96,53.01 v4(50.96,51.64) 50.96,51.59 51.6,50.94 51.88,50.94 52.92,49.9 54.44,49.9 55.55,48.8 60.6,48.8 68.22,41.18 69.03,41.18 71.39,38.81 76.81,38.81 81.68,33.95 92.08,33.95 92.94,34.82 100.94,34.82 101.55,34.21 101.55,33.59 101.93,33.21 104.15,33.21 105,34.05 105.26,34.05 105.51,34.3 105.66,34.3 106.1,34.74 106.1,35.36 106,35.46 106,36.05 107.07,37.12 107.82,37.12 108.49,37.78 v4(108.49,37.91) ; v4(140.6,51.55) 140.4,51.35 139.97,51.35 139.63,51.68 138.8,51.68 138.16,51.04 137.12,51.04 136.76,50.68 136.12,50.68 135.16,49.72 135.16,49.17 134.34,48.35 133.65,48.35 133.18,47.88 133.18,47.56 128.76,43.14 127.61,43.14 123.23,38.76 v4(123.23,37.01)
  IN3 w0.064: v5(141.46,52.07) 140.94,51.55 v4(140.6,51.55) ; v4(15.13,71.67) 15.13,72.32 v5(15.05,72.4) ; v4(50.96,51.64) 50.87,51.56 49.56,51.56 48.04,53.08 45.76,53.08 45.3,52.89 44.21,51.81 43.11,51.81 42.84,52.07 42.33,52.07 v4(42.15,52.25)
TOUCHPAD_INTR#: length 191.5
  TOP w0.081: DZ1.1 133.64,55.87 v2(133.19,55.42) ; UE1.B13 v2(47.98,20.12) ; v2(122.99,56.28) 122.99,56.06 122.99,55.71 123.53,55.18 123.53,54 124.61,52.92 124.61,51.64 123.73,50.77 123.73,43.75 125.76,41.73 125.76,37.3 124.68,36.22 122.77,36.22 122.07,35.52 120.2,35.52 119.93,35.26 119.93,32.24 122.94,29.23 v1(122.94,18.44) 122.94,14.68 121.61,13.35 v2(121.61,11.34)
  IN1 w0.064: v2(47.98,20.12) 47.98,18.33 46.54,16.89 45.95,16.89 45.7,16.64 45.39,16.64 45.33,16.58 45.33,16.46 v2(45.28,16.4) 45.26,16.42 45.09,16.42 44.83,16.15 v4(44.83,15.9) ; v2(121.61,11.34) 121.62,11.33 122.09,11.33 122.41,11.01 122.41,10.87 122.32,10.78 122.32,10.78 122.11,10.57 118.94,7.39 118.25,7.39 117.72,7.39 117.72,7.39 117.48,7.39 117.48,7.39 117.35,7.39 v2(117,7.04) 117.05,6.99 117.2,6.99 v4(117.63,6.57) ; v2(133.19,55.42) 133.12,55.35 132.63,55.35 131.09,56.89 130.31,56.89 129.38,57.82 129.38,60.84 128.3,61.92 128.3,63.7 127.62,64.38 127.62,67.29 127.38,67.54 125.93,67.54 125.84,67.45 125.84,65.3 124.09,63.54 124.09,63.33 123.55,62.79 123.55,62.33 122.23,61.01 122.23,58.04 122.49,57.78 122.99,57.28 v2(122.99,56.28)
  IN2 w0.066: v4(39.75,9.43) 39.75,9.29 40.5,8.54 44.38,8.54 45.07,9.22 45.98,9.22 47.92,7.28 52.93,7.28 56.18,4.03 98.77,4.03 99.28,4.54 101.03,4.54 101.56,4 114.77,4 117.34,6.57 v4(117.63,6.57)
  IN3 w0.064: v4(44.83,15.9) 44.38,15.45 44.38,14.5 44.66,14.21 44.66,12.82 43.3,11.46 41.37,11.46 39.7,9.78 39.7,9.48 v4(39.75,9.43)
TP_EN#: length 114.3
  TOP w0.081: RE542.1 40.87,31.45 41.57,30.76 41.57,30.24 41.48,30.16 41.48,29.81 v2(41.02,29.35) 41.02,29.29 UE1.B52
  IN1 w0.064: v2(41.02,29.35) 41.05,29.33 41.05,29.19 41.81,28.43 42.11,28.43 44.35,26.19 44.35,24.38 41.71,21.74 41.71,20.95 41.4,20.64 40.91,20.64 39.84,19.57 38.95,19.57 38.05,18.67 38.05,17.22 37.54,16.72 37.54,15.19 38.64,14.1 38.64,11.94 39.88,10.7 39.88,10.69 41.11,9.46 42.9,9.46 43.19,9.17 45.55,9.17 46.38,8.35 48.92,8.35 49.33,7.93 49.36,7.93 49.37,7.93 49.67,7.93 49.67,7.93 50,7.93 51.05,6.88 51.48,6.88 52.3,6.06 52.3,5.52 52.72,5.1 52.97,5.1 53.21,4.85 99.08,4.85 99.53,5.3 100.72,5.3 101.1,5.68 109.22,5.68 109.35,5.81 111.06,5.81 113.16,7.9 113.69,7.9 113.7,7.91 114.28,7.91 114.28,7.91 115.91,7.91 116.8,8.79 118.32,8.79 119.68,10.15 v2(119.68,11.53)
TP_EN#_R: length 7
  TOP w0.081: R41.2 119.08,11.54 C23.2 118.5,11.84 118.38,11.96 117.17,11.96 116.91,11.7 116.91,10.37 117.15,10.14 117.51,10.14 117.61,10.04 Q5.5 Q5.2
TP_LOCK#: length 17
  TOP w0.081: D5.2 121.54,9.29 121.6,9.35 R46.2 121.63,9.67 121.63,10.91 v2(121.6,10.94) 121.69,10.94 122.03,11.28 122.03,11.88 v1(122.29,12.13)
  IN1 w0.064: v2(121.6,10.94) 121.6,10.93 v4(121.96,10.93)
  IN3 w0.064: v4(121.96,10.93) 121.93,10.96 v5(121.57,10.96)
  BOTTOM w0.081: v5(121.57,10.96) 121.62,11.01 121.62,12.45 123.08,13.91 126.95,13.91 128.07,12.79 130.15,12.79 130.53,12.41 130.53,11.47 JTP1.3
TYPEC_SMBCLK: length 90.9
  TOP w0.081: RM31.2 v2(14.53,72.49) ; Q30.6 37.52,31.84 37.26,31.59 v2(36.94,31.59) 36.22,31.59 36.04,31.77 36.04,33.06 36.59,33.61 v1(37.24,33.61) 37.76,33.61 38.2,33.17 38.78,33.17 39.66,32.29 RE531.1
  IN1 w0.064: v2(14.53,72.49) 14.55,72.5 15.28,72.5 16.93,70.86 16.93,67.02 14.28,64.37 14.09,64.18 14.09,60.56 14.83,59.81 14.83,57.19 15.55,56.47 15.55,44.91 16.63,43.82 16.63,38.93 17.33,38.23 17.33,36.43 16.39,35.49 16.39,33.61 16.75,33.25 16.75,30.42 16.98,30.19 16.98,28.81 16.86,28.69 16.86,26.38 v4(16.91,26.33) ; v4(36.86,31.13) 36.86,31.38 36.94,31.46 v2(36.94,31.59)
  IN3 w0.064: v4(16.91,26.33) 17.14,26.1 17.89,26.1 17.96,26.17 18.59,26.17 v5(18.69,26.27) 19.13,25.82 24.31,25.82 24.88,25.25 28.27,25.25 31.02,22.51 35.63,22.51 37.89,24.77 37.89,25.83 38.38,26.32 38.38,26.42 37.34,27.46 37.34,29.63 37.03,29.93 37.03,30.96 v4(36.86,31.13)
  BOTTOM w0.089: v5(18.69,26.27) 18.69,26.39 RPD163.2
TYPEC_SMBDA: length 86
  TOP w0.081: RM37.2 v2(14.51,73.04) ; Q30.3 38.61,32.54 38.49,32.66 v2(38.49,32.81)
  IN1 w0.064: v4(17.44,26.62) 17.3,26.76 17.3,28.51 17.41,28.61 17.41,30.45 17.11,30.75 17.11,34 16.85,34.26 16.85,35.32 17.77,36.24 17.77,38.41 16.98,39.21 16.98,44.08 16.08,44.98 16.08,56.39 15.15,57.32 15.15,59.95 14.41,60.69 14.41,64.05 17.25,66.89 17.25,70.99 15.41,72.82 15.19,72.82 15.19,72.82 14.97,72.82 14.97,72.83 14.73,72.83 v2(14.51,73.04) ; v2(38.49,32.81) 38.49,32.77 38.6,32.66 38.6,32.06 38.54,32 37.84,32 37.49,32.35 36.73,32.35 v2(36.4,32.02) 36.49,31.94 v4(36.49,31.56)
  IN3 w0.064: v4(36.49,31.56) 36.41,31.49 36.41,28.19 36.99,27.61 36.99,27.17 37.42,26.74 37.42,24.75 35.5,22.82 31.15,22.82 28.41,25.57 25.01,25.57 24.4,26.18 19.26,26.18 18.83,26.6 v5(17.93,26.6) 17.87,26.54 17.52,26.54 v4(17.44,26.62)
  BOTTOM w0.081: v5(17.93,26.6) 18,26.67 RPD164.2
UG1_CHG: length 24.5
  IN3 w0.762: 189.04,7.49 189.94,8.39 193.48,8.39 194,8.91 194,16.39 196.24,18.63 196.24,20.71
  BOTTOM w0.762: v5(188.94,6.24) v5(188.94,6.98) 188.94,9.13 189.57,9.77 189.57,11.27 190.23,11.92 PQB01.1
  vias: v5(196.91,21.84) v5(196.9,21.49)
UG2_CHG: length 7.3
  IN3 w0.762: 199.76,23.66 199.76,21.56 200.58,20.75 201.99,20.75 203.3,19.44
  BOTTOM w0.203: PUB01.5 v5(198.77,23.67) v5(199.15,23.67)
  vias: v5(203.55,18.45) v5(203.64,18.9)
UIM_CLK: length 4.5
  TOP w0.081: v1(59.84,49.48) 59.62,49.71 CS1.1 58.76,49.71 58.74,49.69 v2(58.44,49.69)
  IN1 w0.064: v2(58.44,49.69) 58.2,49.45 57.72,49.45 57.51,49.65 v4(57.51,50.53)
  IN3 w0.064: v5(57.51,49.53) v4(57.51,50.53)
UIM_CLK_R: length 96.8
  TOP w0.081: v2(23.85,4.67) 23.93,4.75 DS1.9 DS1.1 26.28,4.75 26.3,4.78 27.11,4.78 27.52,5.18 28.07,5.18 v2(28.45,5.56) ; v6(45.33,32.77) 45.38,32.77 46.23,33.62 46.23,34.74 50.63,39.14 50.63,39.57 52.06,41 52.06,41.22 53.65,42.82 54.87,42.82 56.97,44.91 58.06,44.91 58.57,45.42 58.57,46.6 v1(58.2,46.97) 58.09,47.08 58.09,48.32 58.23,48.46 CS6.1 58.45,48.82 58.44,48.82 RN192.2
  IN1 w0.064: v2(28.45,5.56) 28.21,5.8 28.21,7.01 30.94,9.74 30.94,11.78 30.1,12.63 30.1,19.44 30.09,19.45 30.09,19.61 29.1,20.59 29.1,22.58 29.44,22.92 29.44,23.78 29.44,23.79 29.44,27.63 30.61,28.8 30.61,29.54 v4(30.95,29.89) ; v2(23.85,4.67) 24.19,5.01 24.19,7.45 22.65,8.99 16.75,8.99 16.63,8.86 6.77,8.86 v2(5.78,9.85)
  IN3 w0.064: v4(30.95,29.89) 31.38,30.31 33.07,30.31 33.71,29.68 34.2,29.68 35,30.48 35,31.17 35.94,32.12 37.37,32.12 38.57,30.91 40.26,30.91 40.55,31.2 41.2,31.2 41.91,30.49 44.03,30.49 44.98,31.45 44.98,32.37 45.3,32.69 45.3,32.74 45.33,32.77 v6(45.33,32.77)
UIM_DATA: length 99.7
  TOP w0.081: v2(23.85,6.25) DS1.7 DS1.4 25.69,6.25 v2(25.98,5.96) ; v6(46.1,32.89) 46.18,32.97 46.18,33.26 46.45,33.53 46.45,34.65 50.84,39.04 50.84,39.33 v1(50.99,39.48) 52.27,40.76 52.27,41.13 53.73,42.6 54.95,42.6 57.05,44.69 58.14,44.69 59.08,45.63 CS36.1 CS38.1 RS2.2 59.08,47.21 59.43,47.56 v2(59.43,47.56)
  IN1 w0.064: v2(6.93,10.75) 6.1,10.75 5.41,10.07 5.41,9.44 6.44,8.41 16.55,8.41 16.93,8.8 22.5,8.8 23.85,7.44 v2(23.85,6.25) ; v4(59.32,48.07) 59.43,47.97 v2(59.43,47.56) ; v2(25.98,5.96) 26.06,5.88 27.34,5.88 27.87,6.42 27.87,7 30.7,9.83 30.7,11.67 29.9,12.47 29.9,19.36 29.9,19.37 29.9,19.48 28.91,20.46 28.91,22.66 29.22,22.97 29.22,27.69 30.19,28.65 30.19,30 v4(30.75,30.56)
  IN3 w0.064: v5(57.01,49.53) 57.11,49.53 57.46,49.18 58.22,49.18 v4(59.32,48.07) ; v6(46.1,32.89) 45.98,32.89 45.7,33.17 45.09,33.17 44.89,32.97 44.89,32.55 44.79,32.45 44.79,31.53 43.95,30.69 41.99,30.69 41.28,31.39 40.47,31.39 40.21,31.13 38.71,31.13 37.33,32.51 36.01,32.51 34.78,31.28 34.78,30.53 34.15,29.9 33.78,29.9 32.8,30.88 31.06,30.88 v4(30.75,30.56)
UIM_DET: length 3.6
  TOP w0.081: v2(49.05,50.75) 49.14,50.75 49.63,51.25 v1(49.63,53.06)
  IN1 w0.064: v2(49.05,50.75) 49.05,50.27 48.98,50.21 v4(48.96,50.21)
  IN3 w0.064: v4(48.96,50.21) 48.96,50.15 48.95,50.14 48.95,49.92 v5(49.01,49.85)
UIM_DET_R: length 77.3
  TOP w0.081: v1(48.29,52.47) 49.05,51.7 v2(49.05,51.34) ; RN197.2 26.93,6.06 26.88,6.01 RN196.1 27.62,5.74 Q26.1 27.85,6.06 27.45,6.46 v2(27.45,6.5)
  IN1 w0.064: v4(50.03,52.51) 50.03,52.32 v2(49.05,51.34) ; v2(27.45,6.5) 27.56,6.61 27.56,7.06 30.45,9.95 30.45,11.61 29.71,12.34 29.71,19.28 28.72,20.28 28.72,26.26 29.03,26.57 29.03,27.73 29.03,27.73 29.03,27.76 29.93,28.67 29.93,31.72 28.88,32.78 28.88,36.86 29.42,37.4 32.16,37.4 33.85,39.09 34.37,39.09 35.23,39.95 35.23,40.93 36.03,41.73 36.03,43.1 34.71,44.43 34.71,51.44 35.08,51.81 35.08,54.01 v4(35.12,54.06)
  IN3 w0.064: v4(35.12,54.06) 35.15,54.03 37.93,54.03 37.97,54.08 39.13,54.08 39.25,53.95 43.61,53.95 43.88,53.68 44.86,53.68 45.56,53.97 48.57,53.97 48.95,53.58 49.09,53.58 50.03,52.64 v4(50.03,52.51)
UIM_DET_SIM#: length 31.2
  TOP w0.081: v2(26.37,6.33) 26.08,6.33 25.67,6.75 DS1.5 DS1.6 23.93,6.75 21.83,8.85 17.62,8.85 13.11,4.35 8.6,4.35 8.03,4.92 8.03,6.06 JSIM1.5 ; RN198.2 30.47,6.04 Q26.2 29.07,5.31 28.82,5.57 28.82,7.09 28.48,7.42 v2(27.32,7.42)
  IN1 w0.064: v2(26.37,6.33) 26.37,6.47 v2(27.32,7.42)
UIM_RESET: length 140.8
  TOP w0.081: v2(57.84,49.74) 57.84,50.19 57.92,50.28 59.11,50.28 59.26,50.13 59.65,50.13 60.77,49.01 60.77,48.62 v1(61.54,47.84) 61.95,47.44 61.95,43.88 62.13,43.7 62.39,43.7 62.7,43.39 62.7,43.16 63.8,42.06 63.8,39.85 v2(63.37,39.42) ; v2(26.07,5.15) 25.78,5.15 25.68,5.25 DS1.2 DS1.8 v2(23.9,5.25)
  IN1 w0.064: v4(51.95,42.12) 51.97,42.12 51.97,42.04 52.12,41.89 52.12,40.96 53.08,40.01 55.69,40.01 55.84,40.16 59.04,40.16 59.36,39.84 62.95,39.84 v2(63.37,39.42) ; v4(58.01,50.19) 57.84,50.01 v2(57.84,49.74) ; v2(23.9,5.25) 23.57,5.58 23.57,7.46 22.42,8.61 17.07,8.61 16.53,8.06 v2(5.78,8.06) ; v2(26.07,5.15) 26.07,5.26 25.69,5.64 25.69,6.23 27.82,8.36 28.58,8.36 30.23,10.01 30.23,11.25 29.48,12.01 29.48,19.17 28.53,20.11 28.53,20.78 28.53,26.34 28.84,26.65 28.84,27.65 28.84,27.65 28.84,27.89 29.68,28.73 29.68,31.66 28.68,32.66 28.68,37.33 29.67,38.32 32.79,38.32 33.76,39.29 34.29,39.29 35.03,40.03 35.03,41.01 35.84,41.82 35.84,43.03 34.49,44.37 34.49,51.49 34.88,51.89 34.88,51.9 34.89,51.91 34.89,53.79 34.76,53.91 34.76,54.21 34.99,54.44 35.14,54.44 35.45,54.75 35.45,55.78 35.56,55.89 35.56,56.39 35.78,56.61 v4(36.29,56.61)
  IN2 w0.066: v4(36.29,56.61) 36.31,56.61 36.84,56.07 36.84,53.57 37.54,52.88 37.54,49.03 44.47,42.1 50.42,42.1 50.8,41.72 51.55,41.72 v4(51.95,42.12)
  IN3 w0.064: v5(58.01,49.53) v4(58.01,50.19)
UPD1_SMBCLK: length 155.4
  TOP w0.081: Q30.1 39.21,31.84 39.34,31.71 RE531.2 40.3,31.71 RE101.1 40.3,31.43 40.28,31.41 40.28,31.17 v2(40.34,31.11) ; UE1.A58 v2(40.35,24.18)
  IN1 w0.064: v2(40.35,24.18) 40.27,24.1 v4(40.03,24.1) ; v4(39.69,17.19) 39.91,16.97 40.55,16.97 40.63,16.89 40.98,16.89 41.68,16.19 42.07,16.19 43.07,15.2 43.73,15.2 44.86,14.07 49.29,14.07 49.77,14.55 51.94,14.55 52.46,15.08 52.46,15.43 53,15.97 54.52,15.97 55.38,16.84 59.07,16.84 59.5,16.41 59.95,16.41 60.98,15.39 60.98,15.38 60.98,14.68 64,11.66 71.42,11.66 72.34,10.74 74.91,10.74 75.21,11.04 82.86,11.04 83.76,10.14 93.54,10.14 95.36,11.97 97.6,11.97 99.67,14.03 106.83,14.03 107.72,14.92 113.03,14.92 113.77,15.67 116.96,15.67 119.45,18.16 122.73,18.16 125.19,20.62 131.74,20.62 132.39,19.97 138.55,19.97 138.8,20.22 140.4,20.22 140.5,20.13 143.14,20.13 143.81,20.79 147.94,20.79 150.99,17.74 153.93,17.74 155.66,16.01 155.66,15.9 156.55,15.01 156.81,15.01 v4(156.87,14.95) ; v4(40.37,30.44) 40.34,30.47 v2(40.34,31.11)
  IN2 w0.066: v4(156.87,14.95) 156.89,14.97 156.89,15.16 160.12,18.39 161.1,18.39 161.14,18.35 v4(161.15,18.35)
  IN3 w0.064: v4(40.37,30.44) 40.37,30.39 40.54,30.22 40.54,26 39.78,25.24 39.78,24.67 40.03,24.41 v4(40.03,24.1) 40.11,24.02 40.11,22.23 40.48,21.87 40.48,20.05 40.11,19.69 40.11,18.14 39.65,17.67 39.65,17.23 v4(39.69,17.19) ; v5(161.15,18.74) 161.15,18.36 v4(161.15,18.35)
  BOTTOM w0.089: PRZ08.2 161.3,18.69 161.26,18.74 v5(161.15,18.74)
UPD1_SMBDAT: length 166.8
  TOP w0.081: Q30.4 37.44,32.54 37.35,32.63 RE100.1 37,32.03 RE530.2 v2(36.99,32)
  IN1 w0.064: v4(39.54,24.32) 39.71,24.49 40.45,24.49 40.68,24.26 41.21,24.26 v2(41.39,24.44) ; v4(155.8,14.36) 155.47,14.69 155.47,15.93 153.85,17.55 150.91,17.55 147.86,20.6 143.89,20.6 143.22,19.93 140.42,19.93 140.32,20.03 138.88,20.03 138.63,19.78 132.31,19.78 131.66,20.43 125.27,20.43 122.81,17.97 119.53,17.97 116.89,15.33 115,15.33 114.22,14.54 107.88,14.54 106.99,13.65 99.83,13.65 97.76,11.58 95.52,11.58 92.81,8.87 92.4,8.87 91.53,9.74 83.62,9.74 82.7,10.66 75.37,10.66 75.07,10.36 72.18,10.36 71.26,11.28 63.81,11.28 60.6,14.49 60.6,15.23 59.8,16.03 59.34,16.03 58.91,16.46 56.1,16.46 55.42,15.78 53.08,15.78 52.65,15.35 52.65,15 52.01,14.35 49.84,14.35 49.37,13.88 44.78,13.88 43.65,15.01 42.99,15.01 41.99,16 41.6,16 40.96,16.64 40.57,16.64 40.43,16.78 39.8,16.78 v4(39.63,16.61) ; v2(36.99,32) 37.34,31.65 v4(37.34,31.36)
  IN2 w0.066: v4(163.31,18.23) 164.05,18.23 164.5,17.79 164.5,16.27 161.45,13.22 156.41,13.22 155.8,13.83 v4(155.8,14.36)
  IN3 w0.064: v5(163.34,18.69) 163.34,18.27 v4(163.31,18.23) ; v4(39.63,16.61) 39.39,16.61 39.2,16.79 39.2,17.5 39.92,18.22 39.92,19.77 40.29,20.13 40.29,21.79 39.33,22.74 39.33,23.81 39.54,24.02 v4(39.54,24.32) 39.54,27.51 39.04,28.01 39.04,29.59 37.34,31.29 v4(37.34,31.36)
UPD1_SMBINT#: length 33
  TOP w0.081: RE155.1 39.29,28.05 v2(39.4,28.16)
  IN1 w0.064: v4(36.81,28.9) 37.11,28.6 38.75,28.6 39,28.35 39.2,28.35 v2(39.4,28.16) 39.71,28.48 40.05,28.48 41.34,27.19 41.34,26.98 v2(41.38,26.93)
  IN2 w0.066: v4(16.6,28.96) 17.49,28.96 19.2,27.26 20.9,27.26 21.52,26.64 24.82,26.64 25.88,27.7 26.78,27.7 27.98,26.51 29.26,26.51 31.91,29.16 31.91,29.93 32.29,30.31 33.28,30.31 33.71,29.87 34.29,29.87 35.14,30.72 35.61,30.72 36.14,30.19 36.46,30.19 36.69,29.96 36.69,29.02 v4(36.81,28.9)
  IN3 w0.064: v5(16.12,28.96) v4(16.6,28.96)
  BOTTOM w0.081: v5(16.12,28.96) 16.2,28.89 RPD17.2
UPD_L_SMBCLK: length 2.3
  TOP w0.081: v1(15.53,71.54) 15.56,71.57 RM31.1 15.69,72.49 15.89,72.68 UM4.18
UPD_L_SMBDAT: length 1.2
  TOP w0.081: UM4.17 16.15,73.08 16.11,73.04 RM37.1
USB2_COMP: length 5
  BOTTOM w0.081: UC1.CC5 141.34,38.29 141.34,37.88 141.25,37.79 141.25,37.6 141.44,37.4 141.44,37.23 141.36,37.15 141.36,36.5 141.32,36.46 141.32,34.97 141.45,34.84 RC123.1
USB2_ID: length 4.2
  TOP w0.081: RC124.1 140.7,40.46 140.07,40.46 v1(139.95,40.35) 139.95,39.98 v2(140.06,39.87)
  IN1 w0.064: v4(139.43,39.89) 139.48,39.85 140,39.85 140.02,39.87 v2(140.06,39.87)
  IN3 w0.064: v5(140.8,40.15) 139.69,40.15 139.44,39.89 v4(139.43,39.89)
  BOTTOM w0.081: UC1.CE8 140.51,40.15 v5(140.8,40.15)
USB2_VBUSSENSE: length 5.9
  BOTTOM w0.081: RC125.1 142.13,35.68 142,35.82 142,36.44 141.9,36.53 141.9,36.72 141.97,36.79 141.97,38.02 141.84,38.14 141.84,38.55 141.36,39.03 UC1.CC6
USB3_CRX_DTX_N3: length 67.7
  TOP w0.091: JIO1.31 195.28,22.75 195.15,22.62 194.95,22.62 194.86,22.71 194.86,22.91 194.5,23.27 193.72,23.27 193.45,22.99 193.45,22.75 193.32,22.62 193.13,22.62 v2(193.04,22.71)
  IN1 w0.079: v6(142.59,39.33) 142.36,39.11 142.2,39.11 141.91,38.82 141.91,38.74 141.92,38.73 141.92,33.46 144.37,31 152.96,31 153.25,31.28 162.66,31.28 163.77,30.18 185.84,30.18 191.05,24.97 191.05,24.65 191.05,23.65 191.71,23 191.93,23 191.94,22.99 193.29,22.99 193.39,22.89 193.39,22.68 193.32,22.6 193.15,22.6 v2(193.04,22.71)
  BOTTOM w0.091: v6(142.59,39.33) 142.94,39.68 UC1.BY7
USB3_CRX_DTX_N4: length 64.4
  TOP w0.091: v2(191.4,25.93) 191.49,25.84 v7(192.05,25.84) 192.89,25.84 193.15,25.58 193.15,25.19 193.34,25 194.44,25 194.95,25.5 194.95,25.53 195.16,25.75 JIO1.37
  IN1 w0.079: v2(191.4,25.93) 191.49,25.84 191.63,25.84 191.72,25.93 191.72,26.12 191.47,26.37 190.48,26.37 186.34,30.51 186.34,30.51 186.08,30.76 164.01,30.76 162.91,31.87 153,31.87 152.72,31.58 144.62,31.58 142.51,33.69 142.51,37.96 142.84,38.29 142.84,38.29 142.89,38.35 143.13,38.35 v6(143.49,38.71)
  BOTTOM w0.091: UC1.BW6 143.81,39.03 v6(143.49,38.71)
USB3_CRX_DTX_P3: length 67.7
  TOP w0.091: v2(193.04,22.32) 193.14,22.42 193.4,22.42 193.65,22.67 193.65,22.91 193.8,23.07 194.41,23.07 194.65,22.82 194.65,22.63 194.86,22.42 195.12,22.42 195.29,22.25 JIO1.30
  IN1 w0.079: v2(193.04,22.32) 193.12,22.4 193.4,22.4 193.59,22.59 193.59,22.97 193.37,23.19 192.02,23.19 192.02,23.2 191.79,23.2 191.25,23.74 191.25,24.56 191.25,24.57 191.25,25.05 185.92,30.38 163.85,30.38 162.75,31.48 153.16,31.48 152.88,31.2 144.46,31.2 142.12,33.54 142.12,38.73 142.29,38.9 142.48,38.9 v6(142.68,38.7)
  BOTTOM w0.091: v6(142.68,38.7) 143.02,39.03 UC1.BY6
USB3_CRX_DTX_P4: length 64.3
  TOP w0.091: JIO1.36 195.21,25.25 195.16,25.3 195.03,25.3 194.53,24.79 193.26,24.79 192.95,25.1 192.95,25.5 192.81,25.64 192.33,25.64 192.32,25.62 191.78,25.62 191.77,25.64 191.49,25.64 v2(191.4,25.55)
  IN1 w0.079: v2(191.4,25.55) 191.4,25.56 191.49,25.64 191.72,25.64 191.92,25.84 191.92,26.02 191.92,26.03 191.92,26.21 191.55,26.57 190.56,26.57 186.43,30.71 186.42,30.71 186.17,30.96 164.09,30.96 162.99,32.07 152.92,32.07 152.64,31.78 144.71,31.78 142.71,33.78 142.71,37.88 142.98,38.15 143.16,38.15 v6(143.38,37.93)
  BOTTOM w0.091: UC1.BW5 143.83,38.38 v6(143.38,37.93)
USB3_CTX_DRX_N3: length 65.2
  TOP w0.091: v2(196.46,24.2) 196.37,24.11 196.14,24.11 196,24.25 JIO1.34
  IN1 w0.079: v2(196.46,24.2) 196.5,24.16 196.69,24.16 196.77,24.24 196.77,25.04 195.88,25.93 193.84,25.93 193.49,26.28 192.98,26.28 192.22,27.04 190.89,27.04 190.64,27.04 186.59,31.09 186.58,31.09 186.32,31.35 164.41,31.35 163.31,32.45 152.7,32.45 152.41,32.17 145.14,32.17 144.67,32.63 144.67,34.04 144.07,34.65 143.21,34.65 143.1,34.54 143.1,34.33 143.17,34.25 v6(143.3,34.25)
  BOTTOM w0.076: 143.68,35.99 143.66,36.01 143.66,36.31 143.8,36.45 143.8,37.04 UC1.BY4
  BOTTOM w0.091: 143.68,35.99 143.68,35.58 144.01,35.25 144.01,34.79 143.79,34.58 143.63,34.58 v6(143.3,34.25)
USB3_CTX_DRX_N4: length 57.1
  TOP w0.091: v2(194.73,27.2) 194.82,27.11 194.95,27.11 195.09,27.25 JIO1.40
  IN1 w0.079: v2(194.73,27.2) 194.65,27.11 193.32,27.11 192.61,27.82 192.54,27.82 192.54,27.83 191.05,27.83 191.04,27.83 190.95,27.83 186.91,31.88 186.91,31.88 186.65,32.13 164.86,32.13 163.76,33.23 151.45,33.23 150.84,33.85 149.68,33.85 149.04,33.2 145.89,33.2 v6(145.69,33.4)
  BOTTOM w0.091: UC1.BW2 144.09,36.15 144.61,35.62 144.61,33.71 144.92,33.4 v6(145.69,33.4)
USB3_CTX_DRX_P3: length 65.3
  TOP w0.091: v2(196.46,23.82) 196.37,23.9 196.16,23.9 196.01,23.75 JIO1.33
  IN1 w0.079: v6(143.31,35.05) 143.51,34.85 144.15,34.85 144.87,34.13 144.87,32.72 145.22,32.37 152.33,32.37 152.62,32.65 163.39,32.65 164.5,31.55 186.41,31.55 186.66,31.29 186.67,31.29 190.72,27.24 192.3,27.24 193.06,26.48 193.57,26.48 193.92,26.13 195.96,26.13 196.97,25.12 196.97,24.15 196.77,23.96 196.63,23.96 196.58,23.9 196.55,23.9 v2(196.46,23.82)
  BOTTOM w0.076: UC1.BY3 143.63,36.76 143.63,36.95 143.55,37.03 143.35,37.03 143.22,36.9 143.22,36.52 143.49,36.24 143.49,36.01 143.47,35.99
  BOTTOM w0.091: v6(143.31,35.05) 143.58,34.78 143.71,34.78 143.8,34.88 143.8,35.16 143.47,35.5 143.47,35.99
USB3_CTX_DRX_P4: length 57.1
  TOP w0.091: JIO1.39 195.08,26.75 194.92,26.9 194.82,26.9 v2(194.73,26.81)
  IN1 w0.079: v6(145.69,32.81) 145.88,33 149.12,33 149.76,33.65 150.76,33.65 151.37,33.03 163.68,33.03 164.78,31.93 186.57,31.93 186.82,31.68 186.83,31.68 190.87,27.63 190.96,27.63 190.97,27.63 192.46,27.63 192.46,27.62 192.53,27.62 193.24,26.91 194.63,26.91 v2(194.73,26.81)
  BOTTOM w0.091: v6(145.69,32.81) 145.49,32.81 145.38,32.93 145.38,33.12 145.31,33.2 144.84,33.2 144.41,33.62 144.41,35.54 144.26,35.68 UC1.BW1
USB20_N1: length 70
  TOP w0.091: v2(191.22,17.15) 191.3,17.23 191.41,17.23 191.59,17.06 191.78,17.06 RIO4.1
  IN1 w0.079: v2(191.22,17.15) 191.3,17.23 191.31,17.23 191.31,17.24 191.74,17.24 191.96,17.45 191.96,21.52 190.67,22.81 190.67,24.81 185.68,29.79 163.61,29.79 162.5,30.9 153.4,30.9 153.12,30.61 144.19,30.61 141.5,33.31 141.5,33.69 141.5,33.69 141.5,34.35 141.5,34.36 141.5,35.87 140.85,36.52 139.94,36.52 139.63,36.83 139.63,37.31 139.91,37.59 140.21,37.59 140.39,37.41 140.39,37.27 140.3,37.17 v6(140.07,37.17)
  BOTTOM w0.091: UC1.CE3 140.26,36.98 v6(140.07,37.17)
USB20_N1_R: length 3.5
  TOP w0.091: JIO1.19 195.27,16.75 195.19,16.82 195.06,16.82 194.98,16.75 194.98,16.61 194.77,16.4 193.65,16.4 193.26,16.79 193.26,16.92 193.1,17.07 192.78,17.07 LIO1.3
USB20_N2: length 66.6
  TOP w0.091: v2(191.19,18.43) 191.19,18.43 191.28,18.52 191.6,18.52 191.71,18.41 LIO2.4 192.09,18.37 RIO5.1
  IN1 w0.079: v2(191.19,18.43) 191.1,18.52 190.83,18.52 190.64,18.72 190.64,21.59 189.88,22.35 189.88,24.48 185.36,29.01 163.24,29.01 162.14,30.11 153.82,30.11 153.54,29.83 142.94,29.83 141.72,31.05 141.72,31.96 140.09,33.59 140.09,33.89 140.09,33.89 140.09,34.19 140.34,34.44 140.47,34.44 v6(140.67,34.64)
  BOTTOM w0.091: UC1.CE1 140.52,35.81 140.62,35.91 140.75,35.91 140.84,35.83 140.84,35.48 140.68,35.32 140.25,35.32 140.17,35.24 140.17,34.46 140.26,34.37 140.4,34.37 v6(140.67,34.64)
USB20_N2_R: length 3
  TOP w0.091: JIO1.22 195.08,18.25 194.94,18.38 194.19,18.38 194.04,18.53 192.91,18.53 RIO5.2
USB20_N3: length 151.6
  TOP w0.091: v6(22.71,69.88) 22.52,70.08 22.52,70.28 22.09,70.7 21.68,70.7 21.06,71.33 21.06,72.81 20.79,73.08 UM4.9
  IN3 w0.079: v6(22.71,69.88) 22.46,69.88 22.34,70 22.34,70.46 22.85,70.97 24.59,71.57 27.26,71.57 29.37,70.6 29.94,70.6 30.24,70.3 30.24,69.57 30.7,69.11 30.71,69.11 30.75,69.06 34.2,69.06 34.49,68.77 34.49,66.07 35.84,64.72 36.42,64.72 36.66,64.47 36.66,63.15 36.81,63.01 36.81,63 37.15,62.66 38.6,62.66 41.07,60.19 41.51,60.19 42.52,59.18 42.52,58.67 43.37,57.83 44.79,57.83 45.3,57.31 49.47,57.31 49.64,57.48 51.33,57.48 55.42,57.02 55.44,57.02 57.23,55.23 57.23,53.73 63.49,47.47 63.49,44.16 70.53,37.13 76.35,37.13 83.36,30.12 91.97,30.12 102.75,28.96 112.76,28.96 112.84,29.04 114.63,29.04 120.51,34.92 120.52,34.92 123.01,34.92 123.46,34.92 125.34,36.79 128.37,36.79 128.65,37.07 130.52,37.07 130.81,36.78 132.74,36.78 132.91,36.95 133.6,36.95 134.77,38.12 138.02,38.12 139.1,37.03 139.37,37.03 139.45,36.95 v5(139.45,36.71)
  BOTTOM w0.091: UC1.CG3 139.39,36.98 139.45,36.92 v5(139.45,36.71)
USB20_N5: length 65.2
  IN1 w0.079: v6(138.95,38.2) 138.95,38.25 138.75,38.44 138.65,38.44 137.96,37.75 136.98,37.75 136.46,37.22 136.46,35.85 135.74,35.12 135.05,35.12 134.78,35.4 130.68,35.4 130.54,35.4 129.94,34.8 129.94,34.72 128.72,33.49 125.85,33.49 124.78,32.42 124.78,30.27 124.77,30.25 124.77,28.19 125.78,27.18 125.78,25.2 124.41,23.83 123.09,23.83 122.4,23.14 118.79,23.14 117.05,21.4 117.05,20.31 117.05,20.31 115.53,18.79 115.53,18.79 115.18,18.44 115.18,18.44 114.89,18.16 111.63,18.16 110.88,17.4 108.7,17.4 105.9,14.6 99.43,14.6 98.4,13.57 96.95,13.57 96.78,13.74 96.4,13.74 96.4,13.74 95.97,13.74 95.89,13.66 95.89,13.46 95.95,13.4 v4(96.26,13.4)
  IN3 w0.079: v5(96.38,12.96) 96.15,12.96 95.89,13.22 95.89,13.51 95.96,13.59 96.07,13.59 v4(96.26,13.4)
  BOTTOM w0.091: v5(96.38,12.96) 96.3,12.88 v7(95.8,12.88) 94.94,12.88 RFP8.1 ; v6(138.95,38.2) 139.13,38.38 UC1.CG5
USB20_N5_R: length 6.4
  IN3 w0.079: v5(93.29,13.47) 93.18,13.47 93.12,13.41 93.12,13.14 93.49,12.77 94.11,12.77 94.18,12.84 v5(94.18,13.02)
  BOTTOM w0.091: JFP1.6 93.3,9.68 93.15,9.82 93.15,9.98 93.15,10.47 93.3,10.61 ED11.1 ED11.9 93.3,12.06 93.15,12.21 93.15,12.57 93.16,12.58 93.16,13.12 93.15,13.14 93.15,13.33 v5(93.29,13.47)
USB20_N6: length 134.9
  IN3 w0.079: v5(141.65,35.68) 141.65,35.88 141.57,35.96 139.31,35.96 137.73,37.53 135.02,37.53 133.85,36.36 133.15,36.36 132.99,36.2 130.57,36.2 130.28,36.49 128.9,36.49 128.61,36.21 125.58,36.21 123.7,34.33 123.01,34.33 120.96,34.33 114.44,27.82 111.96,27.82 111.58,28.2 103.02,28.2 91.92,29.53 90.24,29.53 90.24,29.53 83.29,29.53 83.12,29.53 83.05,29.6 82.96,29.6 76.03,36.54 71.21,36.54 71.21,36.54 70.77,36.54 70.29,36.54 66.53,40.3 65.83,40.3 65.45,40.68 65.45,41.38 62.91,43.92 62.91,46.84 56.49,53.25 56.49,55.14 55.43,56.21 51.14,56.21 50.93,55.99 50.15,55.99 49.45,56.7 45.09,56.7 44.54,57.24 43.12,57.24 41.9,58.47 41.9,58.98 41.27,59.6 40.82,59.6 38.38,62.04 36.89,62.04 35.8,63.13 35.8,63.18 32.79,66.19 32.04,66.19 31.97,66.12 31.97,66.01 v5(32.07,65.91)
  BOTTOM w0.091: R10.1 32.15,66.37 L3.1 31.98,66.2 31.98,66 v5(32.07,65.91)
USB20_N6_R: length 8.2
  BOTTOM w0.091: R10.2 32.16,66.95 L3.2 31.98,67.14 31.98,67.73 32.12,67.88 ED12.8 ED12.2 32.12,69.39 31.98,69.54 31.98,69.92 31.69,70.21 v7(31.46,70.21) 30.09,70.21 30.08,70.22 29.61,70.22 28.89,70.94 28.89,71.85 29.15,72.12 JEDP1.30
USB20_P1: length 70.1
  TOP w0.091: RIO3.1 191.81,17.26 191.67,17.26 191.5,17.43 191.31,17.43 v2(191.22,17.53)
  IN1 w0.079: v2(191.22,17.53) 191.31,17.44 191.66,17.44 191.76,17.53 191.76,21.43 190.47,22.72 190.47,24.72 185.6,29.59 163.52,29.59 162.42,30.7 153.49,30.7 153.2,30.41 144.11,30.41 141.3,33.22 141.3,33.77 141.3,33.78 141.3,34.27 141.3,34.27 141.3,35.78 140.76,36.32 139.85,36.32 139.43,36.74 139.43,36.82 139.43,36.83 139.43,37.39 139.83,37.79 140.29,37.79 140.43,37.65 140.56,37.65 140.87,37.96 v6(140.87,37.98)
  BOTTOM w0.091: UC1.CE4 v6(140.87,37.98)
USB20_P1_R: length 3.6
  TOP w0.091: JIO1.20 195.24,17.25 195.08,17.1 195.02,17.1 194.78,16.85 194.78,16.7 194.68,16.6 193.73,16.6 193.46,16.88 193.46,17 193.18,17.28 192.82,17.28 LIO1.2
USB20_P2: length 66.6
  TOP w0.091: v2(191.19,18.82) 191.19,18.81 191.28,18.72 191.67,18.72 191.78,18.84 191.92,18.84 RIO6.1
  IN1 w0.079: v2(191.19,18.82) 191.1,18.73 190.91,18.73 190.84,18.8 190.84,21.68 190.08,22.43 190.08,24.57 185.44,29.21 163.33,29.21 162.22,30.31 153.74,30.31 153.46,30.03 143.02,30.03 141.92,31.13 141.92,32.05 140.29,33.67 140.29,34.11 140.42,34.23 140.79,34.23 140.91,34.11 140.91,33.94 140.82,33.84 v6(140.71,33.84)
  BOTTOM w0.091: v6(140.71,33.84) 140.41,34.14 140.17,34.14 139.97,34.34 139.97,35.33 140.21,35.57 140.21,35.86 140.52,36.17 UC1.CE2
USB20_P2_R: length 3.1
  TOP w0.091: JIO1.23 195.06,18.75 194.9,18.58 194.28,18.58 194.12,18.74 192.89,18.74 RIO6.2
USB20_P3: length 151.6
  TOP w0.091: v6(21.95,69.87) 22.22,69.87 22.32,69.96 22.32,70.19 22.01,70.5 21.6,70.5 20.85,71.25 20.85,72.73 20.7,72.88 20.43,72.88 20.23,72.68 UM4.8
  IN3 w0.079: v5(139.59,37.38) 139.44,37.23 139.19,37.23 138.1,38.32 134.69,38.32 133.52,37.15 132.83,37.15 132.66,36.98 130.9,36.98 130.61,37.27 128.57,37.27 128.29,36.99 125.25,36.99 123.38,35.12 123.01,35.12 120.48,35.12 120.41,35.09 114.55,29.24 112.75,29.24 112.67,29.16 102.76,29.16 91.98,30.32 83.44,30.32 76.44,37.33 70.61,37.33 63.69,44.25 63.69,47.55 57.43,53.81 57.43,55.32 55.53,57.22 55.43,57.22 51.35,57.69 49.56,57.69 49.38,57.51 45.39,57.51 44.87,58.03 43.45,58.03 42.72,58.75 42.72,59.26 41.6,60.39 41.15,60.39 38.68,62.86 37.23,62.86 37.01,63.08 37.01,63.09 36.86,63.24 36.86,64.55 36.5,64.92 35.93,64.92 34.69,66.15 34.69,68.86 34.28,69.27 30.83,69.27 30.79,69.31 30.78,69.31 30.44,69.65 30.44,70.39 30.02,70.8 29.41,70.8 27.3,71.77 24.56,71.77 22.74,71.14 22.45,70.86 22.14,70.54 22.14,70.06 v6(21.95,69.87)
  BOTTOM w0.091: v5(139.59,37.38) 139.46,37.38 UC1.CG4
USB20_P5: length 65.1
  IN1 w0.079: v4(95.52,13.4) 95.67,13.55 95.67,13.75 95.86,13.94 95.88,13.94 95.88,13.94 96.48,13.94 96.48,13.94 96.86,13.94 97.03,13.77 98.27,13.77 98.44,13.94 98.49,13.94 99.35,14.8 105.82,14.8 108.62,17.6 108.78,17.6 108.79,17.6 110.79,17.6 111.55,18.36 114.81,18.36 115.09,18.64 115.1,18.64 115.33,18.87 115.33,18.88 116.85,20.4 116.85,21.49 118.7,23.34 122.32,23.34 123.01,24.03 124.33,24.03 125.58,25.28 125.58,27.1 124.57,28.11 124.57,30.27 124.58,30.29 124.58,32.51 125.77,33.69 128.64,33.69 129.74,34.8 129.74,34.89 130.46,35.6 130.76,35.6 134.86,35.6 135.14,35.32 135.65,35.32 136.26,35.93 136.26,37.31 136.9,37.95 137.87,37.95 138.57,38.65 138.7,38.65 138.7,38.65 138.75,38.65 138.93,38.83 v6(138.95,38.83)
  IN3 w0.079: v4(95.52,13.4) 95.52,13.31 96.25,12.58 v5(96.38,12.58)
  BOTTOM w0.091: RFP7.1 94.95,12.66 95.55,12.66 95.55,12.66 96.07,12.66 96.08,12.67 96.28,12.67 v5(96.38,12.58) ; v6(138.95,38.83) 139.16,39.03 UC1.CG6
USB20_P5_R: length 6.5
  IN3 w0.079: v5(92.81,13.47) 92.92,13.36 92.92,13.06 93.4,12.57 94.1,12.57 v5(94.19,12.49)
  BOTTOM w0.091: JFP1.5 92.8,9.65 92.95,9.81 92.95,10.44 92.8,10.59 ED11.2 ED11.8 92.8,12.04 92.95,12.19 v7(92.95,12.85) 92.95,13.33 v5(92.81,13.47)

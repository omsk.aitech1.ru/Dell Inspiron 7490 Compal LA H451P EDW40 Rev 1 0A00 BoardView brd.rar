# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
POWER_SW#_MB: length 323.8
  TOP w0.081: v2(117.16,62.24) 117.68,61.72 117.68,60.94 120.05,58.57 120.18,58.57 121.83,56.91 121.83,56.35 121.99,56.19 121.99,56.1 123.1,55 123.1,53.82 124.17,52.74 124.17,51.82 123.3,50.95 123.3,43.57 124.4,42.48 124.4,38.43 123.04,37.08 122.53,37.08 121.75,36.3 119.98,36.3 118.32,37.96 116.7,37.96 116.35,37.61 116.35,36.63 117.81,35.17 117.81,25.61 115.9,23.7 115.9,18.88 114.35,17.34 114.35,16.75 114.07,16.46 114.05,16.46 v2(113.59,16) 113.31,15.73 113.31,15.14 111.8,13.63 111.8,12.34 111.39,11.92 110.88,11.92 110.63,12.17 110.63,12.69 110.21,13.11 109.44,13.11 108.36,12.03 108.36,10.18 108.48,10.06 109.31,10.06 109.94,9.43 110.38,9.43 110.39,9.42 v2(110.39,9.41) ; RE25.2 34.85,19.03 34.85,18.29 33.36,16.8 33.36,13.63 32.83,13.09 32.83,12.32 33.07,12.07 33.78,12.07 34.27,12.57 34.27,15.2 34.68,15.61 38.52,15.61 v2(38.68,15.77) ; v2(140.61,20.41) 140.67,20.35 150.88,20.35 154.92,16.32 159.74,16.32 160.74,15.32 v3(160.74,11.71) 160.74,11.13 161,10.87 161,8.93 161.76,8.18 161.76,5.3 162.97,4.09 170.24,4.09 170.43,4.28 191.73,4.28 192.87,5.42 192.96,5.42 193.6,6.07 193.93,6.07 193.99,6.12 196.08,6.12 196.81,6.85 196.81,10.38 196.44,10.75 JIO1.7
  IN1 w0.064: v2(113.59,16) 114.31,16 114.36,15.96 116.85,15.96 119.27,18.38 122.68,18.38 125.11,20.81 131.82,20.81 132.47,20.16 138.47,20.16 138.72,20.41 v2(140.61,20.41) ; v2(110.39,9.41) 110.09,9.41 108.66,7.98 108.54,7.98 108.41,7.85 105.42,7.85 104.55,8.73 97.56,8.73 95.29,6.46 86.91,6.46 86.46,6.91 84.54,6.91 v4(84.3,7.14) 84.06,7.14 83.54,6.63 80.23,6.63 79.8,6.19 63.96,6.19 62.54,7.61 61.05,7.61 61.05,7.61 54.93,7.61 51.07,11.46 49.32,11.46 48.94,11.85 43.43,11.85 43.01,12.27 42.45,12.27 40.99,13.73 40.23,13.73 38.68,15.29 v2(38.68,15.77) ; v2(128.95,72.83) 128.95,73.22 127.98,74.19 126.06,74.19 125.75,73.88 125.75,73.55 124.84,72.63 121.13,72.63 120.19,73.57 115.92,73.57 114.69,72.35 114.69,70.42 116.61,68.5 116.61,66.83 116.93,66.51 116.93,64.08 116.61,63.76 116.61,62.69 117.07,62.24 v2(117.16,62.24)
  IN3 w0.064: v5(93.8,9.2) 93.09,9.2 92.21,10.08 v5(91.75,10.08) ; v5(86.49,6.87) 85.76,6.87 85.49,7.14 v4(84.3,7.14)
  BOTTOM w0.081: v5(91.75,10.08) 91.8,10.12 ED11.4 ED11.7 91.8,11.98 91.91,12.09 91.91,12.73 91.78,12.85 90.93,12.85 89.77,11.7 89.77,10.93 89.43,10.59 89.43,8.96 89.53,8.86 89.53,7.59 88.81,6.87 v5(86.49,6.87) 86.49,6.33 87.55,5.27 SW1.1
POWER_SW_IN#: length 15.1
  TOP w0.081: v2(36.97,20.42) 36.97,20.66 36.88,20.74 CE14.1 36.53,20.73 RE25.1 36.62,20.04 RE20.2 37.12,19.66 36.69,19.23 v1(36.2,19.23) ; UE1.B67 v2(41.21,21.43)
  IN1 w0.064: v2(36.96,14.61) 36.72,14.85 36.72,17.06 37.22,17.57 37.22,18.85 36.78,19.3 36.78,20.23 v2(36.97,20.42) 36.97,20.3 37.31,19.95 39.68,19.95 41.16,21.43 v2(41.21,21.43)
PRB01_CSIN: length 18.1
  TOP w0.203: v2(194.78,15.01) 194.36,14.6 188.37,14.6 187.97,14.2 184.87,14.2 184.67,14 PRB01.3
  IN1 w0.203: v4(194.07,17.46) 193.98,17.55 193.78,17.55 193.57,17.33 193.57,17.05 194.78,15.83 v2(194.78,15.01)
  IN3 w0.203: v5(194.32,17.68) 194.32,17.67 194.12,17.46 v4(194.07,17.46)
  BOTTOM w0.203: v5(194.32,17.68) 194.4,17.6 v1(194.91,17.6) 195.36,18.06 196.29,18.06 196.66,18.43 PRB03.1
PRB01_CSIP: length 14.9
  TOP w0.203: v2(194.21,15.01) 194.17,14.97 v7(191.03,14.97) 188.28,14.97 187.88,14.58 184.88,14.58 184.67,14.79 PRB01.2
  IN1 w0.203: v2(194.21,15.01) 194.21,15.89 193.22,16.89 193.22,17.53 193.61,17.93 193.9,17.93 v4(194.06,18.09)
  IN3 w0.203: v5(194.06,18.47) v4(194.06,18.09)
  BOTTOM w0.203: PRB02.1 v5(194.06,18.47)
PRB12_CSON: length 170.7
  TOP w0.203: PRB12.3 93.15,13.71 92.88,13.98 91.3,13.98 88.7,11.39 88.7,6.31 89.62,5.38 v7(95.91,5.38) 98.41,5.38 98.65,5.62 98.65,5.65 98.64,5.66 v2(98.64,5.69)
  IN1 w0.203: v4(202.31,27.92) 202.31,27.38 202.23,27.31 201.22,27.31 200.05,26.14 200.05,25.54 209.1,16.48 209.1,5.17 207.9,3.96 195.78,3.96 195.59,3.77 164.54,3.77 158.74,9.57 148.67,9.57 143.41,14.84 135.95,14.84 135.86,14.75 133.68,14.75 133.33,14.39 129.04,14.39 128.78,14.65 127.01,14.65 125.71,13.36 120.27,13.36 118.61,11.7 118.61,10.47 117.71,9.57 116.31,9.57 115.47,8.73 112.55,8.73 110.46,6.64 109.04,6.64 108.87,6.47 100.45,6.47 100.35,6.37 100.34,6.37 100.13,6.15 99.93,6.15 99.93,6.15 99.18,6.15 98.71,5.69 v2(98.64,5.69)
  IN3 w0.203: v5(201.59,27.95) 201.62,27.92 v4(202.31,27.92)
PRB12_CSOP: length 172
  TOP w0.203: PRB12.2 93.15,14.52 92.95,14.31 91.16,14.31 88.37,11.53 88.37,6.17 89.48,5.05 v7(92.67,5.05) 98.54,5.05 98.88,5.39 98.94,5.39 v2(98.95,5.39)
  IN1 w0.203: v2(98.95,5.39) 98.95,5.46 99.31,5.82 100.07,5.82 100.07,5.82 100.27,5.82 100.48,6.04 100.48,6.04 100.59,6.14 109,6.14 109.18,6.31 110.6,6.31 112.68,8.4 115.6,8.4 116.45,9.24 117.85,9.24 118.94,10.34 118.94,11.57 120.41,13.03 125.85,13.03 127.14,14.32 128.64,14.32 128.91,14.06 133.46,14.06 133.82,14.42 136,14.42 136.09,14.51 143.27,14.51 148.53,9.24 158.6,9.24 164.41,3.44 195.72,3.44 195.92,3.63 207.76,3.63 208.04,3.63 209.43,5.03 209.43,16.62 200.38,25.67 200.38,26.01 201.35,26.98 202.24,26.98 202.34,26.89 v4(202.34,26.27)
  IN3 w0.203: v5(201.74,26.27) v4(202.34,26.27)
PRIM_PWRGD: length 110.4
  TOP w0.081: UE5.1 62.97,20.94 62.61,21.31 62.61,23.72 62.01,24.32 v1(62.01,24.79) 62.01,25.13 62.2,25.32 63.09,25.32 63.39,25.61 v2(63.39,25.69)
  IN1 w0.064: v4(108.32,35.91) 108.19,35.78 106.8,35.78 106.57,36.01 106.08,36.01 105.81,35.74 105.81,34.54 106.15,34.2 106.15,33.39 104.69,31.93 104.69,30.7 101.18,27.18 101.18,27.07 101.18,27.07 101.18,23.77 101.07,23.66 96.76,23.66 95.62,24.8 92.98,24.8 91.27,24.8 88.32,21.85 88.32,21.35 87.1,20.13 80.72,20.13 78.72,22.13 78.72,23.25 78.72,23.38 78.55,23.55 78.55,23.55 77.48,24.62 77.48,25.77 74.78,28.48 66.78,28.48 64.98,26.67 64.37,26.67 v2(63.39,25.69) 63.26,25.56 58.15,25.56 57.21,24.63 56.95,24.63 55.96,23.64 55.83,23.64 55.83,23.64 54.97,23.64 54.53,23.2 53.78,23.2 53.13,22.56 v2(53.13,22.42)
  IN3 w0.064: v5(127.27,49.3) 127.27,49.18 126.87,48.78 124.19,48.78 123.27,49.7 121,49.7 120.86,49.57 119.09,49.57 118.76,49.24 118.76,48.55 118.37,48.16 117.52,48.16 117.13,47.77 116.7,47.77 115.66,46.73 114.64,46.73 113.8,45.89 113.8,44.86 113.49,44.54 113.49,44.16 111.89,42.55 111.89,41.58 110.43,40.11 110.43,38.49 109.31,37.38 109.31,37.32 108.39,36.4 108.39,35.98 v4(108.32,35.91)
PRIM_PWRGD_R: length 1.7
  BOTTOM w0.254: RE473.2 RE165.1 RE182.2 RE507.1
PROCHOT#: length 15.1
  TOP w0.081: v2(56.49,28.23) 56.78,27.94 v1(56.78,27.46) RE547.2 56.67,26.5 56.18,26.02 56.18,25.45 56.57,25.05 56.57,24.08 56.23,23.74 56.23,23.65 RE45.2 55.4,22.83 UE2.2 ; v2(50,27.34) 50.02,27.34 50.43,26.93 UE1.B30
  IN1 w0.064: v2(50,27.34) 51.33,27.34 51.46,27.47 52.2,27.47 52.4,27.27 52.4,26.96 52.63,26.72 53,26.72 53.61,27.33 53.61,27.33 53.77,27.49 55.87,27.49 56.49,28.11 v2(56.49,28.23)
PROCHOT_CHG: length 2.7
  BOTTOM w0.203: PRB19.1 ZTB02.1 192.85,25.82 193.81,24.87 PUB01.23
PROG_CHG: length 2
  BOTTOM w0.203: PRB26.1 195.06,27.49 195.71,26.85 PUB01.27
PROJECT_ID1: length 3.4
  TOP w0.081: RC52.2 RC55.1 136.91,45.84 136.71,46.04 v2(136.48,46.04) 136.48,45.95 136.48,45.95 136.48,45.61 v1(136.3,45.43)
  IN1 w0.064: v2(136.48,46.04) 136.17,46.04 v4(136.15,46.06)
  IN3 w0.089: v5(136.17,45.71) 136.17,45.96 136.15,45.99 v4(136.15,46.06)
  BOTTOM w0.081: UC1.CM16 136.17,45.45 v5(136.17,45.71)
PROJECT_ID2: length 4.6
  BOTTOM w0.081: RC200.2 131.73,45.76 132.45,45.76 132.62,45.59 RC201.1 132.99,45.4 133.13,45.25 134.07,45.25 134.28,45.46 134.81,45.46 135.14,45.13 UC1.CP16
PROJECT_ID3: length 5.4
  BOTTOM w0.081: UC1.CN16 135.92,45.06 135.71,45.06 135.45,44.79 134.33,44.79 133.9,44.36 133.18,44.36 132.91,44.64 RC56.1 132.63,44.84 132.49,44.97 131.56,44.97 131.38,44.79 RC53.2
PS_ID: length 32.5
  TOP w0.081: v2(53.44,15.24) 53.44,15.55 53.13,15.86 RE548.1 RE549.1
  IN1 w0.064: v4(52.9,14.53) 53.44,15.07 v2(53.44,15.24) ; v4(46.99,29.07) 46.98,29.08 v2(46.98,29.53)
  IN2 w0.066: v4(52.9,14.53) 52.77,14.53 52.35,14.1 49.21,14.1 48.48,13.37 42.8,13.37 41.81,14.36 41.81,14.86 41.87,14.93 v4(41.89,14.93)
  IN3 w0.064: v4(41.89,14.93) 41.89,15.17 42.25,15.53 42.25,16.86 42.37,16.98 42.98,16.98 44.53,18.54 44.53,25.84 46.79,28.09 47.02,28.09 47.27,28.35 47.27,28.79 v4(46.99,29.07)
PS_ID_R: length 69.3
  TOP w0.081: PR1.2 115.51,15.23 115.48,15.25 PR5.2 114.88,15.61 114.65,15.38 v2(114.63,15.38) ; v2(55.74,16.5) 55.4,16.16 v1(54.78,16.16) 53.83,16.16 RE548.2
  IN1 w0.064: v2(55.74,16.5) 55.88,16.65 58.99,16.65 59.42,16.22 59.88,16.22 60.79,15.31 60.79,14.6 63.92,11.47 71.34,11.47 72.26,10.55 74.99,10.55 75.29,10.85 82.78,10.85 83.7,9.93 91.72,9.93 92.53,9.12 92.79,9.12 95.44,11.77 97.68,11.77 99.75,13.84 106.91,13.84 107.8,14.73 113.92,14.73 114.57,15.38 v2(114.63,15.38)
PS_SMBCLK: length 5.8
  TOP w0.081: U16.A1 70.88,74.68 70.49,74.29 RS11.1 RS6.2 69.48,74.29 69.09,73.9 v1(69.09,73.26) 69.09,72.39 69.86,71.62 Q28.1
PS_SMBDAT: length 7.4
  TOP w0.081: U16.B1 71,74.12 70.77,73.89 RS12.1 RS7.2 69.7,73.53 69.43,73.26 69.43,72.57 v1(69.91,72.09) 71.66,72.09 71.78,71.97 71.78,70.81 71.97,70.62 Q28.4
PSID: length 61.9
  TOP w0.081: PR3.1 117.19,12.51 116.41,11.73 116.41,11.24 116.24,11.07 PQ1.1 115.53,13.8 116.89,15.17 116.89,18.85 v1(117,18.95) 117.62,19.57 v2(117.62,20.91) ; PJPDC1.5 87.06,14.07 85.35,12.36 84.31,12.36 83.4,11.45 83.4,10.91 v2(83.51,10.8)
  IN1 w0.064: v2(83.51,10.8) 83.9,10.4 93.53,10.4 95.28,12.16 97.53,12.16 99.59,14.22 106.36,14.22 108.57,16.44 108.57,16.74 108.86,17.02 111.03,17.02 111.79,17.78 115.12,17.78 117.62,20.27 v2(117.62,20.91)
PSID-1: length 1.8
  TOP w0.081: PR2.1 PR3.2 118.79,13 118.82,13.03 PQ2.2
PSID-3: length 3.4
  TOP w0.081: v1(112.94,12.87) 113.23,13.15 PQ1.3 114.56,14.18 114.59,14.21 PR1.1
PSYS_CHG: length 2.2
  BOTTOM w0.203: PUB01.30 196.91,26.55 197.56,27.2 PRB33.1
  BOTTOM w0.254: PRB33.1 PRB31.1
PSYS_CPU: length 4.5
  BOTTOM w0.203: PUZ01.46 154.85,19.07 153.79,18 PRZ17.1 PCZ03.2 152.7,17.42 152.57,17.3 152.47,17.3 PRZ16.2
PTP_DIS#: length 112.1
  TOP w0.081: v2(118.74,5.08) 119.09,4.73 120.84,4.73 121.54,5.42 D5.1
  IN1 w0.064: v2(118.74,5.08) 118.4,5.42 v4(118.4,6.57) ; v4(40.72,25.16) 40.75,25.13 41.19,25.13 v2(41.38,24.93)
  IN2 w0.066: v4(118.4,6.57) 118.4,6.53 115.66,3.79 101.51,3.79 100.95,4.34 99.36,4.34 98.74,3.73 55.88,3.73 52.52,7.08 47.65,7.08 45.7,9.03 45.15,9.03 44.35,8.24 39.89,8.24 38.81,9.31 38.81,10.24 38.9,10.33 38.9,11.45 38.83,11.52 36.74,11.52 v4(36.64,11.62)
  IN3 w0.064: v4(40.72,25.16) 40.72,25.02 40.8,24.93 40.8,23.5 40.49,23.19 40.49,22.42 40.86,22.06 40.86,19.89 40.49,19.53 40.49,17.98 40.25,17.73 40.25,17.02 40.6,16.66 40.6,16.27 39.6,15.27 38.52,15.27 36.61,13.35 36.61,11.65 v4(36.64,11.62)
PWM1: length 23.2
  TOP w0.203: PUV01.20 39.31,65.93 v2(39.54,66.16)
  IN1 w0.203: v4(39.44,66.76) 39.5,66.7 39.5,66.19 v2(39.54,66.16)
  IN3 w0.203: v4(39.44,66.76) 40.03,67.34 41.89,67.34 42.46,67.9 43.17,67.9 43.72,67.35 47.63,67.35 49.52,69.24 49.52,75.94 50.22,76.65 51.76,76.65 v5(52.27,76.14)
PWM2: length 15
  TOP w0.203: v2(39.95,66.07) 39.71,65.82 PUV01.19
  IN1 w0.203: v2(39.95,66.07) 40.02,66.13 v4(40.02,66.65)
  IN3 w0.203: v5(52.21,68.67) 50.23,68.67 47.99,66.43 42.78,66.43 42.33,66.88 40.24,66.88 v4(40.02,66.65)
PWM_CORE1: length 16.4
  IN1 w0.203: v4(167.19,11.02) 167.19,11.03 167.19,11.48 166.37,12.3 165.47,12.3 161.28,16.5 160.88,16.5 159.88,17.5 158.58,17.5 v4(156.1,19.98)
  IN3 w0.203: v4(156.1,19.98) 156.01,19.89 156.01,19.41 v5(156.05,19.37) ; v5(167.59,10.96) 167.31,10.96 167.25,11.02 v4(167.19,11.02)
  BOTTOM w0.203: PUZ01.43 v5(156.05,19.37)
PWM_CORE2: length 29.2
  IN1 w0.203: v4(174.8,11.45) 173.5,10.15 169.17,10.15 165.91,13.41 165.01,13.41 161.47,16.95 161.08,16.95 160.04,17.99 158.92,17.99 157.28,19.63 157.28,20.44 156.67,21.05 155.87,21.05 155.61,20.79 v4(155.61,18.76)
  IN3 w0.203: v4(174.8,11.45) 175.19,11.06 v5(175.51,11.06) ; v4(155.61,18.76) 155.69,18.76 155.81,18.88 v5(156.05,18.88)
  BOTTOM w0.203: v5(156.05,18.88) 156.16,18.88 156.45,19.17 PUZ01.42
PWM_CORE3: length 35.4
  IN1 w0.203: v4(155.62,18.2) 155.74,18.33 156.78,18.33 158.19,16.92 158.19,16.71 159.52,15.38 161.75,15.38 165.32,11.8 166.22,11.8 166.74,11.29 166.74,10.61 167.55,9.79 171.49,9.79 172.06,9.23 179.82,9.23 181.97,11.38 v4(183.06,11.38)
  IN3 w0.203: v5(183.32,11.11) v4(183.06,11.38) ; v5(156.06,18.44) 155.83,18.2 v4(155.62,18.2)
  BOTTOM w0.203: v5(156.06,18.44) 156.52,18.44 156.85,18.77 PUZ01.41
PWM_FAN1: length 223
  TOP w0.081: v2(52.06,26.63) 52.41,26.63 52.5,26.55 RE17.1 52.38,26.33 51.81,26.33 51.66,26.18 UE1.A27
  IN1 w0.064: v2(195.49,15.25) 195.5,15.26 197.86,15.26 198.47,15.86 204.25,15.86 205.83,14.28 205.83,7.41 205.25,6.83 189.99,6.83 189.68,7.15 189.68,7.81 189.68,7.97 189.02,8.63 181.62,8.63 180.5,7.5 171.3,7.5 170.71,8.09 163.93,8.09 159.76,12.26 153.45,12.26 150.3,15.4 150.3,15.53 149.5,16.33 148.2,16.33 147.54,16.99 147.54,18.06 147.65,18.17 147.65,18.9 147.21,19.34 144.25,19.34 143.69,18.79 139.94,18.79 139.85,18.89 139.35,18.89 139.11,18.64 125.1,18.64 123.28,16.83 120,16.83 117.13,13.95 116.34,13.95 115.75,13.36 108.8,13.36 108.14,12.7 101.5,12.7 99.43,10.63 95.91,10.63 93.2,7.92 89.95,7.92 89.09,8.78 83.24,8.78 82.31,9.71 75.79,9.71 75.49,9.41 71.78,9.41 71.07,10.12 62.3,10.12 60.86,11.57 60.86,12.96 59.84,13.98 59.84,14.91 59.48,15.27 59.02,15.27 58.59,15.69 56.41,15.69 55.67,14.95 54.58,14.95 53.24,13.61 49.91,13.61 49.6,13.31 44.04,13.31 43.57,13.77 43.57,14.16 v4(43.29,14.44) ; v2(52.06,26.63) 51.73,26.95 49.95,26.95 49.12,27.78 v4(48.45,27.78)
  IN3 w0.064: v4(48.45,27.78) 48.28,27.78 47.78,27.29 47.78,25.8 46.52,24.55 46.52,22.26 47.38,21.39 47.38,19.81 46.5,18.93 46.5,18.71 44.96,17.17 43.99,17.17 43.46,16.64 43.46,16.36 43.34,16.24 43.34,16 43.14,15.81 43.14,14.5 43.2,14.44 v4(43.29,14.44)
PWM_GT1: length 71.5
  IN1 w0.203: v4(158.26,20.02) 158.82,20.02 160.99,17.85 161.22,17.85 165.2,13.87 166.34,13.87 169.6,10.61 173.31,10.61 174.61,11.91 175.61,11.91 177.44,10.08 179.72,10.08 181.72,12.08 185.25,12.08 185.54,12.36 v4(185.54,12.45)
  IN3 w0.203: v5(203.14,36.37) 203.14,32.91 201.13,30.9 201.13,30.06 200.52,29.46 199.86,29.46 199.47,29.06 198.99,29.06 198.82,28.89 198.02,28.89 197.1,27.98 195.91,27.98 194.06,26.13 194.06,21.67 194.72,21 194.72,19.7 193,17.98 193,17.43 190.56,14.99 188.49,14.99 187.88,14.38 186.56,14.38 185.54,13.36 v4(185.54,12.45) ; v5(157.85,18.76) 157.85,19.61 v4(158.26,20.02)
  BOTTOM w0.203: v5(157.85,18.76) 157.66,18.96 PUZ01.39
PWM_SA: length 20
  IN2 w0.203: v4(145.19,18.43) 145.36,18.26 145.36,18.2 146.55,17.02 149.39,17.02 149.97,17.59 153.83,17.59 155.47,19.23 158.12,19.23 v4(158.36,19.47)
  IN3 w0.203: v5(141.89,18.29) 142.22,18.29 142.31,18.19 144.96,18.19 145.19,18.42 v4(145.19,18.43) ; v4(158.36,19.47) 158.33,19.43 158.33,18.73 v5(158.33,18.72)
  BOTTOM w0.203: v5(158.33,18.72) 158.33,18.88 158.05,19.15 PUZ01.38
PWR_DEBUG#_XDP: length 12
  TOP w0.081: JXDP1.45 136.93,5.64 137.79,4.78 143.8,4.78 RC256.2 RC536.2 145.16,7.23 145.42,7.49 v1(145.42,7.76)
PWRGD_XDP: length 8.5
  TOP w0.081: v2(133.48,11.15) 132.6,11.15 131.39,12.37 RC250.2
  IN1 w0.064: v2(135.13,6.77) 135.13,10.58 134.56,11.15 v2(133.48,11.15)
REFCLK_CNV: length 51.4
  TOP w0.081: v6(127.92,34.47) 127.84,34.55 127.25,34.55 126.85,34.96 126.85,41.89 124.59,44.16 124.59,50.74 125.05,51.2 125.05,53.64 124.38,54.31 124.38,55.63 122.61,57.41 122.38,57.41 121.11,58.68 121.11,60.63 v6(121.82,61.34)
  BOTTOM w0.081: RW32.1 118.2,71.72 118.07,71.59 118.07,71.41 117.41,70.75 117.41,67.13 118.9,65.64 118.9,62.61 119.67,61.84 119.9,61.84 119.93,61.81 119.99,61.75 119.99,61.75 120.46,61.28 121.76,61.28 v6(121.82,61.34) ; v6(127.92,34.47) 128.33,34.47 128.7,34.11 129.34,33.99 129.83,33.99 v1(130.26,33.56) 131.92,31.9 131.92,31.37 RC86.1
  BOTTOM w0.089: RC86.1 132.36,31.03 132.36,31.51 LC5.2
REFCLK_CNV_L: length 8.9
  IN1 w0.064: v4(137.44,36.78) 137.44,35.56 135.44,33.56 v6(133.24,33.56)
  IN3 w0.064: v5(136.57,36.67) 136.75,36.84 137.37,36.84 v4(137.44,36.78)
  BOTTOM w0.089: v6(133.24,33.56) 133.08,33.4 132.74,33.4 132.45,33.11 LC5.1
REFCLK_CNV_R: length 7.4
  IN3 w0.064: v5(124.1,71.75) 123.44,71.75 122.99,72.2 122.99,72.58 121.82,73.75 119.98,73.75 118.53,72.3 v5(118.37,72.3)
RESET_N: length 1.6
  BOTTOM w0.102: UPD1.17 23.22,27.7 23.71,27.21 RPD124.2
RESET_OUT#: length 6.6
  TOP w0.081: v2(41.42,18.78) 41.42,17.94 41.31,17.83 RE22.1 41.01,16.7 40.98,16.67 RE550.1 ; UE1.B3 42.98,20.81 v2(42.91,20.89)
  IN1 w0.064: v2(42.91,20.89) 42.98,20.82 42.98,20.1 41.65,18.78 v2(41.42,18.78)
RESET_OUT#_R: length 68.1
  TOP w0.081: v2(131.18,57.18) 131.18,56.9 131.09,56.81 131.09,52.31 128.58,49.8 128.58,46.2 130.57,44.21 130.57,42.96 v1(131.53,42) 132.55,40.98 132.55,36.58 134.83,34.3 135.57,34.3 140.02,29.86 140.02,19.57 139.81,19.36 139.81,17.94 140.39,17.36 140.99,16.76 140.99,16.34 143.64,13.7 CC106.1 RC537.2 RC370.2 142.89,9.58 142.12,8.81 138.63,8.81 137.53,7.71 JXDP1.47
  IN1 w0.064: v2(131.18,57.18) 131.2,57.2 131.29,57.2 132.6,55.89 133.31,55.89 133.66,55.54 134.03,55.54 134.44,55.13 v2(134.44,54.47)
REXT_PS175: length 2.7
  TOP w0.081: v1(24.09,47.17) 23.75,47.17 23.62,47.04 RM13.1 23.3,46.72 24.11,45.91 UM1.20
ROM_SCLK: length 1.8
  TOP w0.081: RV381.1 96.92,65.34 v6(97.18,65.07) 97.25,65.07 RV80.2
  BOTTOM w0.081: UV1.C12 v6(97.18,65.07)
ROM_SI: length 1.5
  TOP w0.081: RV84.2 97.04,66.51 96.88,66.51 96.62,66.77 v6(96.62,66.86)
  BOTTOM w0.081: UV1.B12 v6(96.62,66.86)
ROM_SO: length 2.5
  TOP w0.081: RV81.2 96.48,66.28 96.48,66.43 96.22,66.69 96.22,67.28 v6(96.05,67.45)
  BOTTOM w0.081: UV1.A12 v6(96.05,67.45)
RTCRST_ON: length 27.9
  TOP w0.081: v2(59.1,28.84) 59.35,28.6 v1(59.35,27.71) D8.1 59.74,24.56 60.24,24.56 R65.1 R64.2 60.62,23.97 60.94,23.65 Q17.2
  IN1 w0.064: v2(59.1,28.84) 58.4,28.84 56.13,26.57 55.5,26.57 54.66,25.74 53.74,25.74 53.37,25.36 53.18,25.36 52.95,25.13 52.95,25.04 52.95,25.04 52.95,24.96 52.86,24.87 52.55,24.87 52.5,24.92 51.91,24.92 51.59,25.24 51.26,25.24 50.37,26.13 48.79,26.13 48.57,26.35 47.12,26.35 45.28,28.2 45.02,28.2 44.6,28.62 44.6,30.26 44.41,30.45 43.3,30.45 v2(43.23,30.38)
RTCRST_ON_R: length 6.1
  TOP w0.081: v3(58.55,20.82) 59.09,20.82 59.32,21.05 59.32,22.27 59.16,22.43 C2.1 58.97,22.86 D8.2 59.49,23.38 R64.1 60.24,22.97 Q18.2
RTD3_CIO_PWR_EN: length 141.5
  TOP w0.081: v2(27.16,52.67) 27.16,52.72 27.13,52.75 RT392.2
  IN1 w0.064: v4(27.9,52.56) 27.27,52.56 v2(27.16,52.67)
  IN2 w0.066: v4(43.32,54.32) 43.15,54.14 43.15,53.26 43.48,52.93 43.66,52.93 44.73,51.85 44.73,49.67 48.37,46.04 48.37,45.41 49.87,43.9 53.5,43.9 53.87,44.27 57.11,44.27 58.83,42.56 60.29,42.56 66.63,36.23 66.63,35.54 72.78,29.39 80.86,29.39 81.22,29.75 99.91,29.75 100.09,29.57 108.92,29.57 109.5,28.98 113.78,28.98 121.96,37.16 121.96,38.39 124.14,40.58 124.14,43.29 127.82,46.96 v4(128.02,46.96) 128.25,47.19 129.81,47.19 132.43,49.81 132.93,49.81 132.98,49.75 133.28,49.75 133.68,50.15 134.27,50.15 134.87,50.75 134.87,50.93 v4(135.28,51.34)
  IN3 w0.064: v4(27.9,52.56) 27.99,52.65 29.04,52.65 29.12,52.57 29.59,52.57 30.07,53.05 30.51,53.05 30.85,53.39 30.85,53.96 34.01,57.12 34.43,57.12 34.68,56.88 34.68,55.31 34.94,55.05 36.68,55.05 36.86,55.23 37.12,55.23 37.39,55.5 39.66,55.5 40.31,54.84 41.36,54.84 41.88,54.32 v4(43.32,54.32) ; v5(127.27,46.97) 128.02,46.97 v4(128.02,46.96)
  IN3 w0.089: v5(135.67,51.22) 135.63,51.26 135.38,51.26 135.34,51.3 135.33,51.3 v4(135.28,51.34)
  BOTTOM w0.081: v5(135.67,51.22) UC1.CN26 ; v5(127.27,46.97) v1(128.24,46.97)
RTD3_CIO_PWR_EN_R: length 4.3
  TOP w0.081: v1(29.48,54.02) 29.41,53.95 v2(28.94,53.95) 28.85,53.95 28.76,54.04 28.04,54.04 27.92,53.93 27.92,53.5 27.74,53.33 RT604.1 RT392.1 RT372.1
  IN1 w0.064: v2(28.94,53.95) 29.2,53.95 29.27,54.02 v4(29.27,54.07)
  IN3 w0.064: v4(29.27,54.07) 29.55,54.35 v5(29.59,54.35)
RTD3_USB_PWR_EN: length 1.2
  TOP w0.081: RT26.1 28.59,53.72 28.73,53.58 28.92,53.58 v2(28.93,53.57)
  IN1 w0.064: v2(28.93,53.57) 28.95,53.58 29.21,53.58 v4(29.27,53.52)
  IN3 w0.064: v5(29.59,53.7) 29.51,53.73 29.46,53.71 v4(29.27,53.52)
RUNPWROK: length 141.7
  TOP w0.081: v2(61.96,17.37) 61.96,17.41 63.02,18.47 RE508.1 ; v2(117.97,37.45) 118.74,36.68 119.01,36.68 119.78,35.91 121.91,35.91 122.69,36.68 124.37,36.68 v6(124.43,36.74) ; v2(63.07,15.94) 62.96,15.83 60.29,15.83 59.24,16.88 58.41,16.88 57.28,15.75 v1(56.92,15.75) 54.37,15.75 53.54,14.92 52.55,14.92 52.4,15.06 52.4,15.43 52.07,15.76 51.59,15.76 51.4,15.96 50.85,15.96 50.77,15.89 50.25,15.89 49.84,15.47 45.74,15.47 45.42,15.16 45.01,15.16 44.7,15.47 43.42,15.47 42.65,16.25 42.21,16.25 41.96,16.5 41.96,16.74 41.83,16.87 41.83,18.66 42.13,18.96 42.41,18.96 42.73,19.28 UE1.A2
  IN1 w0.064: v2(117.97,37.45) 117.97,37.33 117.5,36.86 116.29,36.86 116.23,36.92 115.35,36.92 114.36,37.91 112.06,37.91 112.05,37.89 112.05,37.89 111.83,37.68 111.83,37.67 111.6,37.44 111.6,37.32 110.85,36.57 110.85,34.27 111.85,33.26 111.85,33.25 113.78,31.32 113.78,29.35 113.58,29.15 113.58,26.35 112.73,25.51 112.73,24.91 111.84,24.02 111.84,21.77 111.66,21.59 108.01,21.59 107.79,21.37 106.34,19.91 106.34,18.98 104.43,17.07 98.41,17.07 98.06,16.71 93.19,16.71 91.49,15.01 91.49,13.77 90.21,12.49 87.25,12.49 86.72,13.01 85.49,13.01 85.44,12.97 84.46,12.97 84.45,12.98 83.87,12.98 83.72,13.12 75.59,13.12 74.53,14.19 67.65,14.19 67.1,14.74 66.49,14.74 65.22,16.02 63.14,16.02 v2(63.07,15.94) 63.07,16.26 v2(61.96,17.37)
  BOTTOM w0.081: UC10.2 122.11,53.8 121.79,53.48 121.79,51.16 122.21,50.74 122.69,50.74 125.46,47.97 125.46,47.39 127,45.85 127.52,45.85 127.89,45.48 127.89,43.82 127.09,43.03 126.85,43.03 125.21,41.39 125.21,41.07 125.19,41.05 125.18,41.05 125,40.86 124.86,40.86 124.64,40.64 124.64,40.53 124.43,40.32 v6(124.43,36.74)
SAO_UM4: length 2.3
  TOP w0.081: UM4.15 17.52,74.34 17.39,74.48 17.2,74.48 17.01,74.28 RM38.1
SAR_ACT#: length 77.8
  TOP w0.081: v2(53.36,41.81) 53.36,41.77 52.5,40.91 52.5,39.02 53.37,38.15 v1(53.37,36.32) 53.37,35.84 53.12,35.6 52.64,35.6 52.5,35.46 52.5,34.46 52.68,34.28 52.68,33.07 52.17,32.56 52.17,32.04 v2(52.29,31.92) ; UE1.A20 51.36,22.68 v2(51.36,22.68) ; RS10.2 71.33,72.6 71.21,72.48 v2(70.95,72.48)
  IN1 w0.064: v4(48.62,24.63) 49.06,24.19 49.16,24.19 50.1,23.25 50.79,23.25 v2(51.36,22.68) ; v2(53.36,41.81) 53.36,42.37 53.27,42.46 53.27,45.12 52.95,45.43 52.95,46.95 52.66,47.24 52.66,48.78 53.61,49.73 53.61,50.24 54,50.64 54,53.62 54.68,54.3 55.79,54.3 56.48,54.98 56.48,57.69 56.57,57.78 56.57,60.95 56.86,61.24 67.22,61.24 68.13,62.15 69.9,62.15 72.22,64.48 72.22,71.66 72.73,72.16 72.73,72.93 72.42,73.24 70.65,73.24 70.47,73.07 70.47,72.79 70.78,72.48 v2(70.95,72.48) ; v2(52.29,31.92) 52.29,31.27 v4(51.05,30.03)
  IN3 w0.064: v4(48.62,24.63) 48.99,24.99 51.48,24.99 51.98,25.49 51.98,26.48 51.34,27.12 51.34,29.74 v4(51.05,30.03)
SAR_DPR#: length 28.6
  TOP w0.081: v6(55.88,30.06) 56.81,30.99 56.81,34.57 v1(54.98,36.39) 53.83,37.55 53.83,38.69 53.75,38.77 v2(53.75,38.78) ; UE1.B50 42.48,29.42 v2(43.15,28.75)
  IN1 w0.064: v2(53.75,38.78) 53.79,38.74 56.61,38.74 v2(56.73,38.85) ; v4(42.94,29) 43.15,28.78 v2(43.15,28.75)
  IN2 w0.066: v4(42.94,29) 43.72,29.78 46.14,29.78 46.73,30.37 50.57,30.37 50.73,30.52 52.15,30.52 52.36,30.3 55.64,30.3 v6(55.88,30.06)
SAR_DPR_R: length 32.5
  TOP w0.081: v2(56.02,41.3) 55.88,41.16 54.15,41.16 53.68,40.69 53.68,39.65 54.57,38.76 v1(54.57,38.24) 54.57,37.96 55.32,37.21 RN3.2 55.81,37.21 56.33,37.21 56.43,37.3 QN7.1
  IN1 w0.064: v2(56.02,41.3) 56.05,41.33 58.71,41.33 59.13,41.75 59.13,42.2 60.1,43.16 60.12,43.16 60.12,43.16 60.36,43.16 60.36,43.16 60.5,43.16 61.09,42.57 61.9,42.57 62.02,42.69 62.02,42.7 62.3,42.98 62.3,42.98 62.7,43.37 62.7,53.24 60.83,55.11 59.33,55.11 59.26,55.17 v4(59.26,55.32)
  IN3 w0.064: v4(59.26,55.32) v5(59.26,57.08)
SATA_LED#: length 136
  TOP w0.081: Q16.2 39.74,45.33 40.78,46.37 40.99,46.37 v2(41.15,46.53) ; v2(68.87,33.6) 69.11,33.6 v1(70.21,34.7) 73.11,37.6 73.11,39.83 v6(72.83,40.12)
  IN1 w0.064: v2(41.15,46.53) 41.15,46.4 42.44,45.11 42.44,42.15 43.4,41.19 43.4,38.78 45.36,36.82 45.58,36.82 46.47,35.93 47.83,35.93 49.46,34.29 53.44,34.29 53.65,34.5 55.98,34.5 56.78,33.7 68.77,33.7 v2(68.87,33.6)
  IN3 w0.064: v5(131.19,39.36) 129.78,39.36 129.44,39.02 128.32,39.02 128.21,39.13 127.24,39.13 127.13,39.02 124.17,39.02 123.73,39.46 121.09,39.46 120.85,39.22 120.31,39.22 114.59,33.5 114.08,33.5 114.07,33.49 113.41,33.49 111.03,31.11 104.96,31.11 v5(104.56,31.51) 101.37,31.51 100.21,32.67 83.71,32.67 77.81,38.57 77.81,39.97 77.11,40.67 74.96,40.67 74.76,40.48 73.19,40.48 v6(72.83,40.12)
  BOTTOM w0.081: UC1.CN7 135.3,39.74 134.8,39.74 134.68,39.63 133.26,39.63 133.15,39.74 RC127.1 132.65,39.62 132.48,39.45 131.27,39.45 v5(131.19,39.36) ; JSSD1.10 108.53,18.77 107.15,20.16 107.15,23.62 107.72,24.2 107.72,28.35 v5(104.56,31.51)
SATA_LED#_Q16: length 2.9
  TOP w0.081: R31.2 40.98,43.73 40.98,44.04 40.58,44.43 40.58,45.24 40.68,45.33 Q16.5 Q16.6
SATA_LED#_R: length 6.1
  TOP w0.081: Q3.3 38.47,43.73 R30.2 40.35,44.29 39.95,44.68 Q16.3 38.51,45.37 38.51,45.89 v1(38.2,46.19)
SBO_UM4: length 1.6
  TOP w0.081: UM4.11 19.12,74.71 19.76,75.35 RM34.1
SCL_CHG: length 1.6
  BOTTOM w0.203: PRB16.1 193.12,24.96 193.61,24.47 PUB01.22
SCL_P: length 3
  TOP w0.081: PUV01.5 38.19,62.86 37.72,62.39 37.72,61.86 ZTV02.1 37.16,61.3 PRV49.2
SCL_P_CPU: length 4.8
  BOTTOM w0.203: PRZ03.2 162.38,19.27 PRZ08.1 161.26,19.27 160.46,20.07 160.46,20.81 160.25,21.03 160.25,21.39 159.96,21.68 PUZ01.33
SCLK_CPU: length 2
  BOTTOM w0.114: PUZ01.27 160.14,24.08 160.83,24.77 PRZ11.2
SCLK_CPU_R: length 1.5
  BOTTOM w0.114: PRZ22.2 162.55,24.76 162.5,24.82 PRZ27.1 162.21,25.06 162.1,24.95 PRZ11.1
SD_PWR_EN: length 191.1
  TOP w0.081: v2(44.85,35.57) 44.94,35.49 45.71,35.49 47.02,36.8 47.02,38.95 47.34,39.28 48.99,39.28 49.58,39.87 49.58,40.81 49.79,41.02 51.46,41.02 51.64,41.21 51.64,41.5 52.22,42.08 v1(52.22,44.78) v2(52.22,45.38) ; v2(13.09,32.26) 13.12,32.28 RR144.2
  IN1 w0.064: v2(44.85,35.57) 44.36,35.08 v4(44.36,33.11) ; v2(52.22,45.38) 52.11,45.49 v4(52.11,45.83) ; v4(11.25,31.98) 12.81,31.98 v2(13.09,32.26) ; v4(34.78,32.21) 34.65,32.08 34.65,30.48 33.46,29.3 33.33,29.3 32.99,29.3 32.98,29.3 32.77,29.3 32.5,29.57 v4(32.5,29.68)
  IN2 w0.066: v4(52.11,45.83) 52.14,45.83 52.38,46.06 60.87,46.06 60.93,45.99 61.16,45.77 61.27,45.77 64.68,42.36 64.68,41.16 67.47,38.37 69.01,38.37 69.07,38.31 69.09,38.31 71.65,35.75 72.93,35.75 72.93,35.74 74.05,35.74 75.03,34.76 75.46,34.76 77.06,33.15 77.06,32.89 77.93,32.02 78.68,32.02 79.19,31.51 80.25,31.51 80.98,32.24 100.51,32.24 101.09,31.66 109.42,31.66 110.85,33.09 112.26,33.09 112.75,33.58 115.46,33.58 118.55,36.67 118.55,40.38 120.34,42.17 120.99,42.17 122.73,43.91 122.73,44.56 125.24,47.07 125.24,49.77 125.7,50.22 127.99,50.22 128.41,49.81 129.37,49.81 129.53,49.81 131.79,52.07 131.79,54.58 134.66,57.44 137.31,57.44 137.64,57.11 139.04,57.11 139.15,57 139.86,57 140.69,56.17 141.85,56.17 142.18,55.85 v4(142.27,55.85) ; v4(11.25,31.98) 12.08,31.98 12.15,31.91 12.15,24.32 13.06,23.41 13.76,23.41 14.63,24.28 14.96,24.28 15.58,24.9 15.58,26.61 16.84,27.87 18.27,27.87 19.16,26.97 20.52,26.97 21.18,26.32 24.99,26.32 26.13,27.46 26.59,27.46 27.74,26.31 29.34,26.31 32.5,29.47 v4(32.5,29.68)
  IN3 w0.064: v4(34.78,32.21) 35.05,32.21 35.54,32.7 37.41,32.7 38.79,31.32 40.13,31.32 40.39,31.58 41.36,31.58 42.07,30.88 43.87,30.88 44.6,31.6 44.6,32.85 44.36,33.09 v4(44.36,33.11) ; v5(143.71,57.66) 142.68,56.63 142.68,56.36 142.27,55.95 v4(142.27,55.85)
SD_PWR_EN_R: length 4.3
  TOP w0.081: U6903.4 12.08,32 12.34,31.74 v1(13.4,31.74)
  TOP w0.254: RR167.1 RR144.1 U6903.4
SD_RCOMP: length 2.7
  TOP w0.305: v1(138.9,56.8) 138.71,56.61 v2(138.05,56.61)
  IN1 w0.305: v2(138.05,56.61) 137.89,56.45 137.89,56.4 v4(137.84,56.35)
  IN3 w0.254: v5(137.45,56.15) 137.63,56.15 v4(137.84,56.35)
  BOTTOM w0.305: UC1.CM34 136.93,56.47 137.25,56.15 v5(137.45,56.15)
SD_READ_MODE: length 5.3
  TOP w0.081: v1(138.42,59.04) 138.71,58.75 RI55.1 139.48,57.9 v2(140.49,58.91)
  IN1 w0.064: v4(140.95,58.83) 140.57,58.83 v2(140.49,58.91)
  IN3 w0.064: v4(140.95,58.83) 140.93,58.81 140.93,58 v5(140.97,57.95)
  BOTTOM w0.081: UC1.CC36 141.2,57.76 141.02,57.94 140.98,57.94 v5(140.97,57.95)
SD_WP: length 2.9
  TOP w0.081: v2(138.35,57.47) 138.13,57.7 RI55.2 137.35,57.9 v1(137.19,57.74)
  IN1 w0.064: v4(137.83,57.49) 138.34,57.49 v2(138.35,57.47)
  IN3 w0.064: v5(137.62,57.17) 137.62,57.24 137.83,57.44 v4(137.83,57.49)
  BOTTOM w0.081: v5(137.62,57.17) UC1.CK34
SDA_CHG: length 1.4
  BOTTOM w0.203: PUB01.21 193.22,24.07 193.1,24.19 PRB14.1
SDA_P: length 2.3
  TOP w0.081: PUV01.4 37.79,63.26 ZTV01.1 37.1,62.57 PRV50.2
SDA_P_CPU: length 6.6
  BOTTOM w0.203: PUZ01.32 159.84,22.08 159.91,22.01 160.14,22.01 160.66,21.5 v1(160.66,21.29) 160.66,21.25 160.79,21.11 160.79,20.21 161.1,19.9 162.69,19.9 163,19.6 163.02,19.6 PRZ09.1 163.86,19.27 PRZ02.2
SDIO_0_CD#: length 203.1
  TOP w0.081: v1(16.78,22.5) RR156.2 v2(15.93,21.91)
  IN1 w0.064: v4(107.73,37.7) 108.33,37.1 108.87,37.1 110.02,35.95 110.02,31.71 110.01,31.7 110.01,31.53 108.01,29.52 108.01,25.39 103.21,20.6 97.91,20.6 96.35,19.03 92.56,19.03 90.83,17.3 89.73,17.3 89.24,16.82 69.74,16.82 69.09,17.46 67.71,17.46 65.34,19.84 58.62,19.84 58.07,20.38 58.07,21.1 v4(58.32,21.36) ; v2(15.93,21.91) 15.93,21.45 15.43,20.95 v4(15.43,19.1)
  IN3 w0.064: v4(58.32,21.36) 58.31,21.37 58.2,21.37 56.17,19.34 56.17,18.78 54.37,16.98 53.86,16.98 51.52,14.65 51.52,13.97 51.13,13.58 51.13,9.43 50.43,8.73 49.3,8.73 48.46,7.88 43.56,7.88 42.43,6.76 36.69,6.76 32.17,11.28 20.26,11.28 20.08,11.46 16,11.46 15.82,11.64 15.82,12.98 14.78,14.02 14.78,18.46 v4(15.43,19.1) ; v5(138.68,57.01) 138.95,56.74 138.95,55.17 138.11,54.33 138.11,53.6 137.24,52.73 135.47,52.73 134.16,51.42 132.21,51.42 131.94,51.15 131.92,51.15 131.91,51.14 128,51.14 128,51.15 127.9,51.15 127.11,51.93 125.22,51.93 123.31,53.84 118.45,53.84 118.01,53.4 117.81,53.4 117.48,53.06 115.8,53.06 114.97,52.24 113.79,52.24 113.7,52.15 113.7,51.91 113.64,51.85 113.52,51.85 113.46,51.91 113.46,52.23 113.36,52.32 112.87,52.32 109.76,49.22 109.76,49.13 109.85,49.04 109.93,49.04 112.54,51.65 112.63,51.65 112.71,51.57 112.71,51.48 109.94,48.71 109.94,48.63 110.03,48.54 110.12,48.54 113.09,51.51 113.18,51.51 113.26,51.43 113.26,51.34 109.75,47.83 109.32,47.83 108.45,46.96 108.45,44 107.78,43.33 107.78,38.65 107.62,38.48 107.62,37.81 v4(107.73,37.7)
SDIO_0_CLK: length 193.5
  TOP w0.081: JREAD1.5 2.42,24.66 v6(2.52,24.56)
  IN1 w0.064: v4(108.62,33.08) 108.94,32.76 108.94,31.91 107.04,30.01 107.04,25.59 102.89,21.44 96.35,21.44 95.71,20.8 92.76,20.8 90.15,18.19 88.85,18.19 88.32,17.65 75.28,17.65 74.7,18.22 73.09,18.22 72.54,18.78 68.36,18.78 66.37,20.77 61.49,20.77 61.38,20.88 58.7,20.88 v4(58.45,20.63)
  IN3 w0.064: v4(58.45,20.63) 58.45,20.63 58.29,20.47 58.29,19.87 54.58,16.16 53.93,16.16 52.29,14.51 52.29,13.83 51.8,13.35 51.8,9.2 49.85,7.25 44.57,7.25 43.28,5.95 43.07,5.95 43.04,5.98 38.63,5.98 38.18,5.53 36.65,5.53 32.64,9.54 8.86,9.54 8.48,9.92 8.48,10.46 7.93,11.01 6.85,11.01 6.5,11.36 6.5,16.66 5.53,17.63 5.14,17.63 4.71,18.06 4.71,23.18 v5(4.08,23.81) ; v4(108.62,33.08) 108.41,33.29 107.54,33.29 107.15,33.68 106.77,33.68 106.09,34.36 105.94,34.36 105.66,34.64 105.17,34.64 104.93,34.89 104.93,35.73 103.59,37.06 103.59,40.12 104.61,41.14 104.61,43.46 104.42,43.65 104.42,47.6 110.83,54.01 111.25,54.01 111.85,54.61 113.28,54.61 113.72,55.05 113.79,55.05 114.73,55.99 116.34,55.99 118.07,57.72 122.04,57.72 123.34,56.42 126.86,56.42 126.9,56.46 127.62,56.46 128.33,57.17 v5(129.51,57.17)
  BOTTOM w0.081: v5(129.51,57.17) 129.51,57.34 129.73,57.56 CC110.1 129.97,57.99 129.96,57.99 129.96,58.42 130.19,58.65 130.19,58.78 130.49,59.08 RC555.2 ; v6(2.52,24.56) 2.87,24.21 RR132.1 3.17,24.1 3.45,23.81 v5(4.08,23.81)
SDIO_0_CLK_R: length 7
  BOTTOM w0.081: RC555.1 132.01,59.08 132.93,58.17 134.77,58.17 134.96,57.99 136.44,57.99 136.82,57.61 UC1.CK36
SDIO_0_CMD: length 199.5
  IN1 w0.064: v4(107.01,37.68) 107.21,37.68 108.05,36.84 108.85,36.84 109.82,35.87 109.82,34.69 109.77,34.63 109.51,34.63 109.45,34.57 109.45,34.45 109.51,34.39 109.77,34.39 109.82,34.33 109.82,34.2 109.77,34.14 109.51,34.14 109.45,34.08 109.45,33.96 109.51,33.9 109.77,33.9 109.82,33.84 109.82,33.71 109.77,33.65 109.51,33.65 109.45,33.59 109.45,33.47 109.51,33.41 109.77,33.41 109.82,33.35 109.82,31.79 107.67,29.63 107.67,25.33 103.15,20.81 97.85,20.81 96.27,19.23 92.44,19.23 90.7,17.49 89.34,17.49 88.86,17.01 69.81,17.01 69.17,17.66 67.79,17.66 65.42,20.03 58.94,20.03 v4(58.76,20.2)
  IN3 w0.064: v4(58.76,20.2) 58.76,20.2 58.76,19.86 52.12,13.22 52.12,9.07 49.98,6.93 44.71,6.93 42.98,5.21 42.67,5.21 42.62,5.26 42.62,5.46 42.48,5.6 42.27,5.6 42.14,5.47 42.14,5.38 41.97,5.21 41.74,5.21 41.57,5.38 41.57,5.52 41.46,5.63 41.13,5.63 41,5.5 41,5.38 40.83,5.21 40.6,5.21 40.43,5.38 40.43,5.46 40.26,5.63 40.03,5.63 39.86,5.46 39.86,5.32 39.75,5.21 39.4,5.21 39.29,5.32 39.29,5.4 39.13,5.56 38.89,5.56 38.72,5.4 38.72,5.27 38.66,5.21 36.47,5.21 32.49,9.2 7.32,9.2 4.39,12.13 4.39,21.92 v5(3.99,22.33) ; v4(107.01,37.68) 107.01,38.42 107.59,39 107.59,43.41 108.26,44.08 108.26,47.39 108.99,48.12 109.39,48.12 109.68,48.41 109.68,48.75 109.48,48.95 109.48,49.21 112.79,52.52 114.98,52.52 115.72,53.25 117.4,53.25 117.74,53.59 117.93,53.59 118.38,54.03 123.39,54.03 125.3,52.13 127.21,52.13 128.06,51.28 131.85,51.28 132.13,51.56 134.06,51.56 135.39,52.89 137.16,52.89 137.83,53.56 137.83,54.32 138.64,55.13 138.64,56.54 138.39,56.78 138.39,57.38 v5(138.68,57.66)
  BOTTOM w0.081: v5(3.99,22.33) RR127.1
SDIO_0_CMD_R: length 2.3
  TOP w0.135: JREAD1.3 v6(2.54,22.46)
  BOTTOM w0.081: v6(2.54,22.46) 2.97,22.88 RR127.2
SDIO_0_DATA0: length 198.4
  IN1 w0.064: v4(107.61,34.63) 107.56,34.58 107.56,33.56 107.83,33.29 107.83,32.67 107.67,32.5 107.67,31.58 106.4,30.31 106.4,25.86 102.62,22.08 96.01,22.08 95.37,21.43 92.5,21.43 90.15,19.08 88.85,19.08 88.08,18.32 76.5,18.32 76.14,18.68 75.59,18.68 74.93,19.34 74.48,19.34 73.9,19.92 68.12,19.92 66.5,21.54 63.01,21.54 62.48,22.07 58.31,22.07 v4(58.29,22.08)
  IN3 w0.064: v5(3.72,25.35) 4.84,24.23 5.42,24.23 6.13,23.52 6.13,17.47 6.82,16.79 6.82,11.49 6.98,11.33 8.35,11.33 8.53,11.14 19.95,11.14 20.13,10.96 31.91,10.96 36.42,6.44 42.57,6.44 43.69,7.56 49.71,7.56 51.45,9.3 51.45,13.45 51.9,13.9 51.9,14.58 53.92,16.6 54.54,16.6 57.83,19.9 57.83,20.56 58.27,20.99 58.63,20.99 58.69,21.06 58.69,21.68 v4(58.29,22.08) ; v4(107.61,34.63) 107.61,35.5 105.99,37.12 105.99,39.75 106.77,40.53 106.77,44.16 107.34,44.73 107.34,46.4 107.28,46.46 106.92,46.46 106.86,46.52 106.86,46.72 106.92,46.78 107.28,46.78 107.34,46.84 107.34,47.03 107.28,47.09 106.92,47.09 106.86,47.15 106.86,47.35 106.92,47.41 107.28,47.41 107.34,47.47 107.34,47.66 107.28,47.72 106.92,47.72 106.86,47.78 106.86,47.98 106.92,48.04 107.34,48.04 107.52,48.22 107.52,48.53 108.17,49.18 108.55,49.18 112.53,53.15 114.72,53.15 115.46,53.89 117.14,53.89 117.91,54.66 118.15,54.66 118.64,55.15 120.16,55.15 120.37,55.35 121.52,55.35 122.21,54.67 123.65,54.67 124.96,53.36 125.95,53.36 126.54,52.77 127.07,52.77 127.99,51.86 133.86,51.86 135.91,53.91 136.6,53.91 137.5,54.81 137.5,55.38 137.04,55.84 v5(137.04,57.06)
  BOTTOM w0.081: v5(3.72,25.35) RR123.1
SDIO_0_DATA0_R: length 4
  TOP w0.081: v6(2.49,26.64) 2.27,26.86 JREAD1.7
  BOTTOM w0.081: RR123.2 2.96,24.79 2.77,24.98 2.44,24.98 2.13,25.29 v1(2.13,25.81) 2.13,26.29 v6(2.49,26.64)
SDIO_0_DATA1: length 199.6
  IN1 w0.064: v4(59.82,20.39) 66.31,20.39 68.18,18.51 69.64,17.91 73.83,17.91 75.23,17.33 88.44,17.33 88.99,17.87 90.28,17.87 91.99,19.58 93.69,19.58 97.42,21.12 103.02,21.12 107.36,25.46 107.36,29.83 109.38,31.85 v4(109.38,32.4)
  IN3 w0.064: v4(59.82,20.39) 59.79,20.36 59.79,19.41 53.07,12.69 53.07,8.68 50.37,5.98 45.1,5.98 43.38,4.26 35.74,4.26 31.75,8.24 6.93,8.24 3.43,11.74 3.43,19.75 3.55,19.87 3.55,22.74 3.44,22.85 3.44,25.63 v5(3.72,25.91) ; v4(109.38,32.4) 109.38,34.41 108.45,35.34 108.22,35.34 106.65,36.91 106.65,38.71 107.11,39.17 107.11,43.38 107.94,44.21 107.94,48.12 112.66,52.83 114.85,52.83 115.59,53.57 117.27,53.57 117.6,53.9 117.8,53.9 118.24,54.35 123.52,54.35 124.83,53.04 125.82,53.04 126.33,52.53 127.08,52.53 127.89,51.72 133.95,51.72 135.32,53.09 136.88,53.09 137.59,53.8 137.59,54.39 137.66,54.46 137.66,55.42 137.21,55.87 137.21,56.66 137.31,56.76 137.31,57.04 137.09,57.57 v5(136.93,57.95)
  BOTTOM w0.081: v5(3.72,25.91) RR124.1
SDIO_0_DATA1_R: length 2.5
  TOP w0.081: JREAD1.8 1.83,27.96 v6(2.4,27.39)
  BOTTOM w0.081: v6(2.4,27.39) 3.14,26.65 RR124.2
SDIO_0_DATA2: length 200.1
  IN1 w0.064: v4(59.28,22.94) 59.3,22.92 59.59,22.92 59.79,23.13 66.91,23.13 68.59,21.45 75.02,21.45 75.3,21.17 77.92,21.17 80.13,18.96 87.83,18.96 88.58,19.72 88.87,19.72 90.46,21.3 91.14,21.3 91.66,21.82 91.66,21.82 92.08,22.24 92.84,22.24 93.33,22.72 101.86,22.72 103.3,24.16 103.3,27.26 105.58,29.54 105.58,30.65 106.85,31.92 106.85,34.49 106.8,34.54 106.8,34.74 v4(106.85,34.79)
  IN3 w0.064: v5(3.76,19.65) 3.76,11.86 7.06,8.56 32.09,8.56 36.08,4.57 43.25,4.57 44.97,6.29 50.24,6.29 52.75,8.81 52.75,12.83 54.84,14.91 54.84,14.91 59.48,19.55 59.48,20.21 59.46,20.23 59.46,20.71 59.69,20.95 59.69,21.21 58.49,22.41 58.49,22.82 58.74,23.06 59.11,23.06 59.24,22.94 v4(59.28,22.94) ; v5(136.52,57.45) 136.7,57.27 136.7,55.99 137.36,55.32 137.36,54.87 136.55,54.06 135.67,54.06 134.35,52.74 132.77,52.74 130.85,54.67 130.85,56.25 130.7,56.4 128.45,56.4 128.26,56.2 128.26,55.26 127.36,54.36 126.92,54.36 126.6,54.68 126.52,54.68 125.42,55.78 123.08,55.78 121.8,57.06 118.8,57.06 118.42,56.68 118.39,56.68 116.52,54.82 115.22,54.82 114.38,53.98 112.11,53.98 111.51,53.38 111.09,53.38 105.64,47.93 105.64,41.27 104.42,40.05 104.42,37.31 106,35.73 106,35.46 106.21,35.25 106.41,35.25 106.85,34.81 v4(106.85,34.79)
  BOTTOM w0.081: v5(3.76,19.65) 3.99,19.88 RR163.2 RR125.1
SDIO_0_DATA2_R: length 2.2
  TOP w0.081: v6(2.38,20.5) 1.79,20.26 JREAD1.1
  BOTTOM w0.081: RR125.2 2.74,20.65 v6(2.38,20.5)
SDIO_0_DATA3: length 200.1
  IN1 w0.064: v4(59.14,21.25) 59.19,21.2 61.81,21.2 61.91,21.09 66.5,21.09 67.94,19.65 69.28,19.1 73.72,19.1 76.4,17.99 88.2,17.99 88.95,18.74 90.24,18.74 90.27,18.76 90.28,18.76 92.63,21.12 95.58,21.12 96.22,21.76 102.75,21.76 106.72,25.73 106.72,30.14 108.12,31.54 108.44,32.3 108.44,32.52 108.15,33.2 108.15,33.59 v4(107.97,33.77)
  IN3 w0.064: v4(59.14,21.25) 59.14,20.11 59.16,20.1 59.16,19.68 52.44,12.96 52.44,8.94 50.11,6.61 44.84,6.61 43.12,4.89 36.24,4.89 32.25,8.88 7.19,8.88 4.08,12 4.08,21.56 v5(3.99,21.77) ; v4(107.97,33.77) 107.64,33.77 107.05,34.36 106.72,34.36 106.27,34.8 106.21,34.8 105.68,35.33 105.68,35.6 104.29,36.99 104.1,37.17 104.1,39.92 104.1,40.18 104.93,41.01 104.93,43.59 104.74,43.78 104.74,47.47 110.96,53.69 111.38,53.69 111.98,54.29 113.41,54.29 113.85,54.73 113.92,54.73 114.86,55.67 116.48,55.67 118.21,57.4 121.91,57.4 123.21,56.1 126.22,56.1 127.09,55.23 127.6,55.23 127.91,55.54 127.91,56.3 128.36,56.75 130.8,56.75 131.17,56.37 131.17,54.82 133.1,52.9 133.57,52.9 134.03,53.37 134.03,53.67 134.57,54.2 136.48,54.2 137.19,54.91 137.19,55.3 136.45,56.04 v5(136.45,56.97)
  BOTTOM w0.081: UC1.CN35 136.38,57.04 v5(136.45,56.97) ; RR126.1 v5(3.99,21.77)
SDIO_0_DATA3_R: length 2.2
  TOP w0.081: JREAD1.2 2.15,21.36 v6(2.4,21.11)
  BOTTOM w0.081: RR126.2 2.5,21.21 v6(2.4,21.11)
SDIO_0_R_CD#: length 2.6
  TOP w0.081: JREAD1.9 14.74,22.78 15.02,22.5 RR156.1 15.35,23.39 v1(15.39,23.43)
SDIO_CPU: length 1.7
  BOTTOM w0.114: PUZ01.28 160.55,23.68 PRZ13.2
SDIO_CPU_R: length 5.2
  IN3 w0.114: v5(163.33,22.26) 163.33,23.08 v5(163.32,23.09)
  BOTTOM w0.114: v5(163.33,22.26) v1(164.25,22.26) PRZ29.1 ; v5(163.32,23.09) 162.87,23.09 162.55,23.4 PRZ24.2 162.42,23.75 161.98,23.75 PRZ13.1
SHD_CLK: length 1.4
  TOP w0.081: UE1.A23 51.93,24.18 52.29,24.54 RC524.2
SHD_CS0#: length 8
  TOP w0.081: UE1.B24 50.35,23.93 50.03,24.26 v2(50.03,24.43) ; RE536.2 55.03,25.12 RE516.2 55.04,24.55 RC556.2 54.81,24.75 54.71,24.75 v2(54.5,24.96)
  IN1 w0.064: v2(50.03,24.43) 50.03,24.55 50.19,24.72 50.7,24.72 51.29,24.13 52.18,24.13 52.24,24.07 53.6,24.07 v2(54.5,24.96)
SHD_IO0: length 1.3
  TOP w0.081: UE1.A22 51.68,23.68 51.95,23.42 52.4,23.42 RC525.2
SHD_IO1: length 6.3
  TOP w0.081: v2(52.1,22.68) 52.1,21.43 52.29,21.25 RC526.2 ; v2(49.78,24.01) 49.73,23.95 49.73,23.46 50.26,22.93 UE1.B22
  IN1 w0.064: v2(52.1,22.68) 52.03,22.68 50.8,23.91 50.42,23.91 50.32,24.02 49.8,24.02 v2(49.78,24.01)
SHD_IO2: length 4.4
  TOP w0.081: v2(52.55,22.42) 52.55,22.42 RC527.2 ; UE1.B23 50.18,23.43 50.08,23.54 v2(50.08,23.72)
  IN1 w0.064: v2(52.55,22.42) 52.52,22.39 51.96,22.39 51.8,22.54 51.8,22.64 50.72,23.72 v2(50.08,23.72)
SHD_IO3: length 1.2
  TOP w0.081: UE1.A21 51.9,23.18 52.09,22.99 RC528.2
SIO_EXT_WAKE#: length 144.9
  TOP w0.081: v2(78.52,9.23) 78.52,9.86 77.83,10.55 77.83,12.77 v1(77.92,12.85) v6(77.92,14.64) ; v2(139.67,42.94) 140.05,42.94 140.18,42.81 RC113.1 ; UE1.A57 v2(40.73,24.68)
  IN1 w0.064: v4(40.22,16.4) 39.95,16.13 39.95,15.54 40.49,15 41.25,15 42.82,13.43 43.38,13.43 43.88,12.93 49.76,12.93 50.07,13.23 53.4,13.23 54.73,14.57 57.56,14.57 59.49,12.64 59.49,12.17 61.91,9.74 70.91,9.74 71.62,9.03 75.76,9.03 76.06,9.33 78.43,9.33 v2(78.52,9.23) ; v2(40.73,24.68) 40.41,24.68 v4(40.24,24.86) ; v2(139.67,42.94) 139.64,42.97 v4(139.33,42.97)
  IN2 w0.066: v4(139.33,42.97) 139.32,42.96 139.32,42.87 138.73,42.27 138.17,42.27 137.9,42.54 135.78,42.54 134.97,41.73 134.97,40.75 133.85,39.62 133.85,36.54 134.39,35.99 134.39,33.89 132.31,31.81 132.31,28.22 129.43,25.34 129.43,23.26 129.29,23.12 128.54,23.12 128.32,23.34 126.14,23.34 124.31,21.51 124.31,19.68 122.88,18.24 122.72,18.24 121.83,18.24 118.46,14.87 117.99,14.87 117.95,14.83 111.85,14.83 111.41,15.26 92.8,15.26 92.57,15.04 89.16,15.04 88.32,15.88 81.91,15.88 80.67,14.64 v6(77.92,14.64)
  IN3 w0.064: v4(40.22,16.4) 40.06,16.56 40.06,17.81 40.3,18.06 40.3,19.61 40.67,19.97 40.67,21.98 40.3,22.34 40.3,23.27 40.5,23.47 40.5,24.59 v4(40.24,24.86) ; v5(139.19,42.63) 139.19,42.76 139.33,42.91 v4(139.33,42.97)
SIO_PWRBTN#: length 188.4
  TOP w0.081: v2(44.98,21.21) UE1.B7 ; v2(145.15,52.26) 145.21,52.26 145.28,52.33 RC98.1
  IN1 w0.064: v2(44.98,21.21) 44.98,21.08 43.66,19.76 v4(43.66,19.65) ; v4(145.45,52.47) 145.37,52.47 145.3,52.4 145.3,52.32 145.24,52.26 v2(145.15,52.26) ; v4(37.48,19.43) 37.54,19.37 37.54,17.43 37.03,16.93 37.03,14.98 38.1,13.92 38.1,11.67 40.82,8.95 42.68,8.95 42.98,8.66 44.11,8.66 45.68,7.09 49.77,7.09 50.72,6.15 50.95,6.15 51.52,5.58 51.52,4.74 51.91,4.35 99.3,4.35 99.74,4.79 100.93,4.79 101.31,5.17 110.87,5.17 113.14,7.44 113.54,7.44 113.75,7.23 113.75,6.76 113.88,6.63 115.09,6.63 116.93,8.47 118.65,8.47 120.3,10.12 120.3,11.4 121.12,12.22 122.64,12.22 122.83,12.04 125.41,12.04 127.05,13.68 127.61,13.68 127.95,13.34 133.22,13.34 133.5,13.62 133.64,13.62 134,13.98 v4(134,13.98)
  IN2 w0.066: v4(145.45,52.47) 146.08,51.84 146.08,50.98 145.28,50.18 145.28,49.72 145.6,49.41 145.6,47.95 145.68,47.87 145.68,47.87 145.81,47.75 145.84,47.75 145.84,47.74 146.24,47.74 146.25,47.75 146.31,47.75 146.47,47.9 146.47,48.4 146.8,48.73 147.16,48.73 147.65,48.24 147.65,43.92 147.65,43.92 147.65,43.52 147.65,43.22 147.65,43.22 147.65,42.89 148.11,42.43 148.11,40.81 149.14,39.78 149.31,39.78 149.55,39.54 149.55,39.41 151.03,37.94 151.03,32.48 149.74,31.19 146.99,31.19 145.3,29.5 145.3,28.23 145.95,27.59 148.99,27.59 149.19,27.4 149.19,22.06 147.6,20.47 143.84,20.47 140.73,17.36 134.71,17.36 133.76,16.41 133.76,14.57 134,14.33 v4(134,13.98) ; v4(37.48,19.43) 37.86,19.05 41.78,19.05 42.24,19.51 43.52,19.51 v4(43.66,19.65)
  IN3 w0.064: v5(145.1,52.72) 145.11,52.72 145.32,52.51 145.4,52.51 v4(145.45,52.47)
SIO_SLP_A#: length 27.7
  TOP w0.081: v2(131.45,72.83) 131.45,72 131.63,71.81 v1(131.63,71.56)
  IN1 w0.064: v2(144.45,57.21) 144.45,57.25 144.47,57.28 144.47,57.47 144.41,57.53 v4(144.41,57.54) 144.41,57.55 144.33,57.63 144.33,57.68 144.32,57.69 144.32,58.41 140.32,62.4 139.61,62.4 139.07,62.4 137.82,63.65 136.82,63.65 135.8,64.68 133.3,64.68 132.91,64.29 132.43,64.29 131.45,65.27 131.45,69.17 131.96,69.69 131.96,72.07 131.45,72.58 v2(131.45,72.83)
  IN3 w0.064: v5(144.77,58) 144.69,57.92 144.69,57.82 v4(144.41,57.54)
  BOTTOM w0.135: UC1.BU37 144.9,58.31 144.77,58.18 v5(144.77,58)
SIO_SLP_S0#: length 175
  TOP w0.081: v2(113.73,16.86) 114.01,17.14 114.01,17.35 115.53,18.88 v1(115.53,20.35) 115.53,23.76 117.45,25.68 117.45,29.96 115.76,31.65 110.67,31.65 110.35,31.97 110.35,38.09 110,38.45 110,39.01 v2(108.67,40.34)
  IN1 w0.064: v4(157.39,15.13) 156.86,15.65 156.19,15.65 155.85,15.98 155.85,16.09 154.01,17.93 151.06,17.93 148.02,20.98 143.73,20.98 143.5,20.75 140.51,20.75 140.36,20.6 138.64,20.6 138.4,20.35 132.55,20.35 131.9,21 124.95,21 122.52,18.57 119.19,18.57 116.77,16.15 114.44,16.15 v2(113.73,16.86) ; v4(136.64,60.81) 136.61,60.84 136.61,60.88 136.58,60.9 136.58,61.19 136.7,61.31 136.7,61.98 136.47,62.21 136.47,62.77 135.97,63.28 135.97,63.42 135.41,63.99 133.56,63.99 133.19,63.61 132.29,63.61 130.68,65.23 130.68,69.08 129.23,70.52 129.23,71.52 128.61,72.13 127.62,72.13 v2(126.95,72.81) ; v2(108.67,40.34) 108.67,40.22 108.44,39.99 107.56,39.99 106.95,40.6 105.51,40.6 105.16,40.25 v4(105.13,40.25)
  IN2 w0.066: v4(157.39,15.13) 158.07,15.81 158.78,15.81 160.06,17.09 v4(163.36,17.09) ; v4(136.64,60.81) 136.57,60.88 136.51,60.88 136.49,60.91 135.91,60.91 133.61,58.61 132.29,58.61 131.77,58.08 129.64,58.08 127.98,56.42 127.98,54.62 127.58,54.22 127.42,54.22 127.37,54.26 116.85,54.26 110.68,48.1 110.68,46.66 105.13,41.11 v4(105.13,40.25)
  IN3 w0.064: v5(137.5,63.36) 137.31,63.17 136.87,63.17 136.59,62.89 136.59,62.45 136.69,62.35 136.69,61.26 136.58,61.15 136.58,60.9 136.61,60.88 136.61,60.84 v4(136.64,60.81) ; v4(163.36,17.09) v5(163.36,16.72)
  BOTTOM w0.081: v5(137.5,63.36) 137.4,63.27 RC211.1 137.6,63.05 137.89,63.34 148.65,63.34 150.62,61.37 150.62,59.64 150.05,59.07 UC1.BJ37
  BOTTOM w0.089: PRZ07.1 163.04,16.72 v5(163.36,16.72)
SIO_SLP_S3: length 2.8
  TOP w0.081: v1(56.96,17.31) 58.52,17.31 59.25,18.04 QE11.2
SIO_SLP_S3#: length 362.3
  TOP w0.081: v2(107.28,17.24) 104.16,20.35 DZ6.1 103.33,20.35 RZ3.1 ; v2(49.58,48) v1(49.58,46.75) 49.58,46.72 49.28,46.42 U19.3 v2(49.28,44.4) ; v2(74.66,11.5) 75.3,12.14 75.3,13.65 75.65,13.99 75.65,15.24 75.08,15.8 75.08,19.98 v2(74.78,20.28) ; v2(62.75,13.67) 62.75,13.92 63.46,14.63 63.46,16.11 63.24,16.33 61.99,16.33 61.81,16.5 Q29.2 ; U10.2 127.15,16.45 126.92,16.69 126.29,16.69 125.63,16.03 124.49,16.03 123.85,16.66 123.85,27.71 v6(124.15,28) 123.98,28.17 123.98,34.75 122.9,35.82 v2(122.9,35.83) ; v2(145.54,58.1) RC10.2 ; UZ3.5 91.59,24.08 91.65,24.02 v2(91.65,23.83) 91.65,23.16 91.49,23 91.49,20.42 88.89,17.83 88.89,14.8 88.24,14.15 88.24,14.09 87.29,13.14 87.29,12.39 85.66,10.76 84.61,10.76 84.2,11.16 84.2,11.28 v2(84.23,11.3) ; UZ3.3 90.79,23.84 v2(90.8,23.82)
  IN1 w0.064: v2(133.44,72.83) 133.44,72.44 132.63,71.62 132.63,70.56 133.2,69.99 135,69.99 136.46,68.53 136.46,66.69 139.61,63.54 140.8,63.54 144.37,59.98 144.37,59.32 145.14,58.55 v4(145.14,58.26) 145.38,58.26 v2(145.54,58.1) ; v2(90.8,23.82) 90.81,23.83 v2(91.65,23.83) ; v2(40.98,73.57) 41.42,73.57 43,71.99 43,70.37 45.46,67.9 47.3,67.9 47.67,67.53 48.73,67.53 48.73,67.53 48.82,67.53 49.64,66.71 49.64,64.5 51.13,63.01 51.13,60.94 52.84,59.22 52.84,55.33 52.86,55.32 52.86,50.62 52.81,50.57 52.81,50.01 51.9,49.1 51.9,48.47 51.42,48 49.59,48 v2(49.58,48) ; v4(51.1,42.55) 51.1,42.59 49.29,44.4 v2(49.28,44.4) ; v4(136.31,51.25) 136.49,51.42 v2(137.4,51.42) 137.5,51.42 137.92,51.85 139.6,51.85 139.61,51.87 139.62,51.87 140.02,52.27 140.54,52.27 140.72,52.45 140.76,52.45 141.15,52.45 141.9,53.19 143.12,53.19 143.38,53.45 144.95,53.45 145.18,53.69 v4(145.18,53.88) ; v6(124.15,28) 125.02,27.13 125.02,25.49 124.03,24.5 122.88,24.5 122.14,23.77 118.19,23.77 115.62,21.2 115.62,20.76 115.54,20.68 115.54,20.68 113.78,18.91 113.77,18.91 113.61,18.75 111.82,18.75 111.82,18.75 111.41,18.75 111.06,18.4 108.44,18.4 v2(107.28,17.24) 105.41,15.36 99.12,15.36 98.76,15.01 93.89,15.01 93.19,14.31 93.19,13 90.97,10.78 85.52,10.78 84.96,11.34 84.27,11.34 v2(84.23,11.3) 83.99,11.3 83.82,11.47 83.24,11.47 83.1,11.61 74.97,11.61 74.95,11.59 74.75,11.59 v2(74.66,11.5) 74.55,11.39 72.49,11.39 71.65,12.23 64.93,12.23 64.72,12.44 64.72,12.74 64.93,12.96 64.94,12.96 65.14,13.16 65.14,13.51 65.03,13.63 64.72,13.63 64.27,13.18 63.24,13.18 v2(62.75,13.67) ; v4(121.95,36.22) 122.51,36.22 v2(122.9,35.83) ; v2(74.78,20.28) v4(74.48,19.98) ; v2(32.51,35.75) 32.45,35.75 31.91,35.21 v4(31.91,35.1)
  IN2 w0.066: v4(74.48,19.98) 74.37,19.87 73.15,19.87 73.13,19.9 72.89,19.9 72.87,19.92 72,19.92 69.47,22.44 68.71,22.44 67.37,23.78 67.37,31.91 64.63,34.64 63.21,34.64 57.37,40.48 54.58,40.48 52.22,42.85 51.4,42.85 v4(51.1,42.55) 50.83,42.81 45.77,42.81 43.17,45.41 42.34,45.41 37.92,49.83 37.92,53.53 37.67,53.79 37.67,54.15 v4(37.41,54.41) ; v4(31.91,35.1) 31.91,35.58 33.05,36.71 33.05,38.96 29.92,42.08 29.92,49.54 28.85,50.61 v4(28.85,51.74) ; v4(136.31,51.25) 136.31,51.14 136.05,50.88 136.04,50.88 135.55,50.38 134.78,50.38 134.35,49.95 133.76,49.95 133.36,49.56 132.9,49.56 132.9,49.57 132.61,49.57 129.75,46.71 128.62,46.71 128.5,46.59 128.07,46.59 124.41,42.93 124.41,40.53 122.22,38.34 122.22,36.6 121.95,36.33 v4(121.95,36.22)
  IN3 w0.064: v4(145.14,58.26) 145.14,57.79 v5(145.02,57.66) 145.32,57.36 145.32,57.07 145.52,56.88 146.4,56.88 146.58,56.7 146.58,55.88 146.41,55.71 146.41,55.07 146.17,54.83 146.17,54.21 145.88,53.92 145.22,53.92 v4(145.18,53.88) ; v4(28.85,51.74) 28.93,51.81 29.62,51.81 29.9,52.1 30.55,52.1 31.32,52.86 32.21,52.86 33.02,53.67 33.49,53.67 33.68,53.87 34.02,53.87 34.22,53.67 34.22,53.5 v5(34.48,53.24) 34.54,53.3 34.54,53.55 34.63,53.65 34.63,54.31 34.7,54.37 36.83,54.37 36.86,54.41 v4(37.41,54.41) ; v5(139.15,31.78) 139.08,31.85 137.82,31.85 136.51,33.17 126.09,33.17 124.15,31.23 v6(124.15,28)
  BOTTOM w0.081: v5(34.48,53.24) 34.48,52.92 34.41,52.85 RT593.1 34.35,52.99 34.17,53.17 32.8,53.17 31.97,54 UT1.U1 ; v5(139.15,31.78) 139.53,31.4 139.53,30.06 139.98,29.62 139.98,28.03 140.21,27.8 RZ2.1

# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VALW_AP2285: length 1.8
  TOP w0.254: U711.6 41.48,76.47 D9.1
+3VALW_DSW: length 12.5
  TOP w0.254: 145.05,59.12 145.05,59.78 143.55,61.28 140.19,61.28 v2(139.75,60.83)
  TOP w0.305: 145.46,50.54 145.46,51.69
  IN1 w0.254: v2(146.05,49.93) 145.87,49.93 145.75,49.8 v4(145.71,49.8) ; v4(137.91,60.27) 138.13,60.27 138.18,60.22 138.94,60.22 139.55,60.83 v2(139.75,60.83)
  IN3 w0.254: v5(146.51,50.3) 146.07,49.86 145.8,49.86 145.75,49.8 v4(145.71,49.8) 145.71,49.62 v5(145.86,49.47) ; v5(137.94,61) 137.91,60.97 v4(137.91,60.27)
  vias: v2(146.89,54.32) v2(147.33,55.28) v3(146.24,59.11)
+3VALW_DSW_PG: length 2.2
  TOP w0.089: R1014.1 39.82,76.83 40.61,76.83 40.98,76.45 U711.7
+3VALW_EC: length 144.1
  TOP w0.229: Q30.5 38.22,32.19 v2(38.32,32.29) 38.39,32.22 38.4,32.22 38.42,32.19 Q30.2
  TOP w0.254: CE9.1 37.25,21.87 v2(37.55,21.57) ; v6(54.12,26.53) 54.45,26.2 CE8.1 ; v6(54.12,26.53) 53.9,26.3 RE9.2 53.59,25.99 53.32,25.72 RE8.2 ; v6(54.12,26.53) 53.92,26.73 53.92,29.45 54.2,29.73 54.2,30.25 54.03,30.42 53.49,30.42 53.08,30.83 CE101.1 53.08,31.68 CE100.1 52.53,32.3 v2(52.49,32.26) 52.49,32.46 RE5.2 53.17,33.14 CE1.1 53.17,34.37 52.82,34.72 v2(52.82,35.27) ; UE1.A15 49.23,19.08 49.73,18.58 CE504.1 49.7,18.42 v2(49.6,18.32) ; RE48.1 32.84,7.35 33.41,7.35 ; UE1.A52 40.13,27.18 v2(39.97,27.01) ; v6(46.98,21.14) UE1.B11 ; CE2.1 52.91,17.15 v2(53.05,17.28) 53.05,17.28 54.75,17.28 55.08,17.6 RE478.2 ; UE5.5 62.97,24.18 v6(63.32,24.53) 64,24.53 CE508.1 64.02,24.3 63.85,24.13 RE511.2 ; RE3.1 47.48,16.38 v2(47.49,16.39) ; RE524.2 v2(36.73,7.72) ; RE91.2 38.88,25.35 RE93.2 38.88,25.61 38.79,25.7 CE7.1 38.89,26.09 RE90.2 38.67,26.72 38.42,26.98 RE155.2 v2(38.02,28.05) ; RE12.2 44.69,16.51 44.57,16.63 44.57,17.6 v2(44.57,17.6) ; RE542.2 40.57,32.25 40.53,32.3 RE101.2 40.3,32.45 40.66,32.81 v2(40.66,32.88) 40.64,32.9 CE5.1 ; v2(50.83,35.24) 50.37,35.7 48.66,35.7 v1(48.43,35.47) 47.66,34.7 RE51.1 ; UE1.B26 49.57,24.93 v6(49.23,24.6) ; v2(44.57,17.6) 44.57,17.89 44.68,18 CE506.1 44.68,18.58 44.94,18.84 45.52,18.84 45.73,19.05 UE1.A8 45.73,19.76 45.98,20.01 UE1.B9 v6(45.98,21.52) ; v2(44.57,17.6) 44.54,17.63 CE507.1 ; 33.41,7.35 RE49.2 33.99,7.57 34.24,7.83 v2(35.31,7.83) 35.33,7.8 RE50.2 ; 33.41,7.35 RE92.2 ; v6(56.17,24.88) 55.94,25.11 RE516.1 ; UE1.B5 v2(43.98,20.96) 43.6,20.96 43.48,20.84 v2(43.48,20.33)
  IN1 w0.254: v2(38.32,32.29) 38.32,32.39 38.06,32.65 v4(38.03,32.65) 38.03,32.65 36.44,32.65 v2(36.41,32.63) ; v4(48.38,18.75) 48.71,18.42 v2(49.17,18.42) 49.27,18.32 v2(49.6,18.32) 49.62,18.32 50.24,17.7 50.44,17.7 50.77,17.36 ; v2(44.57,17.6) 44.35,17.37 44.35,16.55 v4(44.26,16.46) ; v2(43.48,29.53) 43.55,29.46 43.55,28.24 v4(43.89,27.91) ; v2(37.55,21.57) v4(37.55,22.06) ; v2(41.44,17.2) 41.97,17.2 42.3,17.54 v4(42.68,17.54) ; v2(50.83,35.24) 50.86,35.27 v2(52.82,35.27) ; v2(52.49,32.26) 52.67,32.08 52.67,31.01 51.2,29.54 50.62,29.54 50.08,29 v4(48.29,29) 48.29,29.1 47.98,29.4 v2(47.98,29.5) ; v2(38.02,28.05) 38.48,28.05 v4(38.61,27.91) 38.7,27.83 39.1,27.83 39.7,27.23 39.75,27.23 v2(39.97,27.01) ; v2(36.73,7.72) 36.77,7.76 36.77,8.36 36.5,8.62 36.12,8.62 35.32,7.83 v2(35.31,7.83) 35.31,9.62 v4(35.79,10.1) ; 50.77,17.36 50.92,17.51 52.65,17.51 52.88,17.28 v2(53.05,17.28) ; 50.77,17.36 50.77,17.04 50.52,16.79 49.98,16.79 v4(49.8,16.61) 49.47,16.28 v2(49.38,16.28) 48.42,16.28 48.19,16.51 47.63,16.51 47.51,16.39 v2(47.49,16.39) ; v2(40.66,32.88) 40.66,32.42 40.41,32.17 40.41,32.17 40.1,31.86 40.03,31.86 39.92,31.75 v4(39.92,31.75) ; v2(43.48,20.33) 43.48,20.66 v4(43.57,20.75) v4(43.57,21.24) 43.83,21.24 43.98,21.08 v2(43.98,20.96)
  IN2 w0.254: v4(48.29,29) 47.2,27.91 v4(43.89,27.91) 43.71,27.91 42.41,26.6 42.03,26.6 41.47,26.04 ; 41.47,26.04 40.55,26.96 39.61,26.96 38.9,27.66 38.86,27.66 v4(38.61,27.91) 38.61,28.22 39.17,28.77 39.17,30.93 39.92,31.69 v4(39.92,31.75) ; 41.47,26.04 41.47,25.68 41.67,25.48 41.67,24.16 40.46,22.95 39.18,22.95 38.67,23.46 37.62,23.46 37.36,23.2 37.36,22.61 37.55,22.43 v4(37.55,22.06) 37.44,21.96 36.62,21.96 v4(36.52,21.86)
  IN3 w0.254: v4(39.92,31.75) 39.82,31.65 38.89,31.65 38.03,32.51 v4(38.03,32.65) ; v6(49.23,24.6) 51.5,24.6 52.31,25.41 52.31,26.25 52.59,26.53 v6(54.12,26.53) ; v4(35.79,10.1) 35.26,10.1 34.04,11.32 33.59,11.32 32.84,12.08 32.84,12.9 33.33,13.4 33.33,16.24 36.52,19.42 v4(36.52,21.86)
  BOTTOM w0.254: v6(54.12,26.53) 55.77,24.88 v6(56.17,24.88) 62.97,24.88 v6(63.32,24.53)
  vias: v4(42.93,17.99)
+3VALW_ESPI1:
  vias: v1(38.96,6.73)
+3VALW_PCH: length 448.3
  TOP w0.203: v2(138.06,50.19) 137.81,50.19 137.6,49.98 RC110.2 137.02,49.85 RC117.1 ; RC34.2 141.6,44.19 141.9,44.49 141.9,46.97 141.97,47.05 ; v2(134.32,64.35) 134.32,64.68 134.34,64.7 134.34,65.6 134.19,65.76 RC571.1
  TOP w0.254: v2(56.52,41.63) 56.62,41.63 57.23,41.02 UN4.5 ; 140.87,59.39 139.7,59.39 v6(139.42,59.1) ; v2(40.44,11.39) 40.46,11.39 RC562.2 ; v2(142.04,12) 142.04,14.58 140.49,16.14 140.49,16.55 139.31,17.73 139.31,19.57 139.51,19.78 139.51,29.65 135.36,33.8 134.58,33.8 v2(131.43,36.95) 131.43,38.63 v2(131.61,38.8) ; v2(133.95,72.83) 133.95,73.55 133.27,74.22 124.96,74.22 124.7,73.97 124.7,71.27 123.71,70.28 121.34,70.28 121.33,70.28 ; v2(135.66,54.28) RC36.2
  IN1 w0.254: v2(136.11,37.84) 135.95,37.84 135.46,37.34 135.13,37.34 134.51,36.72 131.66,36.72 v2(131.43,36.95) ; v4(41.57,10.75) 41.32,11 40.83,11 v2(40.44,11.39) ; v2(56.52,41.63) 57.26,41.63 59.08,43.44 59.46,43.82 59.46,44.6 v4(59.19,44.86) ; v6(139.42,59.1) 139.35,59.03 132.1,59.03 131.79,59.34 131.79,60.56 132.03,60.8 v6(132.03,60.84) ; v2(138.06,50.19) 138.04,50.19 137.64,49.79 137.64,49.36 138.15,48.85 138.35,48.85 138.42,48.78 138.9,48.78 139.72,47.97 140.15,47.97 140.52,48.33 140.52,48.8 140.77,49.06 v4(140.94,49.06) ; v2(133.95,72.83) 133.95,73.02 133.7,73.26 133.32,73.26 132.97,72.92 132.97,72.66 132.7,72.39 132.19,72.39 131.96,72.62 131.96,72.9 131.61,73.24 131.2,73.24 130.95,72.99 130.95,72.49 131.53,71.9 131.53,70 130.9,69.37 130.9,69.26 130.96,69.19 130.96,65.35 132.32,63.99 133.08,63.99 133.44,64.35 v2(134.32,64.35) 135.62,64.35 v4(136.58,63.39) ; v4(144.24,49.14) 144.61,49.51 145.25,49.51 145.62,49.14 v4(146.88,49.14) ; 142.43,54.73 142.32,54.73 142.1,54.51 140.32,54.51 138.85,53.04 138.02,53.04 137.54,53.52 137.54,53.92 137.04,54.43 135.81,54.43 v2(135.66,54.28) 135.29,54.28 v6(134.44,53.44) ; v4(31.78,70.96) 31.52,70.7 v2(31.39,70.7) ; v4(131.86,39.21) 131.86,39.06 v2(131.61,38.8) ; v4(123.74,5.5) 123.98,5.74 142.81,5.74 144.35,7.29 144.35,10.01 v2(144.22,10.14) 142.71,10.14 142.04,10.81 v2(142.04,12)
  IN2 w0.254: v4(41.57,10.75) 43.78,10.75 45.21,12.18 50.25,12.18 56.9,5.52 84.79,5.52 85.78,6.51 86.54,6.51 86.86,6.2 95.61,6.2 97.17,7.76 110.52,7.76 111.42,8.66 122,8.66 122.81,7.85 122.81,7.11 123.74,6.18 v4(123.74,5.5) ; v6(121.73,41.4) 121.73,40.55 119.36,38.18 119.36,36.53 114.86,32.03 111.71,32.03 110.67,30.98 100.81,30.98 100.23,31.56 81.26,31.56 80.48,30.78 77.51,30.78 77.1,31.19 75.41,31.19 74.44,32.16 73.73,32.16 72.32,33.57 71.17,33.57 63.54,41.2 63.54,41.44 60.65,44.33 59.72,44.33 v4(59.19,44.86) 59.15,44.9 59.09,44.9 58.61,45.39 53.45,45.39 52.92,44.86 50.14,44.86 49.62,45.38 49.62,46.24 48.31,47.55 48.31,52.78 46.96,54.13 46.96,57.81 46.33,58.43 46.33,62.48 45.26,63.55 v4(45.18,63.55) 45.18,63.55 45.18,63.64 45.12,63.69 45.12,66.34 43.24,68.22 43.24,71.61 39.79,75.05 34.89,75.05 33.84,74 32.17,74 v4(31.88,73.71) ; v4(39.73,52.46) 39.88,52.61 39.88,54.49 41.36,55.97 41.36,59.71 42.96,61.3 42.96,62.6 42.93,62.63 42.93,63 v4(42.91,63.02)
  IN3 w0.254: v4(146.88,49.14) 147.16,49.43 v5(147.16,49.47) 147.29,49.47 147.55,49.72 147.55,50.46 147.26,50.75 145.93,50.75 145.86,50.69 144.88,50.69 144.39,50.2 144.39,49.64 v5(144.56,49.47) 144.56,49.46 v4(144.24,49.14) ; v5(31.8,51.19) 31.8,51.19 32.18,51.57 33.84,51.57 33.94,51.67 34.44,51.67 34.59,51.81 35.15,51.81 35.62,52.28 35.62,52.87 36.22,53.47 36.58,53.47 37.7,52.35 39.62,52.35 v4(39.73,52.46) ; v5(130.58,57.9) 130.58,57.62 130.43,57.47 v4(130.43,57.43) ; v6(122.72,41.7) 122.96,41.94 124.62,41.94 125.25,42.57 v5(126.96,42.57) ; v5(128.05,40.2) 128.14,40.3 131.91,40.3 v5(131.93,40.27) 131.95,40.27 132.11,40.12 132.11,39.45 v4(131.86,39.21) 131.86,38.86 v5(131.9,38.81) ; v6(139.42,59.1) 139.53,58.98 139.61,58.98 139.86,58.73 139.86,57.69 139.68,57.51 139.68,56.52 140.02,56.18 140.28,56.18 140.92,55.54 140.92,55.1 141.56,54.46 v4(142.58,54.46) ; v4(31.78,70.96) 31.85,71.03 31.85,71.11 32.77,72.03 32.77,73.42 32.49,73.71 v4(31.88,73.71) ; v4(136.58,63.39) 136.71,63.53 v5(137.1,63.53) ; v4(42.91,63.02) 42.91,63.18 43.19,63.46 45.08,63.46 45.18,63.55 v4(45.18,63.55) ; v4(140.94,49.06) 140.94,49.09 v5(141.31,49.47) ; v5(142.88,49.11) 142.88,48.92 141.8,47.84 141.8,46.58 141.96,46.42 v5(141.96,45.27)
  BOTTOM w0.102: 146.91,49.72 v5(147.16,49.47) 146.94,49.24
  BOTTOM w0.203: v6(132.03,60.84) 132.03,60.86 131.52,61.37 RC31.1 ; RC69.1 130.52,43.65 RC395.1 130.49,43.43 130.35,43.29 ; RC568.1 130.97,49.27 RC118.1 130.34,49.05 129.96,48.66 129.96,48.38 ; RC190.2 132.18,38.81 v5(131.9,38.81) ; RT391.2 33.32,50.24 33.12,50.04 32.3,50.04 31.8,50.54 v5(31.8,51.19) ; RC188.2 v5(131.93,40.27) ; v5(137.1,63.53) 137.05,63.47 RC211.2
  BOTTOM w0.254: 130.35,43.29 129.86,42.79 128.66,42.79 128.03,42.16 128.03,40.33 128.05,40.31 v5(128.05,40.2) 128.06,40.19 128.06,39.72 127.8,39.46 127.44,39.46 127.19,39.72 127.19,42.35 v5(126.96,42.57) ; 128.35,51.47 128.3,51.41 128.3,48.52 128.49,48.34 128.49,47.46 ; 128.49,47.46 129.29,47.46 129.96,48.13 129.96,48.38 ; 128.49,47.46 127.99,47.46 127.9,47.55 RC575.2 127.27,47.56 RE473.1
  vias: v2(142.23,48.71) v2(142.55,48.7) v2(143.34,54.47) v2(143.33,54.17) v3(118.9,73.5) v6(118.73,74.22) v6(119.05,74.73) v6(119.28,72.29) v6(119.36,74.19) v6(121.15,41.59) v6(121.6,41.95) v6(122.21,41.95) v6(142.84,52.45)
+3VALWP: length 18.5
  IN2 w0.254: v4(12.73,18.24) 12.81,18.24 14.22,16.83 v4(14.35,16.83) 15.23,16.83 16.73,18.34 22.82,18.34 23.08,18.08 v6(23.08,17.49)
  IN3 w0.254: v5(14.4,18.07) 14.35,18.02 v4(14.35,16.83) ; v5(12.73,18.99) 12.73,18.24 v4(12.73,18.24) 11.71,18.24 v5(10.9,17.43)
  BOTTOM w0.254: PR304.1 11.21,17.11 v5(10.9,17.43) ; PU301.11 14,17.51 14.4,17.91 v5(14.4,18.07)
  vias: v3(25.36,14.76) v6(22.25,12.35) v6(22.21,11.69) v6(22.82,12.28) v6(22.82,11.67) v6(23.46,12.28) v6(23.46,11.67) v6(24.09,12.28) v6(24.09,11.67) v6(24.73,12.28) v6(24.73,11.67) v6(25.36,12.28) v6(25.36,11.67) v6(25.43,12.85)
+3VLP: length 216.2
  TOP w0.254: U34.8 61.46,29.57 RE99.1 60.13,30.31 RE97.1
  TOP w0.381: v6(27.76,18.69) 30.61,18.69 v6(30.67,18.63) 30.66,18.62 30.66,18.08 31.22,17.53 RE552.2 ; v2(36.64,17.95) 36.88,17.72 38.3,17.72 RE30.1
  TOP w0.508: v2(59.22,14.6) 62.48,14.6 v2(62.69,14.82) ; RE97.1 60.05,31.74 60.67,32.37 60.67,32.85 61.88,34.06 64.15,34.06 65.6,32.61 v3(65.6,26.19) 65.6,24.9 65.26,24.56 65.26,15.06 v2(64.98,14.78)
  IN1 w0.254: v4(13.89,71.27) 13.77,71.15 11.33,71.15 9.76,72.72 6.95,72.72 6.33,73.34 5.38,73.34 4.83,73.89 4.83,75.07 v4(3.9,76) ; v2(2.32,73.97) 2.41,74.05 v4(2.41,75.59)
  IN1 w0.508: v2(59.22,14.6) 58.83,14.6 58.34,15.09 56.98,15.09 v4(56.97,15.08) ; v2(36.64,17.95) 36.64,18.05 v4(36.3,18.39)
  IN2 w0.254: v4(29.82,37.85) 29.82,37.99 30.51,38.67 30.51,39.46 28.46,41.5 28.46,47.49 24.08,51.88 21.92,51.88 18.7,55.09 13.12,55.09 12.67,55.54 12.67,56.12 13.08,56.54 13.5,56.54 13.75,56.78 13.75,62.62 14.09,62.96 14.09,63.14 15.33,64.38 15.33,67.82 14.12,69.03 14.12,70.16 13.89,70.39 v4(13.89,71.27)
  IN2 w0.508: v4(23.11,7.31) 21.26,9.16 17.08,9.16 14.48,6.56 12.67,6.56 11.65,7.58 11.65,10.97 11.28,11.34 8.71,11.34 8.18,11.87 8.18,17.06 10.1,18.98 14.18,18.98 v4(15.18,17.98) 16.08,18.89 26.33,18.89 26.53,18.69 v6(27.76,18.69) ; v4(56.97,15.08) 56.96,15.09 55.06,15.09 53.47,13.5 50.04,13.5 49.25,12.7 42.55,12.7 41.26,13.98 36.03,13.98 35.67,13.63 35.21,13.63 34.21,14.63 34.21,15.35 36.3,17.45 v4(36.3,18.39) 34.58,18.39 34.38,18.19 31.17,18.19 30.7,18.66 ; v4(33.16,29.71) 33.16,29.51 30.68,27.03 30.68,24.45 31.33,23.79 31.33,20.16 30.7,19.52 30.7,18.66 ; 30.7,18.66 v6(30.67,18.63)
  IN3 w0.254: v4(29.82,37.85) 29.59,37.62 29.59,32.4 30.08,31.91 30.08,30.01 30.91,29.17 32.87,29.17 33.16,29.46 v4(33.16,29.71) ; v4(2.41,75.59) 3.29,76.47 v5(3.31,76.47) ; v5(3.9,76.47) v4(3.9,76)
  IN3 w0.508: v4(23.11,7.31) v5(23.64,6.78)
  BOTTOM w0.254: v5(3.31,76.47) v5(3.9,76.47)
  BOTTOM w0.508: v5(23.64,6.78) 23.85,6.78 24.04,6.6 DB4.2
  vias: v5(15.42,18.26) v5(15.65,17.97)
+3VS: length 446.9
  TOP w0.203: 139.39,52.19 139.61,51.97 139.61,51.83 140,51.44 RC106.1 ; 139.39,52.19 139.39,52.33 139.21,52.52 139.21,53.74 v2(139.09,53.86) ; 139.39,52.19 RC68.1 138.85,51.92 ; RC208.2 RC207.2 139.13,50.23 139.92,51.02 140.18,51.02 140.45,51.29 RC106.1 ; RC8.2 139.94,40.99 ; 134.53,37.22 134.53,36.75 134.74,36.54 134.74,36.54 134.76,36.53 134.96,36.53 RC6.1 135.45,36.05 v2(135.45,36) ; RC106.1 140.86,51.44 RC516.2 ; R53.1 136.09,50.56 RC114.1 136.61,50.56 136.84,50.79 ; RV113.1 113.87,48.97 113.93,48.97 114.16,49.2 RV4996.1 113.96,49.4 113.96,49.72 114.01,49.77 v2(114.01,50.02)
  TOP w0.254: Q10.5 113.88,5.89 113.77,5.78 113.77,5.13 113.5,4.86 R36.1 112.12,4.86 v6(112.1,4.88) ; v6(24.5,74.52) R90.1 RS13.1 ; QV18.4 34.72,71.98 v2(35.33,71.98) ; 134.53,37.22 134.69,37.37 134.69,39.39 135.79,40.5 135.79,41.5 v2(135.79,41.5) ; 138.85,51.92 138.93,51.85 138.93,51.26 138.46,50.79 136.84,50.79 ; v6(138.01,13.81) 137.82,13.81 RC529.2 ; v6(133.74,12.87) 133.74,13.21 133.36,13.59 132.76,13.59 132.5,13.34 RC535.2 ; v2(118.93,40.65) 119.1,40.65 UV11.5 ; R37.1 113.88,8.54 Q10.2 113.88,7.65 v6(114.26,7.27) ; 137.31,35.28 139.5,37.47 139.5,40.64 139.84,40.99 139.94,40.99
  TOP w0.356: RE16.2 38.46,30.42 38.13,30.1 v6(37.83,30.1) 37.89,30.04 37.89,29 38.26,28.63 R47.1
  TOP w0.381: Q11.2 32.91,70.23 32.28,69.59 v2(32.28,69.34) ; v6(63.99,19.27) 63.8,19.08 RE510.2 ; v6(52.81,25.93) 53.08,26.21 RE17.2 ; R55.1 131.77,50.88 131.77,58.31 131.03,59.05 ; v2(36.19,70.64) 36.19,70.25 R50.1 35.87,70.2 35.85,70.23 Q11.5 ; v6(55.2,19.33) 55.22,19.33 55.6,19.71 CE22.1 55.6,20.35 UE2.5
  TOP w0.508: 128.82,63.6 128.47,63.96 124.62,63.96 124.13,63.48 124.06,63.44 122,63.44 v6(119.55,60.99) ; v2(134.36,41.51) 133.49,42.39 R54.1 ; v6(138.78,32.9) 138.78,33.81 136.59,36 v2(135.45,36) ; 134.73,57.27 133.8,58.2 133.8,60.36 132.24,61.92 131.68,61.92 v6(131.53,62.07) ; v6(86.03,5.86) 83.74,5.86 81.57,8.02 80.38,8.02 79.98,7.62 79.98,7.04 79.01,6.07 68.76,6.07 68.2,6.63 68.2,7.47 Q9.2 68.52,9.06 68.52,10.26 67.57,11.22 65.48,11.22 63.33,13.36 v6(63.33,13.65) ; UC4.5 137.12,68.78 136.46,68.11 136.46,64.57 v6(136.58,64.45) ; RM2.2 v6(13.37,55.83) ; 35.27,34.1 35.27,32.09 35.09,31.91 35.09,31.31 35.46,30.94 35.78,30.94 36.42,30.3 36.42,30.25 36.72,29.96 37.69,29.96 v6(37.83,30.1)
  IN1 w0.254: v2(138.42,56.01) 138.42,55.62 138.21,55.41 138.21,55.06 138.46,54.82 138.46,54.59 139.09,53.96 v2(139.09,53.86) ; v2(66.49,58.96) 65.47,57.94 65.47,53.75 v4(64.2,52.48) ; v2(135.79,41.5) 135.77,41.48 134.4,41.48 v2(134.36,41.51) ; v4(38.37,67.63) 38.63,67.89 v2(38.63,68.02) ; v6(133.74,12.87) 133.9,12.87 134.34,13.31 136.98,13.31 137.47,13.81 v6(138.01,13.81) ; v2(40.92,57.94) 40.79,58.07 v4(40.79,58.38) ; v2(38.29,22.85) 38.27,22.87 v4(37.89,22.87)
  IN1 w0.508: v2(118.93,40.65) 120.34,39.25 121.7,39.25 123.08,37.87 127.15,37.87 127.25,37.97 v6(127.72,37.97) 129.18,37.97 130.94,36.21 135.24,36.21 v2(135.45,36)
  IN2 w0.254: v6(184.63,51.31) 184.15,51.79 184.15,57.13 178.13,63.15 177.95,63.15 177.89,63.21 161.58,63.21 161.58,63.21 158.52,63.21 158.4,63.34 139.33,63.34 137.84,64.82 136.95,64.82 v6(136.58,64.45)
  IN2 w0.508: v6(138.01,13.81) 137.72,13.81 134.04,10.12 126.7,10.12 124.87,8.28 124.87,5.17 124.36,4.66 120.29,4.66 119.78,5.17 119.78,6.65 119.27,7.15 114.37,7.15 v6(114.26,7.27) 113.99,7 113.99,5.96 112.91,4.88 v6(112.1,4.88) 111.69,4.88 110.46,6.12 96.48,6.12 96.05,5.69 86.19,5.69 v6(86.03,5.86) ; v6(131.53,62.07) 131.53,62.25 132.12,62.84 133.85,62.84 135.45,64.45 v6(136.58,64.45) ; v4(37.89,22.87) 38.31,22.87 38.73,22.45 40.22,22.45 40.54,22.12 41.26,22.12 42.34,23.2 42.34,25.22 43.41,26.29 48.04,26.29 49.25,27.5 50.53,27.5 51.53,26.5 52.27,26.5 52.78,25.99 52.78,25.96 v6(52.81,25.93) 52.47,25.59 52.47,21.62 53.25,20.83 53.25,20.46 53.76,19.95 54.28,19.95 54.91,19.33 v6(55.2,19.33) ; v4(21.04,68.41) 18.94,68.41 17.76,67.23 17.76,65.63 14.45,62.33 14.45,56.49 13.8,55.83 v6(13.37,55.83) ; v6(97.67,13.17) 97.67,12.96 96.78,12.06 95.85,12.06 94.33,10.54 82.39,10.54 80.89,12.04 76.89,12.04 75.11,13.82 72.18,13.82 v6(67.37,18.63)
  IN2 w0.762: v6(119.55,60.99) 119.55,58.47 v4(113.04,51.96) 107.99,46.92 107.99,45.39 102.84,40.24 102.84,37.69
  IN3 w0.254: v5(119.65,43.8) 119.65,43.73 118.44,42.53 v4(117.19,42.53)
  IN3 w0.508: v6(37.83,30.1) 37.97,29.95 37.97,27.7 38.95,26.72 38.95,24.03 37.89,22.96 v4(37.89,22.87) ; v5(115.76,60.26) 115.76,60.97 116.73,61.94 116.73,67.83 115.76,68.8 115.76,70.96 113.61,73.11 110.79,73.11 110.66,73.24 v6(109.79,73.24)
  BOTTOM w0.203: v6(138.78,32.9) 139.13,32.9 RC9.2 ; v6(127.72,37.97) 128.45,38.69 128.45,40.05 128.52,40.13 128.52,42.03 128.93,42.44 129.8,42.44 130.05,42.18 131.29,42.18 131.43,42.32 131.43,42.69 131.43,42.69 RC517.1 131.89,42.97 131.91,42.98 RC564.1 ; RV111.1 109.57,73.46 v6(109.79,73.24) ; RC127.2 131.93,39.74 ; 184.41,49.51 184.16,49.27 RC19.1
  BOTTOM w0.254: v6(127.72,37.97) 128.27,37.43 129.66,37.43 130.4,38.17 130.4,39.36 130.78,39.74 131.93,39.74 131.93,39.74 ; 184.41,49.51 184.82,49.93 184.82,51.11 v6(184.63,51.31) ; PRF04.1 119.4,44.05 119.65,43.8 v5(119.65,43.8)
  BOTTOM w0.508: v6(97.67,13.17) 97.67,13.15 96.31,11.79 96.13,11.79 R256.1
  vias: v2(20.88,67.71) v2(20.87,67.39) v2(21.27,67.71) v2(21.25,67.38) v2(42.32,51.08) v2(42.32,50.76) v2(116.86,42.42) v2(117.14,42.1) v2(118.92,46.31) v2(119.21,46.11) v3(37.12,36.06) v4(31.19,70.08) v4(36.69,70.66) v4(114.43,49.47) v4(118.77,45.95) v6(24.05,74.18) v6(40.85,49.11) v6(41.43,49.11) v6(68.37,42.02) v6(68.95,42.02) v6(69.54,42.02) v6(70.12,42.02) v6(70.71,42.02) v6(71.29,42.02) v6(92.82,27.05) v6(92.82,26.46) v6(93.4,27.05) v6(93.4,26.46) v6(93.99,27.04) v6(93.99,26.46) v6(94.57,27.04) v6(94.57,26.46) v6(102.13,35.5) v6(102.54,35.93) v6(102.5,35.08) v6(102.95,36.33) v6(102.93,35.5) v6(103.33,35.92)
+3VS_CAM: length 31.8
  TOP w0.254: 40.16,49.75 39.78,49.37 v3(39.78,49.18)
  IN2 w0.508: v4(41.55,52.32) 41.55,52.65 41.59,52.7 41.59,52.97 42.1,53.48 42.1,54.82 42.19,54.91 42.19,59.26 43.66,60.73 43.66,62.13 43.71,62.18 43.71,63.41 41.86,65.26 41.86,68.02 40.68,69.2 40.68,70.8 39.11,72.38 38.09,72.38 37.68,72.79 34.81,72.79 34.66,72.94 34.33,72.94 34.08,73.18 32.22,73.18 v6(32.19,73.14)
  BOTTOM w0.203: v6(32.19,73.14) 32.19,72.9 32.35,72.73 JEDP1.22
  vias: v2(41.41,51.44) v2(41.41,51.12)
+3VS_CR: length 24.7
  TOP w0.127: CR5.1 6.15,31.35 5.98,31.51 4.76,31.51 4.48,31.23 v3(4.48,30.8)
  TOP w0.508: JREAD1.4 2.65,23.56 3.14,24.04 3.14,25.11 2.79,25.45 v6(2.54,25.45)
  IN3 w0.508: 6.4,28.95 2.55,28.95 1.66,28.06 1.66,26.33 v6(2.54,25.45) 1.87,24.78 1.87,22.2 2.3,21.77 v5(2.87,21.77) 3.01,21.63 3.01,20.13 2.68,19.8 v5(2.54,19.8)
  BOTTOM w0.254: v6(2.54,25.45) 3.04,25.45 RR161.1 RR162.1 ; RR163.1 3.12,19.8 v5(2.54,19.8) ; v5(2.87,21.77) RR164.1 RR165.1
  vias: v2(6.15,30.56) v2(6.12,30.01) v4(6.57,30.49) v4(6.58,30)
+3VS_CR_R:
  vias: v1(8.86,31.09)
+3VS_DTH: length 12
  TOP w0.203: RM51.1 21.66,35.19 21.31,35.54 RM50.1 21.71,35.98 RM12.1 RM11.1 22.63,35.98 22.86,36.21 RM45.1 23.28,36.16 v2(23.84,36.16) ; RM26.2 v2(22.59,47.74)
  IN1 w0.254: v4(21.23,44.01) 21.58,44.36 22.19,44.36 22.73,44.9 22.73,47.59 v2(22.59,47.74)
  IN3 w0.254: v5(22.1,42.08) 22.1,41.72 v4(22.06,41.68) ; v5(24.53,41.75) 24.89,41.39 24.89,41.03 v5(24.53,40.68) 24.52,40.67 24.52,40.23 v4(24.5,40.21)
  BOTTOM w0.203: v5(24.53,40.68) 24.69,40.84 RM40.1 ; RM44.1 21.79,41.99 21.87,42.08 v5(22.1,42.08) ; RM42.1 v5(24.53,41.75)
  vias: v3(14.64,53.95) v4(20.66,44) v5(20.37,44.18) v5(21.73,45.28) v5(21.73,44.82) v5(21.73,44.53) v6(13.99,53.5) v6(13.99,52.89)
+3VS_SENSOR: length 41.3
  TOP w0.254: v2(44.93,59.21) 44.95,59.18 v1(46.34,59.18) 46.64,58.88 F9.2
  IN1 w0.203: v2(44.93,59.21) 44.62,58.9 44.61,58.9 44.45,58.74 44.03,58.74 43.45,59.32 43.45,59.63 v4(43.55,59.73)
  IN2 w0.254: v4(33.18,71.73) 32.93,71.97 32.79,71.97 32.66,72.1 31.84,72.1 31.56,72.38 30.91,72.38 30.4,72.89 29.49,72.89 28.9,72.3 24.4,72.3 24.28,72.42 v4(21.17,72.42)
  IN3 w0.254: v5(33.15,72.87) 33.15,71.78 33.18,71.75 v4(33.18,71.73) 33.86,71.73 35.42,70.17 35.42,66.25 35.59,66.08 36.51,66.08 37.08,66.64 38.06,66.64 38.34,66.36 38.34,65.46 38.84,64.97 40.88,64.97 41.16,64.68 41.16,62.87 40.73,62.44 40.73,61.95 41.11,61.57 41.11,61.38 41.44,61.05 41.87,61.05 42.58,60.34 42.77,60.34 43.38,59.73 v4(43.55,59.73) ; v5(20.85,71.6) 20.98,71.73 20.98,72.23 v4(21.17,72.42)
  BOTTOM w0.135: JEDP1.20 v5(33.15,72.87)
+3VS_SSD: length 2.1
  TOP w0.254: RS1.1 111.87,33.39 v3(111.68,33.58) 111.52,33.75 v6(111.52,34.34)
  vias: v3(106.26,34.19) v3(108.1,33.05) v6(108.11,34.87) v6(108.17,34.29) v6(108.53,33.7) v6(108.7,34.53) v6(108.74,19.27) v6(108.99,34.05) v6(111.21,19.2)
+3VS_UN5: length 0.7
  TOP w0.081: 54.18,44.87 53.62,44.87 v1(53.54,44.95)
+3VS_WWAN_RF: length 3.3
  TOP w0.081: v2(36.22,68.56) 36.17,68.51 v3(35.26,68.51)
  IN1 w0.064: v4(36.22,68.12) v2(36.22,68.56)
  IN3 w0.064: v4(36.22,68.12) 36.4,67.94 v5(37,67.94)
  BOTTOM w0.152: JANT2.1 37.64,67.6 37.3,67.94
  BOTTOM w0.356: 37.3,67.94 v5(37,67.94)
+5V_KB_BL: length 1.5
  TOP w0.508: F3.1 v6(39.2,9.93)
  vias: v3(39.01,10.57)
+5VALW: length 232
  TOP w0.203: UV2.4 118.73,49.67 119.09,49.32 ; v6(90.99,22.73) 91.19,22.93 UZ3.4
  TOP w0.254: v6(80.3,28.19) 79.94,28.19 77.58,30.56 RV5008.1 C6671.2 ; PR4.1 117.84,16.45 118.35,16.96 121.59,16.96 122.29,16.25 v6(122.29,15.01) ; RV5002.1 119.46,54.06 v2(119.03,53.62) ; CZ10.1 113.3,29.41 UZ2.3 ; 119.17,64.99 119.17,70.76 117.78,72.15 117.78,75.41 116.64,76.54 113.88,76.54 RV2008.1 ; Q32.3 35.63,45.28 35.08,44.73 35.08,43.59 34.2,42.71 v6(34.2,42.34) 34.86,41.67 Q31.3 ; CV322.1 118.45,47.85 119.16,48.56 119.16,49.25 119.09,49.32 ; U19.4 48.78,44.95 48.53,45.21 47.6,45.21 v2(47.6,45.2) ; UM2.10 33.12,37.75 33.28,37.59 CM1.1 34.19,37.59 v6(34.74,37.03) ; RV2007.1 96.83,36.23 v6(97,36.4)
  TOP w0.356: v6(111.85,31.22) 112.79,31.22 113.28,30.73 113.28,30.22 113.22,30.16 CZ10.1
  TOP w0.508: 126.07,65.13 128.89,65.13 129.37,64.65 130.85,64.65 134.58,60.91 138.09,60.91 139.64,62.46 153.21,62.46
  IN1 w0.508: 98.21,37.75 101.99,41.53 101.99,44.75 108.27,51.03 108.27,56.14 108.8,56.66 108.8,57.81 110.37,59.38 110.81,59.38 111.88,60.45 114.63,60.45 114.82,60.26 ; v2(47.6,45.2) 47.6,42.12 v4(49.19,40.52)
  IN2 w0.254: v6(122.29,15.01) 122.52,15.01 122.79,14.74 125.99,14.74 128.16,16.91 132.36,16.91 133.59,18.15 139.04,18.15 140.4,19.51 140.4,21.76 140.4,21.76 140.4,27.74 140.4,27.74 140.4,28.63 141.11,29.33 v4(141.95,29.33)
  IN2 w0.508: v6(88.89,20.45) 88.9,20.45 90.29,19.05 94.23,19.05 94.25,19.04 96.26,19.04 97.89,20.67 103.76,20.67 104.35,20.08 105.4,20.08 105.76,20.44 114.46,20.44 114.67,20.23 116.14,20.23 117.06,21.15 117.06,22.52 118.39,23.85 121.12,23.85 v6(121.47,24.2) ; v6(34.74,37.03) 34.74,37.47 35.08,37.8 35.08,40.95 34.2,41.83 v6(34.2,42.34)
  IN3 w0.254: v4(120.13,43.91) 120.13,43.65 v5(119.77,43.3) ; v4(141.95,29.33) 142.01,29.39 142.56,29.39 v5(142.68,29.27) ; v4(122.84,48.83) 122.9,48.83 v5(123.6,48.13)
  BOTTOM w0.203: CZ1.1 142.55,29.15 v5(142.68,29.27) 142.89,29.48 UZ1.4
  BOTTOM w0.254: v5(123.6,48.13) 123.36,48.13 122.86,47.62 UZ4.4 ; v5(119.77,43.3) 119.51,43.3 119.43,43.22 PRF01.1
  BOTTOM w0.508: v6(122.29,15.01) 122.29,15.03 121.1,16.22 121.1,21.06 121.47,21.43 v6(121.47,24.2)
  BOTTOM w1.016: 90.9,24.8 91.61,25.5 94.99,25.5 104.3,34.82 104.3,36.47 103.29,37.48 98.59,37.48 98.41,37.31
  vias: v2(115.37,59.56) v2(115.51,59.89) v2(117.75,55.04) v2(117.77,54.73) v2(118.06,46.81) v2(118.44,46.81) v3(30.76,22.18) v3(118.07,64.85) v3(129.07,68.66) v4(118.26,46.44) v4(118.97,52.58) v4(119.48,52.59) v6(29.51,21.9) v6(29.51,21.32) v6(29.51,20.74) v6(30.09,21.9) v6(30.09,21.32) v6(30.09,20.74) v6(30.25,20.16) v6(30.68,21.32) v6(30.68,20.74) v6(90.35,22.71) v6(90.38,22.1) v6(90.95,22.11) v6(97.43,36.82)
+5VALW_L_TBT: length 5
  IN3 w0.254: v5(20.09,27.44) 20.09,27.82 20.13,27.87 v4(20.13,28.21)
  BOTTOM w0.081: v1(30.67,36.79) 30.31,36.44 RPD121.2
  BOTTOM w0.203: UPD1.25 20,28.18 20,27.53
  BOTTOM w0.254: 20,27.53 v5(20.09,27.44) 20.09,26.9 20,26.82 CPD8.1
  vias: v2(23.74,34.89) v4(26.07,35.13) v4(26.07,34.64) v4(26.64,35.15) v4(26.64,34.65) v5(24.8,33.97) v5(24.82,35.11) v5(24.83,34.75) v5(24.81,34.33) v5(25.18,35.13) v5(25.19,34.76) v5(25.17,34.35) v5(25.16,33.98) v5(27.81,35.26) v5(27.81,34.91) v5(28.25,35.26) v5(28.27,34.93) v5(28.63,35.24) v5(28.63,34.89) v5(28.99,35.26) v5(28.99,34.9)
+5VALWP: length 17.9
  IN2 w0.254: v6(22.22,24.59) 22.22,25.55 21.82,25.95 19.06,25.95 17.84,27.18 16.75,27.18 15.98,26.41 15.98,23.86 12.59,20.47 12.59,20.33 v4(11.99,19.74)
  IN3 w0.254: v5(12.55,19.74) v4(11.99,19.74)
  BOTTOM w0.254: PR508.1 12.86,20.27 12.55,19.97 PC515.2 v5(12.55,19.74)
  vias: v3(23.01,22.77) v6(22.25,23.62) v6(22.74,24.87) v6(22.93,24.23) v6(23.39,24.84) v6(23.59,24.14) v6(24.03,24.81) v6(24.33,24.17) v6(24.69,24.72) v6(25.39,24.03)
+5VS: length 255.7
  TOP w0.254: v6(61.37,15.22) RE213.1
  TOP w0.508: Q12.3 60.18,6.02 60.03,5.86 55.21,5.86 53.34,7.74 v6(52.68,7.74) 52.68,7.88 52.17,8.39 45.94,8.39 45.92,8.37 45.44,8.37 45.42,8.39 F3.2 ; v6(48.31,37.76) 48.5,37.76 50.21,39.47 v6(50.21,40.39) ; v6(34.05,33.8) 34.2,33.95 34.2,34.73 34.64,35.17 34.64,35.89 35.48,36.73 35.48,38.15 UV17.1
  IN1 w0.508: 120.6,19.27 120.31,19.27 119.3,20.29 118.27,20.29 116.02,18.04 116.02,17.09 115.56,16.63 115.12,16.63 114.38,17.37 111.96,17.37 111.13,16.54 110.58,16.54 ; v4(166.53,16.67) 166.05,16.67 165.53,17.19 165.53,18.29 164.34,19.48 162.91,19.48 158.81,23.58 152.1,23.58 151.73,23.2 150.65,23.2 148.93,21.49 140.07,21.49 139.59,21.97 139.59,25.66 139.08,26.16 138.71,26.16 137.29,27.59 131.01,27.59 129.67,26.24 128.21,26.24 124.51,22.54 124.51,21.91 123.7,21.09
  IN2 w0.508: v6(34.05,33.8) 34.64,33.8 34.86,33.58 37.67,33.58 38.22,34.14 38.29,34.14 39.03,34.87 40.84,34.87 42.35,36.38 46.93,36.38 v6(48.31,37.76) ; v4(166.53,16.67) 166.53,15.47 163.48,12.41 163.48,8.75 164.16,8.06 191.57,8.06 v4(193.17,9.66)
  BOTTOM w0.508: v6(50.21,40.39) 50.22,40.38 61.67,40.38 71.75,30.3 86.48,30.3 88.23,28.54 ; v6(52.68,7.74) 52.12,8.3 52.12,8.57 51.03,9.65 51.03,11.89 51.61,12.47 51.61,14.31 53.4,16.1 59.34,16.1 59.93,15.51 61.08,15.51 v6(61.37,15.22) 61.37,14.75 61.31,14.69 61.31,13.97 63.94,11.33 80.3,11.33 82.66,13.69 89.83,13.69 90.43,14.29 90.43,15.79 90.06,16.16 v6(90.06,16.62)
  vias: v2(194.72,9.49) v2(194.97,9.74) v3(88.67,26.7) v4(109.13,16.61) v4(109.77,16.59) v6(88.81,27.45) v6(89.24,26.93) v6(89.4,26.38) v6(90.67,16.62)
+8.4V_BATT:
  vias: v3(99.59,9.93)
+8.4V_BATT+: length 1.4
  TOP w0.081: PL4.2 101.43,11.77 v3(100.1,11.77)
  vias: v2(101.56,12.33) v2(101.94,12.32) v2(102.32,12.32) v2(102.7,12.32) v2(103.08,12.32) v2(103.46,12.32) v2(103.84,12.32) v2(104.22,12.32) v2(104.61,12.32) v2(105.11,12.31) v2(105.49,12.32) v2(105.88,12.32) v2(106.26,12.32) v2(106.64,12.31) v2(107.02,12.31) v2(107.4,12.31) v2(107.78,12.31) v2(108.16,12.31) v3(104.74,12.85) v3(106.71,12.79) v4(101.69,11.77) v4(101.69,11.27) v4(102.32,11.77) v4(102.32,11.27) v4(102.96,11.77) v4(102.96,11.27) v4(103.59,11.77) v4(103.59,11.27) v4(104.23,11.77) v4(104.23,11.27) v4(104.86,11.77) v4(104.86,11.27) v4(105.5,11.77) v4(105.5,11.27) v4(106.13,11.77) v4(106.13,11.27) v4(106.77,11.77) v4(106.77,11.27) v5(101.16,12.64) v5(101.16,12.26) v5(101.6,12.63) v5(101.6,12.25) v5(102.29,12.64) v5(102.29,12.25) v5(103.2,12.49) v5(103.18,12.11) v5(103.86,12.49) v5(103.86,12.11) v5(104.42,12.51) v5(104.43,12.11) v5(105.05,12.53) v5(105.05,12.15) v5(105.69,12.53) v5(105.68,12.16) v5(106.32,12.52) v5(106.33,12.15)
+VCC1V8_TBT_L_LDO: length 3.9
  IN3 w0.254: v5(17.23,31.49) 17.07,31.33 16.53,31.33 16.23,31.03 16.23,30.49 15.98,30.24 15.93,30.24 v5(15.6,29.9)
  BOTTOM w0.203: UPD1.35 v5(17.23,31.49)
  BOTTOM w0.254: CPD51.1 v5(15.6,29.9)
+VCC3V3_TBT_L_LDO: length 129.6
  TOP w0.254: v2(19.09,25.77) 19.09,27.41 19.01,27.48 ; v2(19.09,25.77) 15.81,25.77 14.76,26.82 14.76,37.42 15.12,37.77 15.67,37.77 ; v2(19.09,25.77) 19.38,25.48 20.15,25.48 20.6,25.92 20.6,28.15 21.22,28.77 21.22,34.45 21.3,34.53 ; RT578.2 39.79,50.79 39.79,50.01 39.2,49.43 39.2,48.73 39.71,48.22 40.54,48.22 40.9,47.86 v3(40.9,47.14) 40.9,47.04 40.6,46.75 38.94,46.75 38.8,46.61 35.66,46.61 35.09,46.03 33.97,46.03 33.24,45.3 33.24,43.28 32.93,42.98 32.93,42.55 v2(32.13,41.75) ; v2(21.28,34.53) 21.3,34.53 ; 21.3,34.53 21.89,34.53 22.2,34.84 22.2,35.22 22.59,35.61 24,35.61 24.25,35.35 24.25,34.82 24.61,34.46 27.53,34.46 v2(27.64,34.57)
  IN1 w0.254: v2(25.4,10.65) 24.88,11.17 15.68,11.17 14.46,9.95 8.67,9.95 8.36,10.25 8.36,11.91 6.98,13.3 6.98,25.39 7.21,25.63 10.29,25.63 10.65,25.99 15.22,25.99 15.57,25.64 17.77,25.64 17.9,25.77 v2(19.09,25.77) 19.91,26.59 v4(20.17,26.59) ; v2(21.28,34.53) 20.84,34.53 20.49,34.88 v4(20.32,34.88) ; v2(27.64,34.57) 27.97,34.57 28.12,34.42 v4(28.3,34.42) 28.36,34.47 28.36,37.43 29.57,38.65 30.93,38.65 32.84,40.55 32.84,41.03 v2(32.13,41.75)
  IN2 w0.254: v4(28.26,31.41) 27.68,31.99 27.68,33.79 v4(28.3,34.42)
  IN3 w0.254: v4(20.17,26.59) 20.73,26.59 21.48,27.34 v5(22.14,27.34) ; v5(25.7,31.1) 26.01,31.1 26.52,31.6 27.21,31.6 27.48,31.33 v5(27.8,31.33) 28.18,31.33 v4(28.26,31.41) ; v4(20.32,34.88) 20.23,34.88 19.35,34 17.11,34 16.18,33.06 v5(15.82,33.06)
  BOTTOM w0.203: UPD1.9 v5(25.7,31.1)
  BOTTOM w0.254: RPD129.2 v5(15.82,33.06)
+VCC_CORE: length 96.3
  IN1 w0.254: v4(155.47,36.48) 155.07,36.09 v2(155.07,36.01) ; v4(161.64,35.26) 161.64,35.53 161.19,35.98 v2(161.18,35.98) ; v4(164.29,35.66) 164.14,35.66 163.76,36.04 v2(163.09,36.04) ; v4(152.39,35.82) 152.45,35.87 152.54,35.87 v2(152.71,36.05) ; v4(158.95,35.73) 159.05,35.83 159.05,35.93 v2(159.14,36.03) ; v4(156.74,36.33) 157.01,36.05 v2(157.08,36.05)
  IN3 w0.254: v5(152.07,36.01) 152.26,35.82 v4(152.39,35.82) ; v4(152.56,50.39) v5(152.85,50.68) ; v4(151.99,51.08) 151.94,51.03 v5(151.94,50.68) ; v4(168.69,34.71) 169,34.71 169.3,35.02 169.3,35.5 v5(169.2,35.6) ; v4(158.13,50.33) 158.13,50.49 v5(158.32,50.68) ; v4(161.64,35.26) 161.75,35.38 v5(161.95,35.38) ; v4(152.28,33.63) 152.31,33.63 v5(152.62,33.94) ; v4(159.89,50.42) v5(160.14,50.68) ; v5(159.29,36.05) 159.27,36.05 v4(158.95,35.73) ; v5(166.71,36.01) 167.06,36.01 v4(167.07,35.99) ; v5(164.27,36.01) 164.27,35.68 v4(164.29,35.66) ; v5(159.23,50.68) 159.04,50.49 v4(159.04,50.34) ; v4(157.14,50.31) 157.41,50.58 v5(157.41,50.68) ; v5(157.86,52.07) 157.86,52.06 v5(158.32,51.61) v4(158.75,51.61) v5(159.23,51.61) v5(160.14,51.61) ; v5(156.49,50.68) 156.43,50.6 v4(156.04,50.56) ; v4(156.04,51.58) v5(156.04,51.14)
  BOTTOM w0.102: 156.69,50.88 v5(156.49,50.68) ; v5(156.49,50.68) 156.74,50.43 ; v5(156.49,50.68) 156.31,50.87 ; v5(156.49,50.68) 156.26,50.45 ; 166.42,40.56 v5(166.65,40.79) ; v5(166.65,40.79) 166.47,40.97 ; v5(166.65,40.79) 166.86,40.58 ; v5(166.65,40.79) 166.86,41 ; 159.03,51.41 v5(159.23,51.61) ; v5(159.23,51.61) 158.99,51.84 ; v5(159.23,51.61) 159.45,51.83 ; v5(159.23,51.61) 159.44,51.4 ; 164.55,40.55 v5(164.34,40.33) ; v5(164.34,40.33) 164.54,40.13 ; v5(164.34,40.33) 164.08,40.08 ; v5(164.34,40.33) 164.16,40.52 ; 158.99,40.14 v5(158.8,40.33) ; v5(158.8,40.33) 158.57,40.11 ; v5(158.8,40.33) 158.62,40.52 ; v5(158.8,40.33) 159,40.54 ; 157.59,50.49 v5(157.41,50.68) ; v5(157.41,50.68) 157.62,50.89 ; v5(157.41,50.68) 157.17,50.45 ; v5(157.41,50.68) 157.19,50.89 ; 156.7,40.58 v5(156.49,40.79) ; v5(156.49,40.79) 156.72,41.02 ; v5(156.49,40.79) 156.27,40.58 ; v5(156.49,40.79) 156.29,40.98 ; 165.94,40.58 v5(165.73,40.79) ; v5(165.73,40.79) 165.93,41 ; v5(165.73,40.79) 165.54,40.97 ; v5(165.73,40.79) 165.49,40.56 ; 158.99,51.36 UC1.AR25 ; UC1.AR25 158.57,51.35 ; UC1.AR25 159,50.91 ; UC1.AR25 158.57,50.94 ; 161.34,41.48 UC1.AL10 ; UC1.AL10 161.79,41.03 ; UC1.AL10 161.8,41.48 ; UC1.AL10 161.37,41.05 ; 154.42,51.86 v5(154.67,51.61) ; v5(154.67,51.61) 154.46,51.39 ; v5(154.67,51.61) 154.88,51.4 ; v5(154.67,51.61) 154.91,51.85 ; 159.02,41.03 v5(158.8,41.25) ; v5(158.8,41.25) 158.58,41.47 ; v5(158.8,41.25) 159.02,41.47 ; v5(158.8,41.25) 158.61,41.06 ; 153.5,50.94 v5(153.3,51.14) ; v5(153.3,51.14) 153.54,51.37 ; v5(153.3,51.14) 153.1,51.35 ; v5(153.3,51.14) 153.11,50.95 ; 162.77,40.6 v5(162.95,40.79) ; v5(162.95,40.79) 163.18,40.56 ; v5(162.95,40.79) 163.15,40.98 ; v5(162.95,40.79) 162.76,40.98 ; 155.8,51.39 v5(155.58,51.61) ; v5(155.58,51.61) 155.8,51.82 ; v5(155.58,51.61) 155.36,51.83 ; v5(155.58,51.61) 155.4,51.42 ; 153.06,40.53 v5(153.25,40.33) ; v5(153.25,40.33) 153.49,40.1 ; v5(153.25,40.33) 153.48,40.56 ; v5(153.25,40.33) 153.04,40.11 ; 159.92,51.83 v5(160.14,51.61) 159.93,51.4 ; 157.63,40.09 v5(157.87,40.33) ; v5(157.87,40.33) 158.09,40.12 ; v5(157.87,40.33) 158.1,40.56 ; v5(157.87,40.33) 157.67,40.54 ; 163.63,40.12 v5(163.42,40.33) ; v5(163.42,40.33) 163.65,40.57 ; v5(163.42,40.33) 163.21,40.54 ; v5(163.42,40.33) 163.22,40.13 ; 152.14,50.88 v5(151.94,50.68) 152.18,50.43 ; 155.4,50.87 UC1.AY24 ; UC1.AY24 155.78,50.88 ; UC1.AY24 155.8,50.46 ; UC1.AY24 155.36,50.45 ; 157.19,40.57 v5(157.41,40.79) ; v5(157.41,40.79) 157.63,41.01 ; v5(157.41,40.79) 157.22,40.98 ; v5(157.41,40.79) 157.62,40.58 ; 152.08,40.58 v5(151.87,40.79) 152.08,41 ; 155.83,51.35 v5(156.04,51.14) ; v5(156.04,51.14) 156.26,50.92 ; v5(156.04,51.14) 155.84,50.94 ; v5(156.04,51.14) 156.27,51.37 ; 163.67,40.58 UC1.AG9 ; UC1.AG9 164.12,40.55 ; UC1.AG9 163.66,41.01 ; UC1.AG9 164.11,41.02 ; UC1.BF26 152.15,51.4 ; UC1.BF26 151.73,51.82 ; UC1.BF26 151.73,51.4 ; UC1.BF26 152.19,51.86 ; UC1.AN9 160.39,40.99 ; UC1.AN9 160,40.97 ; UC1.AN9 159.97,40.58 ; UC1.AN9 160.41,40.56 ; 161.79,40.55 v5(161.57,40.33) ; v5(161.57,40.33) 161.36,40.12 ; v5(161.57,40.33) 161.76,40.14 ; v5(161.57,40.33) 161.37,40.53 ; 165.02,40.57 v5(164.8,40.79) ; v5(164.8,40.79) 164.6,40.59 ; v5(164.8,40.79) 164.58,41.01 ; v5(164.8,40.79) 165.04,41.02 ; 152.61,51.36 UC1.BE25 ; UC1.BE25 152.62,50.92 ; UC1.BE25 152.21,51.32 ; UC1.BE25 152.17,50.92 ; 162.27,40.55 UC1.AK9 ; UC1.AK9 161.84,40.98 ; UC1.AK9 162.23,40.99 ; UC1.AK9 161.85,40.6 ; 159.07,40.6 v5(159.26,40.79) ; v5(159.26,40.79) 159.47,40.58 ; v5(159.26,40.79) 159.49,41.02 ; v5(159.26,40.79) 159.06,40.98 ; 161.3,40.59 v5(161.11,40.79) ; v5(161.11,40.79) 161.33,41.01 ; v5(161.11,40.79) 160.91,40.59 ; v5(161.11,40.79) 160.89,41.01 ; 153.02,41.02 v5(152.79,40.79) ; v5(152.79,40.79) 153.02,40.56 ; v5(152.79,40.79) 152.59,40.59 ; v5(152.79,40.79) 152.59,40.99 ; 156.69,51.41 v5(156.49,51.61) ; v5(156.49,51.61) 156.26,51.84 ; v5(156.49,51.61) 156.71,51.82 ; v5(156.49,51.61) 156.31,51.42 ; 153.57,51.41 v5(153.76,51.61) ; v5(153.76,51.61) 153.52,51.84 ; v5(153.76,51.61) 154.03,51.87 ; v5(153.76,51.61) 153.96,51.4 ; 162.71,41.03 v5(162.49,41.25) ; v5(162.49,41.25) 162.68,41.43 ; v5(162.49,41.25) 162.31,41.06 ; v5(162.49,41.25) 162.29,41.45 ; 155.33,50.94 v5(155.13,51.14) ; v5(155.13,51.14) 155.36,51.37 ; v5(155.13,51.14) 154.9,50.92 ; v5(155.13,51.14) 154.92,51.35 ; 167.82,41.03 v5(168.04,41.25) 167.8,41.48 ; 153.06,51.39 v5(152.85,51.61) ; v5(152.85,51.61) 153.09,51.84 ; v5(152.85,51.61) 152.61,51.84 ; v5(152.85,51.61) 152.65,51.41 ; 157.21,51.41 UC1.AU26 ; UC1.AU26 157.19,51.82 ; UC1.AU26 157.62,51.39 ; UC1.AU26 157.64,51.84 ; UC1.BC9 153.94,41.01 ; UC1.BC9 153.94,40.57 ; UC1.BC9 153.52,40.98 ; UC1.BC9 153.53,40.6 ; 155.3,40.14 v5(155.1,40.33) ; v5(155.1,40.33) 155.32,40.55 ; v5(155.1,40.33) 154.88,40.55 ; v5(155.1,40.33) 154.89,40.12 ; 156.25,40.11 v5(156.03,40.33) ; v5(156.03,40.33) 156.21,40.52 ; v5(156.03,40.33) 155.79,40.1 ; v5(156.03,40.33) 155.82,40.54 ; 158.07,51.35 UC1.AU25 ; UC1.AU25 157.65,50.93 ; UC1.AU25 158.08,50.93 ; UC1.AU25 157.66,51.35 ; 166.4,40.13 v5(166.19,40.33) ; v5(166.19,40.33) 165.98,40.54 ; v5(166.19,40.33) 165.91,40.06 165.91,40.06 ; v5(166.19,40.33) 166.41,40.55 ; 159.92,41.05 v5(159.72,41.25) ; v5(159.72,41.25) 159.5,41.47 ; v5(159.72,41.25) 159.96,41.48 ; v5(159.72,41.25) 159.52,41.05 ; 158.52,50.47 v5(158.32,50.68) ; v5(158.32,50.68) 158.12,50.88 ; v5(158.32,50.68) 158.54,50.9 ; v5(158.32,50.68) 158.11,50.47 ; 166.9,41.03 v5(167.11,41.25) ; v5(167.11,41.25) 167.29,41.43 ; v5(167.11,41.25) 167.33,41.03 ; v5(167.11,41.25) 166.88,41.48 ; 156.25,41.03 v5(156.03,41.25) ; v5(156.03,41.25) 155.83,41.05 ; v5(156.03,41.25) 155.81,41.47 ; v5(156.03,41.25) 156.26,41.48 ; 160.86,40.12 v5(160.65,40.33) ; v5(160.65,40.33) 160.87,40.56 ; v5(160.65,40.33) 160.41,40.1 ; v5(160.65,40.33) 160.45,40.53 ; 165.45,41.43 v5(165.26,41.25) ; v5(165.26,41.25) 165.05,41.03 ; v5(165.26,41.25) 165.48,41.03 ; v5(165.26,41.25) 165.03,41.48 ; 158.09,51.83 v5(158.32,51.61) ; v5(158.32,51.61) 158.53,51.82 ; v5(158.32,51.61) 158.12,51.41 ; v5(158.32,51.61) 158.53,51.39 ; 158.57,40.55 v5(158.34,40.79) ; v5(158.34,40.79) 158.56,41.01 ; v5(158.34,40.79) 158.12,40.58 ; v5(158.34,40.79) 158.12,41.01 ; 159.45,50.9 v5(159.23,50.68) ; v5(159.23,50.68) 159.03,50.88 ; v5(159.23,50.68) 159.02,50.47 ; v5(159.23,50.68) 159.45,50.46 ; 159.92,50.9 v5(160.14,50.68) 159.94,50.48 ; 165.5,40.1 v5(165.26,40.33) ; v5(165.26,40.33) 165.45,40.52 ; v5(165.26,40.33) 165.08,40.52 ; v5(165.26,40.33) 165.02,40.09 ; 167.34,40.56 v5(167.57,40.79) ; v5(167.57,40.79) 167.78,41 ; v5(167.57,40.79) 167.79,40.58 ; v5(167.57,40.79) 167.39,40.97 ; 154.37,41.06 v5(154.18,41.25) ; v5(154.18,41.25) 154.41,41.48 ; v5(154.18,41.25) 153.95,41.48 ; v5(154.18,41.25) 153.97,41.04 ; 164.55,41.46 v5(164.34,41.25) ; v5(164.34,41.25) 164.14,41.05 ; v5(164.34,41.25) 164.53,41.06 ; v5(164.34,41.25) 164.09,41.49 ; 153.49,41.48 v5(153.25,41.25) ; v5(153.25,41.25) 153.49,41.01 ; v5(153.25,41.25) 153.05,41.45 ; v5(153.25,41.25) 153.06,41.05 ; 162.31,40.52 v5(162.49,40.33) ; v5(162.49,40.33) 162.7,40.13 ; v5(162.49,40.33) 162.7,40.54 ; v5(162.49,40.33) 162.26,40.1 ; 153.05,50.48 v5(152.85,50.68) ; v5(152.85,50.68) 153.06,50.89 ; v5(152.85,50.68) 152.65,50.88 ; v5(152.85,50.68) 152.63,50.46 ; 156.71,41.49 v5(156.95,41.25) ; v5(156.95,41.25) 156.76,41.06 ; v5(156.95,41.25) 157.16,41.46 ; v5(156.95,41.25) 157.19,41.01
  BOTTOM w0.254: UC1.BB2 154.29,35.79 154.29,35.49 153.86,35.07 153.86,34.77 153.03,33.94 v5(152.62,33.94) ; RC167.1 159.33,33.04 159.07,33.3 159.07,35.3 159.39,35.62 UC1.AP2 ; v5(161.95,35.38) 161.95,35.6 161.89,35.67 161.89,35.96 UC1.AK2 ; v5(169.2,35.6) 169.15,35.65 UC1.V2 ; UC1.AV2 156.65,36.01 v5(156.62,35.97)
  vias: v2(153.03,51.25) v2(153.03,50.7) v2(153.03,49.01) v2(153.03,48.44) v2(153.03,47.86) v2(153.03,47.3) v2(153.03,46.74) v2(153.03,46.18) v2(153.03,45.62) v2(153.03,45.06) v2(153.03,44.5) v2(153.03,43.94) v2(153.03,43.38) v2(153.03,42.82) v2(153.19,42.27) v2(153.69,51.25) v2(153.87,42.5) v2(153.87,42.24) v2(154.27,46.4) v2(154.32,45.68) v2(154.43,48.71) v2(154.43,48.46) v2(154.58,45.68) v2(154.66,38.74) v2(154.67,38.48) v2(154.66,37.96) v2(154.66,37.71) v2(155.05,42.5) v2(155.05,42.25) v2(155.11,41.11) v2(155.11,39.92) v2(155.11,38.72) v2(155.36,41.11) v2(155.36,39.92) v2(155.36,38.72) v2(155.44,51.25) v2(155.44,50.7) v2(155.63,48.71) v2(155.63,48.46) v2(156.04,52.07) v2(156.08,41.09) v2(156.08,39.91) v2(156.08,38.7) v2(156.29,42.52) v2(156.29,42.27) v2(156.38,51.23) v2(156.37,50.67) v2(156.33,41.09) v2(156.33,39.92) v2(156.33,38.71) v2(156.74,39.81) v2(156.74,39.55) v2(156.74,38.55) v2(156.74,38.3) v2(156.82,48.71) v2(156.82,48.46) v2(157.48,42.51) v2(157.49,42.25) v2(158.01,48.71) v2(158.01,48.46) v2(158.27,51.24) v2(158.27,50.66) v2(158.21,45.66) v2(158.46,45.66) v2(158.51,46.38) v2(158.51,44.52) v2(158.62,42.53) v2(158.62,42.28) v2(158.86,51.24) v2(158.86,50.67) v2(158.97,47.39) v2(158.97,47.14) v2(158.95,46.81) v2(158.95,46.56) v2(158.91,46.03) v2(158.91,45.78) v2(158.91,45.35) v2(158.91,45.1) v2(159.18,48.68) v2(159.18,48.43) v2(159.18,48.08) v2(159.18,47.83) v2(159.26,44.67) v2(159.26,44.42) v2(159.69,46.14) v2(159.67,45.32) v2(159.71,46.95) v2(159.79,42.49) v2(159.8,43.49) v2(159.97,47.46) v2(160.06,48.8) v2(160.06,48.55) v2(160.06,43.5) v2(160.14,42.45) v2(160.29,47.21) v2(160.29,46.57) v2(160.29,45.94) v2(160.93,47.21) v2(160.93,46.57) v2(160.93,45.94) v2(161.06,47.83) v2(161.56,47.21) v2(161.56,46.57) v2(161.56,45.94) v2(162.68,48.72) v2(162.68,48.46) v2(162.92,47.56) v2(162.92,47.31) v2(162.96,46.41) v2(162.97,46.15) v2(162.96,45.81) v2(162.97,45.55) v2(162.99,45.19) v2(162.99,44.94) v2(162.99,44.59) v2(162.99,44.34) v2(162.93,42.59) v2(163.07,43.87) v2(163.05,43.5) v2(163.26,48.72) v2(163.26,48.47) v2(163.36,48.05) v2(163.36,47.79) v2(163.36,47.44) v2(163.36,47.19) v2(163.57,43.49) v2(163.57,42.45) v2(163.53,39.92) v2(163.73,42.71) v2(163.79,39.93) v2(163.82,43.5) v2(163.82,42.46) v2(164,46.38) v2(164,45.78) v2(164,45.17) v2(164,44.57) v2(164,46.13) v2(164,45.53) v2(164,44.91) v2(164,44.31) v2(164.37,47.68) v2(164.37,47.42) v2(164.37,47.08) v2(164.37,46.82) v2(164.98,46.39) v2(164.99,46.14) v2(164.98,45.79) v2(164.99,45.54) v2(165.05,45.17) v2(165.05,44.91) v2(165.05,44.57) v2(165.05,44.31) v2(165.26,43.48) v2(165.26,42.72) v2(165.25,42.37) v2(165.52,43.48) v2(165.51,42.73) v2(165.51,42.37) v2(165.92,43.49) v2(165.92,42.3) v2(166.01,42.71) v2(166.17,43.5) v2(166.17,42.3) v2(166.87,43.49) v2(166.87,42.3) v2(166.87,41.11) v2(167.13,43.5) v2(167.13,42.3) v2(167.13,41.11) v3(157.06,25.74) v4(151.95,52.27) v4(152.08,51.76) v4(152.8,41.19) v4(152.85,52.04) v4(153.24,40.76) v4(153.32,51.61) v4(153.36,49.01) v4(153.36,48.44) v4(153.36,47.86) v4(153.36,47.3) v4(153.36,46.74) v4(153.36,46.18) v4(153.36,45.62) v4(153.36,45.06) v4(153.36,44.5) v4(153.36,43.94) v4(153.36,43.38) v4(153.36,42.82) v4(153.77,52.07) v4(153.74,39.4) v4(153.94,46.4) v4(154.07,43.21) v4(154.17,52.54) v4(154.18,42.37) v4(154.22,51.73) v4(154.45,45.37) v4(154.64,40.78) v4(154.74,48.58) v4(154.99,43.14) v4(155.11,51.6) v4(155.23,40.8) v4(155.23,39.61) v4(155.23,38.41) v4(155.36,42.38) v4(155.58,40.39) v4(155.67,43.15) v4(155.87,40.77) v4(155.93,48.58) v4(155.92,37.73) v4(156.18,36.33) v4(156.21,39.61) v4(156.21,38.4) v4(156.39,51.95) v4(156.31,43.12) v4(156.6,42.4) v4(156.51,39.19) v4(156.65,37.73) v4(156.92,40.84) v4(157.04,43.12) v4(157.13,48.58) v4(157.39,38.71) v4(157.43,39.98) v4(157.46,39.35) v4(157.55,37.48) v4(157.69,43.14) v4(157.65,38.27) v4(157.79,42.38) v4(157.87,40.75) v4(158.09,37.82) v4(158.27,43.11) v4(158.3,40.27) v4(158.29,39.75) v4(158.26,38.67) v4(158.32,48.58) v4(158.33,45.35) v4(158.33,39.22) v4(158.68,38.35) v4(158.79,40.77) v4(158.84,44.52) v4(158.92,42.41) v4(159.27,47.27) v4(159.26,46.68) v4(159.22,45.9) v4(159.22,45.23) v4(159.49,48.56) v4(159.49,47.96) v4(159.57,44.55) v4(159.93,43.19) v4(160.37,48.68) v4(160.35,45.34) v4(160.4,47.98) v4(160.99,45.34) v4(161.11,41.12) v4(161.59,41.89) v4(161.69,42.74) v4(161.67,40.98) v4(163.06,43.14) v4(163.06,42.29) v4(163.27,46.28) v4(163.27,45.68) v4(163.3,45.07) v4(163.3,44.46) v4(163.67,47.92) v4(163.67,47.32) v4(163.69,43.19) v4(163.7,42.15) v4(163.66,39.59) v4(164.31,46.25) v4(164.31,45.65) v4(164.31,45.04) v4(164.31,44.44) v4(164.68,47.55) v4(164.68,46.95) v4(165,35.87) v4(165.29,46.27) v4(165.29,45.67) v4(165.29,40.86) v4(165.36,45.04) v4(165.36,44.44) v4(165.39,43.17) v4(165.69,36.07) v4(166.04,43.19) v4(166.04,41.99) v4(166.53,33.47) v4(166.64,43.99) v4(166.8,39.25) v4(167,43.19) v4(167,41.99) v4(167,40.8) v4(167.46,35.41) v4(167.7,40.15) v4(167.73,34.85) v4(167.92,34.21) v4(168.66,33.31) v4(169.88,33.3) v5(151.48,52.07) v5(152.39,52.07) v5(153.3,52.07) v5(154.18,39.68) v5(154.18,39.03) v5(154.22,52.07) v5(154.58,38.89) v5(154.71,38.57) v5(155.13,52.07) v5(155.78,39.39) v5(156.04,52.07) v5(156.03,39.03) v5(156.95,39.68) v5(156.95,38.38) v5(157.87,39.68) v5(157.87,39.03) v5(158.8,39.68) v5(158.8,39.03) v5(160.19,40.78) v5(161.32,41.5) v5(167.11,40.33) v5(168.04,40.33) v6(152.84,40.07) v6(152.97,50.03) v6(153.05,41.72) v6(153.67,50.03) v6(153.68,41.72) v6(154.23,50.38) v6(154.32,41.72) v6(154.58,40.01) v6(154.58,39.37) v6(154.67,52.24) v6(154.7,50.03) v6(154.94,41.74) v6(155.37,50.03) v6(155.59,52.29) v6(155.64,41.72) v6(156.08,50.03) v6(156.21,41.69) v6(156.65,50.04) v6(156.77,41.7) v6(157.4,41.73) v6(157.66,50.03) v6(158.01,41.74) v6(158.6,50.03) v6(158.65,41.74) v6(159.24,41.73) v6(159.52,50.03) v6(162.01,41.55) v6(162.97,39.93) v6(163.95,41.64) v6(165.35,41.75) v6(166.52,41.67) v6(167.53,41.66) v6(167.85,26.73) v6(167.85,26.09) v6(167.85,25.46) v6(168.49,26.73) v6(168.49,26.09) v6(168.49,25.46) v6(169.12,26.09) v6(169.12,25.46) v6(169.76,26.09) v6(169.76,25.46) v6(170.52,26.09) v6(170.52,25.46) v6(171.16,26.09) v6(171.16,25.46) v6(171.75,26.14) v6(171.77,25.57) v6(171.72,24.89) v6(171.72,24.26) v6(171.72,23.62) v6(171.72,22.99) v6(171.72,22.35) v6(171.72,21.72) v6(172.38,26.17) v6(172.38,25.53) v6(172.36,24.89) v6(172.36,24.26) v6(172.36,23.62) v6(172.36,22.99) v6(172.36,22.35) v6(172.35,21.72) v6(173.01,26.17) v6(173.01,25.53) v6(173.12,24.89) v6(173.12,24.26) v6(173.12,23.62) v6(173.12,22.99) v6(173.12,22.35) v6(173.11,21.76) v6(173.71,25.4) v6(173.75,24.84) v6(173.75,24.26) v6(173.75,23.62) v6(173.75,22.99) v6(173.75,22.35) v6(173.75,21.74) v6(174.35,25.4) v6(174.38,24.84) v6(174.39,24.26) v6(174.39,23.62) v6(174.39,22.99) v6(174.39,22.35) v6(174.38,21.74) v6(175.16,25.37) v6(175.82,25.35) v6(176.51,25.35) v6(177.25,25.38) v6(178.31,26.12) v6(178.31,25.49) v6(178.89,21.73) v6(178.94,26.12) v6(178.94,25.49) v6(179.18,24.86) v6(179.18,24.22) v6(179.18,23.59) v6(179.18,22.95) v6(179.18,22.32) v6(179.58,26.12) v6(179.58,25.49) v6(179.53,21.73) v6(179.81,24.86) v6(179.81,24.22) v6(179.81,23.59) v6(179.81,22.95) v6(179.81,22.32) v6(180.16,21.73) v6(180.21,25.49) v6(180.57,24.86) v6(180.57,24.22) v6(180.57,23.59) v6(180.57,22.95) v6(180.57,22.32) v6(180.88,25.5) v6(180.82,21.73) v6(181.18,24.88) v6(181.21,24.22) v6(181.21,23.59) v6(181.21,22.95) v6(181.21,22.32) v6(181.46,25.5) v6(181.46,21.73) v6(181.77,24.88) v6(181.8,24.18) v6(181.83,23.58) v6(181.83,22.95) v6(181.83,22.31) v6(182.05,25.5) v6(182.08,21.75) v6(182.39,24.89) v6(182.38,24.18) v6(182.44,23.55) v6(182.4,22.97) v6(182.66,25.5) v6(183.24,25.5) v6(183.82,25.5) v6(184.39,25.47) v6(184.97,25.47) v6(185.56,25.47) v6(186.14,25.47) v6(186.7,24.8) v6(186.74,24.23) v6(186.77,23.55) v6(186.71,22.94) v6(187.33,24.23) v6(187.35,23.55) v6(187.3,22.99)
+VCC_GT: length 41.3
  IN3 w0.203: v5(171.27,40.79) 171.11,40.95 v4(171.11,41.12) ; v4(179.64,44.7) 179.46,44.7 v5(179.28,44.51) ; v4(177.88,39.19) 177.88,39.19 ; v5(177.97,38.78) v4(178.2,38.55) ; v4(174.27,40.1) v5(174.5,40.33) ; v5(170.35,40.79) v4(170.11,41.02) ; v5(178.61,40.09) 178.84,39.86
  IN3 w0.254: v5(179.27,45.45) 179.5,45.21 ; v5(175.43,40.33) 175.43,40.3 175.17,40.04 v4(175.13,40.04) ; v5(178.62,41.68) v4(178.85,41.44) ; v5(176.35,39.03) v4(176.12,38.8) ; v5(175.37,41.68) v4(175.6,41.44) ; v5(177.97,45.45) 178.2,45.21 ; v5(177.32,45.45) 177.32,45.26 v4(177.6,44.97) ; v5(177.32,41.68) v4(177.55,41.44) ; v4(173.27,40) 173.58,40.31 v5(173.58,40.33) ; 175.14,45.15 175.2,45.22 175.2,45.28 v5(175.37,45.45) ; v5(172.19,40.79) v4(172.19,41.12) ; v5(173.12,40.79) 172.95,40.95 v4(172.95,41.1) ; v5(177.32,44.5) v4(177.55,44.27) ; v5(178.01,36.94) v4(177.78,36.71) ; v5(176.95,37.63) v4(176.71,37.87) ; v5(176.35,39.68) v4(176.12,39.45) ; v5(169.88,40.33) 169.55,40.33 v4(169.44,40.21) ; v5(176.02,41.68) v4(176.25,41.44) ; v5(177.97,43.56) v4(178.2,43.33) ; v5(179.27,40.09) v4(179.5,39.85) ; v5(177.97,44.5) v4(178.2,44.27) ; v5(174.5,39.68) v4(174.27,39.45) ; v4(170.33,40.07) 170.59,40.33 v5(170.81,40.33) ; v5(175.43,39.68) 175.43,39.67 v4(175.66,39.43) ; v5(176.67,45.45) 176.87,45.24 176.87,45.08 v4(177.02,44.92) ; v5(173.58,39.68) v4(173.34,39.45) ; v5(172.65,39.68) v4(172.42,39.45) ; v5(168.5,40.79) v4(168.97,40.79) ; v5(171.73,40.33) 171.69,40.33 v4(171.39,40.03) ; v5(179.24,37.9) v4(179.48,37.67) ; v5(177.56,37.41) v4(177.32,37.17) ; v5(178.66,37.48) v4(178.42,37.25) ; v5(175.43,39.03) v4(175.19,38.8) ; v4(172.35,40.03) v5(172.65,40.33) ; v5(178.62,43.56) v4(178.85,43.33) ; v5(179.27,38.77) v4(179.5,38.53) ; v5(174.72,41.68) v4(174.95,41.44) ; v4(172.35,35.42) 171.98,35.42 171.6,35.8 v5(171.6,36.01) ; v5(176.67,41.68) v4(176.9,41.44) ; v5(179.27,43.56) v4(179.5,43.33) ; v5(174.04,36.01) 174.04,36.05 v4(173.67,36.41) ; v5(176.67,43.56) v4(176.9,43.33) ; v5(175.37,44.5) v4(175.6,44.27) ; v5(178.17,36.28) 178.31,36.42 v4(178.31,36.61) ; v5(176.02,42.62) 176.02,42.44 v6(176.34,42.11) ; v5(176.02,43.56) v4(176.25,43.33) ; v5(176.35,38.38) v4(176.12,38.15) ; v5(177.32,43.56) v4(177.55,43.33) ; v4(176.12,40.1) v5(176.35,40.33) ; v5(177.97,41.68) v4(178.2,41.44)
  BOTTOM w0.102: 170.16,40.97 v5(170.35,40.79) ; v5(170.35,40.79) 170.56,40.58 ; v5(170.35,40.79) 170.55,41 ; v5(170.35,40.79) 170.14,40.59 ; UC1.T10 170.59,41.03 ; UC1.T10 171.03,41.47 ; UC1.T10 171.02,41.03 ; UC1.T10 170.59,41.47 ; 171.99,40.59 v5(172.19,40.79) ; v5(172.19,40.79) 172.01,40.97 ; v5(172.19,40.79) 172.4,40.58 ; v5(172.19,40.79) 172.4,41 ; 169.66,41.47 UC1.U10 ; UC1.U10 170.1,41.03 ; UC1.U10 169.67,41.03 ; UC1.U10 170.1,41.47 ; 172.43,41.47 UC1.N10 ; UC1.N10 172.88,41.47 ; UC1.N10 172.44,41.03 ; UC1.N10 172.87,41.03 ; 169.63,40.58 UC1.V9 ; UC1.V9 169.22,40.59 ; UC1.V9 169.24,40.97 ; UC1.V9 169.63,41 ; 171.48,40.58 v5(171.27,40.79) ; v5(171.27,40.79) 171.09,40.97 ; v5(171.27,40.79) 171.48,41 ; v5(171.27,40.79) 171.06,40.59 ; 173.8,41.03 UC1.L10 ; UC1.L10 173.36,41.47 ; UC1.L10 173.8,41.47 ; UC1.L10 173.36,41.03 ; 173.85,41.46 UC1.K11 ; UC1.K11 174.26,41.87 ; UC1.K11 173.83,41.92 ; UC1.K11 174.26,41.49 ; 173.33,40.58 v5(173.12,40.79) ; v5(173.12,40.79) 173.32,41 ; v5(173.12,40.79) 172.93,40.97 ; v5(173.12,40.79) 172.91,40.59 ; 168.71,40.58 v5(168.5,40.79) ; v5(168.5,40.79) 168.32,40.97 ; v5(168.5,40.79) 168.29,40.59 ; v5(168.5,40.79) 168.71,41
  BOTTOM w0.254: RC169.1 183.46,33.08 183.72,33.34 183.72,34.58 183.48,34.82 183.05,34.82 182.53,35.35 182.53,37.83 182.76,38.06
  vias: v2(169.46,40.83) v2(170.68,47.05) v2(170.68,45.86) v2(170.68,44.66) v2(170.68,43.47) v2(170.93,47.05) v2(170.93,45.86) v2(170.93,44.67) v2(170.93,43.47) v2(170.95,40.79) v2(171.86,40.8) v2(172.8,40.8) v2(173.14,44.66) v2(173.14,43.47) v2(173.39,44.67) v2(173.39,43.47) v2(173.71,40.8) v2(174.73,41.89) v2(174.79,40.31) v2(175.42,41.87) v2(176.13,42.94) v2(176.38,42.94) v2(177.88,42.96) v2(178.13,42.96) v2(178.3,39.37) v2(178.32,40.15) v2(179.56,42.94) v2(180.14,42.94) v3(182.59,40.35) v4(170.8,46.75) v4(170.8,45.55) v4(170.8,44.36) v4(170.8,43.17) v4(173.27,44.36) v4(173.27,43.17) v4(176.01,44.88) v4(177.75,39.78) v5(168.96,40.33) v5(174.72,47.33) v5(174.72,45.45) v5(174.72,43.56) v5(175.37,47.33) v5(175.37,46.39) v5(175.37,43.56) v5(175.43,38.38) v5(176.02,47.33) v5(176.02,46.39) v5(176.02,45.45) v5(176.02,44.49) v5(176.67,47.33) v5(177.32,42.62) v5(177.63,39.41) v5(177.97,46.39) v5(177.97,42.62) v5(178.02,39.99) v5(178.62,47.33) v5(178.62,38.78) v5(178.65,36.79) v5(179.27,46.39) v5(179.27,42.62) v5(179.27,41.68) v6(169.67,41.79) v6(170.23,41.68) v6(170.79,41.73) v6(171.35,41.8) v6(172.43,41.77) v6(173.07,42.31) v6(173.02,41.65) v6(173.58,41.73) v6(173.65,42.32) v6(174.26,43.09) v6(174.22,42.14) v6(174.32,44.94) v6(174.38,44.03) v6(177.64,42.15) v6(178.26,42.13) v6(178.93,44.97) v6(179.62,39.23) v6(179.64,35.54) v6(179.71,42.12) v6(179.82,38.09) v6(179.91,40.23) v6(180.39,38.5) v6(180.37,37.9) v6(180.34,37.03) v6(180.3,36.31) v6(180.32,35.65) v6(180.42,43.43) v6(180.41,42.13) v6(180.4,39.12) v6(180.51,40.07) v6(181.04,35.63) v6(184.04,41.49) v6(184.04,40.86) v6(184.04,40.22) v6(184.04,39.59) v6(184.67,41.49) v6(184.67,40.86) v6(184.67,40.22) v6(184.67,39.59) v6(185.31,41.49) v6(185.31,40.86) v6(185.31,40.22) v6(185.31,39.59) v6(185.94,41.49) v6(185.94,40.86) v6(185.94,40.22) v6(186.58,41.49) v6(186.58,40.86) v6(186.57,38.3) v6(187.21,41.49) v6(187.21,40.86) v6(187.2,38.3) v6(187.85,41.49) v6(187.85,40.86) v6(187.84,38.3) v6(188.48,41.49) v6(188.48,40.86) v6(188.47,38.3) v6(188.81,43.52) v6(188.81,42.89) v6(188.81,42.25) v6(189.12,41.49) v6(189.12,40.86) v6(189.11,38.3) v6(189.45,43.52) v6(189.45,42.89) v6(189.45,42.25) v6(190.08,43.52) v6(190.08,42.89) v6(190.08,42.25) v6(190.72,43.52) v6(191.37,43.47) v6(192.01,43.47) v6(192.61,43.44)

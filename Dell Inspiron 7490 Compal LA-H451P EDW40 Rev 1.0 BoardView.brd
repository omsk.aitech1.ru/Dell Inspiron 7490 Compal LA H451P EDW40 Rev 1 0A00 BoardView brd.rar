# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Nets (continued)
N36804565: PQ501.3 PR524.2
N40235254: T4990.1(TP-1) UC1.CR35
N40449957: PC1816.2 PQ1402.2 PR1815.1
N40451324: PQ1.2 PQ2.1 PR4.2
N41366254: JXDP1.4 TP105.1(TP-1)
N41366256: JXDP1.6 TP106.1(TP-1)
N41366258: JXDP1.10 TP107.1(TP-1)
N41366267: JXDP1.12 TP108.1(TP-1)
N41366269: JXDP1.16 TP109.1(TP-1)
N41366285: JXDP1.18 TP110.1(TP-1)
N41366301: JXDP1.22 TP111.1(TP-1)
N41366303: JXDP1.24 TP112.1(TP-1)
N41366319: JXDP1.28 TP113.1(TP-1)
N41366321: JXDP1.30 TP114.1(TP-1)
N41366330: JXDP1.34 TP115.1(TP-1)
N41366332: JXDP1.36 TP116.1(TP-1)
N41366348: JXDP1.9 TP117.1(TP-1)
N41366350: JXDP1.11 TP118.1(TP-1)
N41366366: JXDP1.15 TP119.1(TP-1)
N41366382: JXDP1.17 TP120.1(TP-1)
N41366384: JXDP1.27 TP121.1(TP-1)
N41366386: JXDP1.29 TP122.1(TP-1)
N41366395: JXDP1.33 TP123.1(TP-1)
N41366411: JXDP1.35 TP124.1(TP-1)
N41366427: JXDP1.51 TP125.1(TP-1)
N41366429: JXDP1.53 TP126.1(TP-1)
N41366445: JXDP1.57 TP127.1(TP-1)
N41366447: JXDP1.52 TP128.1(TP-1)
N41366449: JXDP1.54 TP129.1(TP-1)
N41366458: JXDP1.56 TP130.1(TP-1)
N41366474: JXDP1.58 TP131.1(TP-1)
N41366476: JXDP1.5 TP132.1(TP-1)
N41366492: JXDP1.3 TP133.1(TP-1)
N42766510: PCH09.1 PUH01.14
N42766662: PCH12.2 PRH09.2
N43968416: PCW35.1 PRW24.1 PUW01.15
N44377954: PCF09.1 PUF01.7
N44377971: PCF01.1 PRF01.2 PUF01.4
N45032542: QV144.3 RV5003.2
N45072311: QV151.3 RV5005.2
N45072322: QV152.3 RV5007.2
N50440735: CT21.1 RT394.2 YT1.1
N57652736: PQ100.6 PR102.1

Pads without a net: EU6 3; FD1 1; FD2 1; FD3 1; FD4 1; JANT2 5; JAPS1 16 17 18; JEDP1 4; JFP1 1; JKB1 2 3; JKBBL1 3; JNGFF1 1 7 9 10 20 22 24 28 29 31 35 37 38 40 42 44 46 48 56 58 63 65 75; JSIM1 6; JSSD1 6 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67 68; JTP1 1 2; PD6 3; PU301 12; PU501 8; PUB01 13; PUV01 14 18; PUW01 10 12; PUZ01 2 40; QC1 1 4; QN7 3; RC238 1; RC241 1; RC243 2; RC245 1; RC246 1; RC247 1; RC249 2; RC250 1; RC253 1; RC256 1; RC370 1; RC387 2; RC388 2; RC531 2; U1 3; U7 1; U16 B3; U6903 3; UC1 A35 AA24 AA26 AA35 AB25 AC24 AC25 AC26 AC35 AD24 AD26 AE34 AE35 AF31 AG6 AG7 AG37 AJ1 AJ2 AJ3 AJ4 AL1 AL2 AL3 AL4 AL34 AM3 AM4 AM7 AN1 AN2 AN3 AN4 AR3 AT3 AU3 AY9 BB9 BB24 BC1 BC2 BC24 BC28 BE1 BE2 BJ34 BJ36 BK34 BK35 BK36 BL34 BL35 BL36 BL37 BP8 BP9 BP28 BP29 BP34 BP35 BR18 BT8 BT9 BT30 BT31 BU34 BV24 BV25 BV28 BV29 BV30 BV34 BW37 BY8 BY9 BY30 BY32 CA1 CA2 CA32 CA34 CA37 CB8 CB9 CB35 CB36 CC3 CC4 CC8 CC29 CC30 CC32 CC35 CC37 CD3 CD4 CE9 CE32 CF20 CF27 CF29 CF31 CG1 CG2 CG8 CG9 CG14 CG20 CH4 CH5 CH6 CH7 CH8 CH9 CH25 CH27 CH28 CH30 CH32 CH34 CJ27 CJ29 CJ30 CJ31 CK17 CM8 CM22 CM28 CN4 CN8 CN20 CN22 CN28 CN36 CP3 CP4 CP6 CP7 CP8 CP10 CP18 CP26 CP28 CR3 CR4 CR16 CR18 CR26 CR28 D34 F34 F37 G1 G2 G3 G4 H3 H4 K12 K14 K15 K17 K18 K20 L5 L25 M24 M26 N5 P24 P26 R24 R25 R26 T25 V24 V25 W3 W25 W31 W37 Y3 Y24 Y25 Y29; UC2 1; UD41 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD42 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD43 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD44 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UE1 B14; UE2 1; UM1 17 18 19 38 43; UM2 1 5 9; UM4 6 7 19 20; UPD1 21 22 23 40 54 55; US2 11; UT1 A7 A9 A11 A13 AB3 AB5 AB23 AC3 AC5 B7 B9 B11 B13 B23 D19 D20 E19 E20 F19 H5 J9 J11 L4 L5 M5 V8; UV1 A3 A7 A16 A22 AA1 AA2 AA3 AA4 AA5 AA6 AA14 AA15 AB1 AB2 AB3 AB4 AB5 AB6 AB8 AB13 AB15 AB16 AB18 AB19 AB21 AB27 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE2 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE22 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF22 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B4 B6 B7 B19 C2 C3 C4 C7 C14 D4 D10 D11 D12 E6 E7 E10 E12 F3 F4 F5 F7 F10 F12 F19 H2 H5 L2 P2 P5 P25 T27 U2 U5 V5 V6 V7 W5 W6 W7 W22 Y3 Y4 Y6; UV6 A5 A10 U5 U10; UV8 A5 A10 U5 U10; WL1 1 2 3 7 8 9 10 14 15 16 18 19 21 22 24 25 30 33 34 36 37 39 40 42 43 44 45 46 47 48 49 50 51 52 53 60 61 64 65 66 67 69 70 A08 A09 A10 A11 A12 A13 A14 A16 A17 A18 A27 A28 A29 A30 A45 A46 A47; XE1 1

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 461 vias
v2: diameter 0.254, hole 0.102, TOP to IN1, 2096 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 146 vias
v4: diameter 0.406, hole 0.203, IN1 to IN3, 2576 vias
v5: diameter 0.254, hole 0.102, IN3 to BOTTOM, 3479 vias
v6: diameter 0.457, hole 0.203, TOP to BOTTOM, 2596 vias
v7: diameter 0.508, hole 0.254, TOP to BOTTOM, 51 vias
v8: diameter 0.254, hole 0.102, TOP to GND1, 2569 vias
v9: diameter 0.254, hole 0.102, GND1 to IN1, 261 vias
v10: diameter 0.254, hole 0.102, IN3 to GND4, 5 vias
v11: diameter 0.254, hole 0.102, GND4 to BOTTOM, 2662 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 41.4
  IN2 w0.066: v6(184.24,50.64) 184.24,48.25 186.02,46.47 194.36,46.47 197.83,49.93 197.83,59.02 195.4,61.45 192.51,61.45 191.74,62.22 v6(191.74,62.97)
  BOTTOM w0.081: PRM17.1 190.11,63.64 191.17,63.64 191.65,63.17 191.65,63.06 v6(191.74,62.97) ; UC2.4 183.01,49.97 182.71,49.67 RC523.2 RC19.2 183.2,49.47 184.24,50.51 v6(184.24,50.64)
1.0V_VCCST_EN: length 4.8
  BOTTOM w0.081: v1(140.36,31.57) 140.36,31.35 140.61,31.09 DZ5.2
  BOTTOM w0.089: UZ1.5 142.68,29.88 142.47,29.68 142.24,29.68 CZ3.1 RZ1418.2 142.21,30.53 142.07,30.67 140.69,30.67 DZ5.2
1.0VS_DGPU_EN: length 32.5
  TOP w0.081: 113.8,42.49 113.44,42.14 v6(113.44,41.88) 113.74,41.58 v1(114.03,41.58) ; QV145.2 94.62,33.9 95.2,34.48 96.46,34.48 v2(96.61,34.63)
  IN1 w0.064: v6(113.44,41.88) 112.65,41.88 110.72,43.81 105.36,43.81 105.36,43.81 105.23,43.81 98.97,37.55 98.97,37.35 96.61,34.99 v2(96.61,34.63)
  BOTTOM w0.081: v6(113.44,41.88) 113.89,41.88 114.17,41.6 PRF03.1 114.59,41.35 114.84,41.1 116.66,41.1 116.73,41.04 118.8,41.04 119.24,41.48 PRF02.2
1.0VS_DGPU_EN#: length 0.8
  TOP w0.081: v3(92.74,35.46) 93.5,35.46
1.0VS_DGPU_EN_U: length 3
  TOP w0.081: UV10.1 113.55,44.58 114.44,44.58 CV196.2 114.64,44.77 114.82,44.59 114.82,44.49 RV103.2 115.42,44.72 DV5.2
1.2V_VDDQ_EN: length 51.1
  TOP w0.081: v6(191.7,28.82) 191.6,28.82 190.66,27.88 v1(189.06,27.88) DZ7.2 186.9,27.52 CZ225.1 186.29,26.92 RZ9.2
  IN1 w0.064: v4(195.99,35.71) 196.05,35.78 196.49,35.78 196.74,36.03 198.59,36.03 199.54,36.98 199.54,41.05 199.22,41.37 199.22,41.87 198.75,42.35 198.75,43.97 197.15,45.57 197.15,46.8 v4(196.37,47.59)
  IN3 w0.064: v4(195.99,35.71) 195.99,35.46 195.21,34.69 195.21,31.76 192.43,28.98 191.86,28.98 v6(191.7,28.82) ; v5(191.86,63.46) 191.89,63.46 192.2,63.15 192.2,62.86 194.23,60.84 194.23,60.84 195.92,59.15 195.92,57.82 197.7,56.04 197.7,54.96 197.27,54.53 197.27,48.49 v4(196.37,47.59)
  BOTTOM w0.081: v5(191.86,63.46) 191.9,63.5 PRM22.1
1.2V_VTT_PWRGD: length 231.1
  TOP w0.081: v2(104.13,21.01) v1(105.72,19.43) 107.98,17.17 v2(107.98,13.04) ; v6(64.53,19.01) 64.42,18.9 RE509.2
  IN1 w0.064: v2(104.13,21.01) 103.53,20.41 97.99,20.41 96.41,18.83 92.63,18.83 90.91,17.11 89.81,17.11 89.32,16.63 69.66,16.63 69.01,17.27 67.63,17.27 65.89,19.01 v6(64.53,19.01) ; v2(107.98,13.04) 108.48,13.55 115.67,13.55 116.26,14.14 117.05,14.14 119.92,17.02 123.2,17.02 125.02,18.83 139.03,18.83 139.28,19.08 139.93,19.08 140.02,18.98 143.61,18.98 144.17,19.53 147.29,19.53 147.84,18.98 147.84,18.1 147.73,17.98 147.73,17.17 148.38,16.52 149.58,16.52 150.63,15.47 150.63,15.35 153.53,12.45 159.84,12.45 164.01,8.28 170.83,8.28 171.41,7.7 180.43,7.7 181.54,8.82 189.1,8.82 189.87,8.05 189.87,7.73 189.87,7.23 190.02,7.08 197.05,7.08 197.67,7.69 197.99,7.69 198.66,7.02 204.73,7.02 v4(205.02,7.3)
  IN3 w0.064: v4(205.02,7.3) 208.83,7.3 209.89,8.37 209.89,19.97 207.92,21.93 207.92,22.32 206.65,23.59 206.65,28.48 205.45,29.68 205.45,35.84 205.83,36.22 205.83,38.83 206.53,39.52 206.53,40.54 206.21,40.86 206.21,41.49 205.61,42.09 205.61,44.15 204,45.76 202.45,45.76 200.55,47.67 200.55,50.5 202.31,52.26 202.31,55.83 202.07,56.06 202.07,57.46 201.45,58.08 201.45,59.84 201.32,59.97 201.32,60.42 201.19,60.54 201.19,60.61 200.75,61.05 200.75,62.07 200.11,62.7 199.71,62.7 199.38,63.03 198.53,63.88 v5(198.53,63.97)
  BOTTOM w0.081: PRM26.1 198.1,63.55 v5(198.53,63.97)
1.05V_PRIM_PG: length 47.1
  TOP w0.081: v2(130.9,19.23) 131.41,19.74 v1(131.41,19.97) 131.41,26.97 132.51,28.07 132.51,32.01 130.39,34.13 130.39,34.44 130.77,34.83 131.72,34.83 131.98,34.57 131.98,34.32 132.42,33.87 132.8,33.87 132.93,34 132.93,34.52 131.54,35.9 130.07,35.9 129.86,36.12 129.86,40.9 128.32,42.44 128.32,43.91 126.71,45.52 126.71,45.6 126.68,45.64 126.68,47.78 126.72,47.82 v6(126.72,49.18)
  IN1 w0.089: v4(130.52,19.23) v2(130.9,19.23)
  IN2 w0.066: v4(127.61,21.45) 127.64,21.45 127.91,21.17 129.44,21.17 130.52,20.09 v4(130.52,19.23)
  IN3 w0.064: v5(127.06,21.33) 127.44,21.33 127.56,21.45 v4(127.61,21.45)
  BOTTOM w0.081: v6(126.72,49.18) 126.72,49.59 126.99,49.86 RE507.2
  BOTTOM w0.254: PRH07.1 125.72,22.29 126.67,21.33 v5(127.06,21.33)
1.8V_PRIM_PG: length 94.4
  TOP w0.081: v2(75.35,14.3) 75.35,14.83 74.64,15.55 v1(74.64,18.25) 74.64,20 74.48,20.16 74.48,20.69 73.35,21.83 PR1814.2 73.35,22.62 ; PU1801.5 73.11,22.62 73.35,22.62 ; 73.35,22.62 PR1802.1
  IN1 w0.064: v4(110.44,37.36) 110.23,37.15 110.23,33.95 113.15,31.02 113.15,29.67 112.52,29.04 112.52,27.81 112.55,27.79 112.55,27.78 112.64,27.69 112.64,27.69 112.85,27.48 112.85,27.18 112.85,27.18 112.85,26.48 112.33,25.96 111.28,24.91 111.28,22.36 111.06,22.15 107.69,22.15 104.61,19.06 104.61,18.45 103.93,17.77 103.93,17.77 103.78,17.63 98.18,17.63 97.82,17.27 92.95,17.27 90.93,15.24 90.93,14 90.47,13.53 88.96,13.53 88.94,13.55 88.84,13.55 88.84,13.56 88.6,13.8 87.67,13.8 87.43,13.56 87.43,13.55 86.97,13.55 86.95,13.57 85.25,13.57 85.24,13.55 84.09,13.55 83.96,13.68 75.82,13.68 75.35,14.16 v2(75.35,14.3)
  IN3 w0.064: v4(110.44,37.36) 110.5,37.3 111.33,37.3 112.48,38.45 112.48,39.62 112.62,39.77 112.62,40.61 113.02,41 113.02,42.14 113.16,42.28 113.61,42.28 115.17,43.84 115.17,44.06 116.1,44.99 116.34,44.99 116.68,45.33 116.68,45.78 118.19,47.28 118.86,47.28 119.81,46.34 122.1,46.34 122.91,47.14 124.17,47.14 124.44,47.42 v5(126.48,47.42)
  BOTTOM w0.081: RE165.2 127.06,48.75 126.48,48.16 v5(126.48,47.42)
1.35V_PWR_EN: length 107.7
  TOP w0.081: v2(79.89,29.51) 79.17,29.51 78.77,29.92 78.77,31.26 78.83,31.33 81.18,31.33 81.58,31.73 81.58,32.26 80.94,32.9 QV152.2 80.54,32.9 79.85,33.59 79.85,33.67 79.68,33.84 79.59,33.84 78.78,34.66 78.78,35.82 74.76,39.84 74.76,40.61 v2(74.84,40.69) ; v2(93.07,28.22) 93.07,29.3 93.42,29.66 101.49,29.66 101.9,30.06 101.9,32.32 101.63,32.59 101.63,36.66 v1(103.87,38.9) 105.84,40.87 108.59,40.87 110.39,39.07 110.5,39.07 111,38.57 121,38.57 UV23.4 ; PRW19.2 v2(64.83,59.7)
  IN1 w0.064: v2(64.83,59.7) 65.11,59.98 67.09,59.98 67.27,59.81 72.27,59.81 73.95,58.13 74.46,58.13 75.4,57.19 75.4,56.37 76.69,55.08 78.26,55.08 78.38,54.95 80.05,54.95 81.81,53.19 81.81,48.99 81.43,48.6 81.43,47.07 76.62,42.25 75.54,42.25 74.76,41.47 74.76,40.78 v2(74.84,40.69) ; v2(79.89,29.51) 80.23,29.17 85.62,29.17 86.58,28.22 v2(93.07,28.22)
3V3_1.2V: length 2.5
  BOTTOM w0.254: PRM27.1 192.65,71.79 PCM20.1 192.65,71.49 192.65,70.84 192.54,70.73 PUM01.3
+0.6V_DDR_VTT: length 43.1
  TOP w0.152: v6(198.9,58.07) 198.84,58.13 v3(198.34,58.13)
  IN3 w0.254: v4(189.91,62.08) 189.77,61.95 v5(189.77,61.58)
  BOTTOM w0.254: 152.63,78 152.63,77.76 152.89,77.5 152.89,75.87 152.59,75.57 151.95,75.57 151.66,75.28 RD87.2 RD62.2 151.33,74.15 151.11,73.92 151.11,72.75 151.38,72.47 RD89.2 ; 152.63,78 150.32,78 150.06,77.75 CD106.1 CD105.1 RD42.2 RD48.2 RD44.2 RD50.2 RD46.2 RD72.2 RD70.2 RD82.2 RD86.2 143.61,77.66 143.48,77.79 142.42,77.79 142.24,77.6 RD52.2 RD56.2 RD54.2 RD58.2 RD60.2 v6(140,77.81) ; 152.63,78 153.18,78 153.36,77.82 155.15,77.82 155.35,77.63 RD40.2 RD38.2 RD34.2 RD36.2 RD32.2 ; RD39.2 RD37.2 RD33.2 ; CD101.1 CD100.1 RD88.2 RD75.2 RD77.2 RD29.2 RD63.2 RD67.2 RD65.2 RD78.2 RD79.2 198.56,54.55 198.95,54.94 198.95,56.7 198.7,56.96 RD31.2 RD35.2 RD33.2 ; RD73.2 RD64.2 v5(189.77,61.58) ; RD33.2 v6(198.9,58.07)
  vias: v2(193.26,71.08) v2(193.26,70.7) v2(193.26,70.32) v2(193.26,69.94) v6(166.71,77.56) v6(185.09,77.86)
+0.6VSP: length 5.7
  TOP w0.127: v3(192.65,69.08) 193.57,69.08 193.71,69.22 195.1,69.22 195.49,69.61
  IN3 w0.508: v5(195.25,71.49) 194.16,71.49 v5(193.54,70.86)
  BOTTOM w0.254: PUM01.5 v5(193.54,70.86)
  vias: v6(196.24,70.8) v6(196.78,70.94)
+0.9V_TBT_LC: length 0.8
  IN1 w0.254: v4(27.97,57.28) 27.85,57.4 v2(27.85,57.59)
  IN3 w0.254: v4(27.97,57.28) v5(28.29,57.6)
+0.9V_TBT_LVR_OUT: length 0.7
  IN3 w0.064: v4(28.53,58.49) v5(28.29,58.25) ; v5(28.94,58.25) 29.17,58.02 29.23,57.96 v4(29.23,57.96)
  vias: v2(29.38,57.11) v2(29.66,57.4) v2(29.6,56.95) v2(30.08,57.08)
+0.9V_TBT_PCIE: length 1
  TOP w0.081: 21.67,55.88 21.04,55.88 v1(20.8,56.12)
  vias: v2(21.72,56.71) v2(22.49,57.02) v2(22.48,55.78) v2(23.06,57.03) v2(23.06,55.78) v4(22.86,56.71) v4(22.86,56.06) v4(23.5,57.35) v4(23.51,56.71) v4(23.51,56.06) v4(24.15,56.54) v5(23.09,56.95) v5(23.09,56.3) v5(23.74,57.6) v5(23.74,56.95) v5(23.74,56.3) v5(24.39,56.3)
+0.9V_TBT_SVR:
  vias: v2(24.45,54.37) v2(25.03,54.37) v2(25.39,56.9) v2(25.48,57.57) v2(25.43,56.23) v2(25.47,55.57) v2(25.6,54.39) v2(26.25,54.41) v2(26.68,57.58) v2(26.64,56.91) v2(26.69,56.24) v2(26.69,55.58) v2(26.9,54.41) v2(27.56,54.41) v2(28.73,65.15) v2(28.73,64.8) v2(28.74,64.44) v2(29.06,65.15) v2(29.06,64.8) v2(29.07,64.43) v2(29.44,65.15) v2(29.44,64.8) v3(30.56,63.57) v4(24.16,54.76) v4(24.69,54.68) v4(24.75,58.51) v4(25.44,58.5) v4(25.4,57.9) v4(25.41,57.23) v4(25.42,56.57) v4(25.44,55.9) v4(25.46,55.23) v4(25.94,54.59) v4(26.07,58.05) v4(26.58,54.59) v4(26.71,63.48) v4(26.75,58) v4(26.71,57.23) v4(26.72,56.57) v4(26.73,55.91) v4(26.75,55.24) v4(27.19,63.48) v4(27.23,54.59) v4(27.36,58.06) v4(27.66,63.49) v4(28.05,56.06) v4(28.12,63.5) v4(28.53,55.89) v5(24.39,58.25) v5(24.39,55) v5(24.39,54.35) v5(25.04,58.25) v5(25.04,54.35) v5(25.69,58.25) v5(25.69,57.6) v5(25.69,56.95) v5(25.69,56.3) v5(25.69,55.65) v5(25.69,55) v5(25.69,54.35) v5(26.34,58.25) v5(26.34,54.35) v5(26.99,58.25) v5(26.99,56.95) v5(26.99,56.3) v5(26.99,55.65) v5(26.99,55) v5(26.99,54.35) v5(27.64,58.25) v5(27.64,54.35) v5(28.29,59.55) v5(28.29,56.3) v5(28.29,55.65) v5(28.29,55) v5(28.29,54.35) v5(28.94,55.65)
+1.0VGAP: length 2.1
  BOTTOM w0.081: v1(110.4,45.98) 110.73,45.65 110.73,44.03
+1.0VS_DGPU: length 26.5
  TOP w0.254: v2(99.72,31.46) 99.52,31.66 94.19,31.66 93.74,32.1 RV2006.1 ; v2(101.59,32.21) 101.33,32.46 101.33,38.75 v3(105.82,43.23) v6(109.23,46.64)
  IN1 w0.254: v2(101.59,32.21) 100.84,31.46 v2(99.72,31.46)
  vias: v6(109.68,47.05)
+1.0VS_DGPU_PGOOD: length 14
  TOP w0.254: v2(116.52,39.66) 116.6,39.74 117.18,39.74 119.11,41.66 119.74,41.66 UV23.1
  IN1 w0.254: v4(115.4,39.59) 115.68,39.59 115.76,39.66 v2(116.52,39.66)
  IN2 w0.254: v4(115.4,39.59) 115.42,39.59 118,42.17 v4(118,43.77)
  IN3 w0.254: v4(118,43.77) 118.24,43.77 v5(118.38,43.91)
  BOTTOM w0.254: PRF04.2 118.1,44.05 117.76,43.71 PUF01.3
+1.2V_DDR: length 109.1
  TOP w0.203: RZ11.1 149.73,59.67 149.39,59.32 149.39,56.22 148.82,55.65 148.82,55.23 148.3,54.71 146.42,54.71 RC576.1
  IN3 w0.254: v5(179.41,73.84) 180.06,73.19 v5(180.06,73.04) ; v5(158.19,73.84) 158.84,73.19 v5(158.84,73.04) ; v6(158.16,65.34) 158.19,65.37 v5(158.19,65.84) ; v6(172,52.97) 172,52.97 171.95,53.02 171.95,54.27 v5(171.97,54.29)
  BOTTOM w0.203: 185.26,48.6 182.43,48.6 182.22,48.81 CC1.2 CC76.2 181.71,49.29 UC2.5
  BOTTOM w0.254: UC1.AD36 165.76,58.26 165.91,58.4 165.91,60.37 CC84.1 ; CC41.1 165.88,60.4 CC84.1 ; v6(179.74,69.49) 180.06,69.18 UD41.H8 ; UD44.P4 162.74,72.3 v6(163.09,72.65) ; UD42.M2 194.88,52.41 v6(195.56,52.41) ; UD43.E12 v6(141.67,65.23) ; UD43.L5 145.89,71.12 v6(145.89,71.05) ; 151.07,58.91 150.81,58.66 150.81,58.05 UC1.BH36 ; UD43.L2 145.59,73.86 v6(145.59,74.37) ; UD44.P5 162.74,71.38 v6(163.06,71.07) ; v6(184.26,71.07) 183.96,70.76 UD41.P6 ; v6(156.12,55.8) 156.12,55.4 UC1.AW32 ; v6(177.09,72.63) 177.46,72.27 UD41.D4 ; v6(156.56,69.44) 156.89,69.11 UD44.E8 ; UD43.P5 147.52,71.34 v6(147.82,71.05) ; v6(179.75,70.2) 180.06,70.51 UD41.H6 ; v6(144.64,70.2) 144.27,70.57 UD43.J6 ; UD41.D5 177.46,71.36 v6(177.14,71.05) ; v6(159.81,68.66) 159.49,68.34 UD44.J9 ; UD43.K6 145.25,70.31 v6(145.25,70.19) ; v6(147.79,70.24) 147.52,70.51 UD43.P6 ; v6(181.64,69.46) 181.64,69.32 UD41.K8 ; UD41.L5 182.01,71.49 v6(182.34,71.82) ; v6(184.24,71.83) 183.96,71.54 UD41.P5 ; UD42.P5 192.48,51.17 v6(192.82,50.83) ; UD43.M2 146.28,73.9 v6(146.28,74.35) ; v6(158.5,69.48) 158.52,69.48 158.84,69.16 UD44.H8 ; v6(163.11,70.18) 162.74,70.54 UD44.P6 ; UD44.J6 159.49,70.37 v6(159.73,70.13) ; v6(179.05,71.04) 179.41,71.4 UD41.G5 ; UD44.G5 158.19,71.41 v6(157.83,71.05) ; UD43.E8 141.67,69.24 v6(141.4,69.51) ; UD41.J9 180.71,68.29 v6(180.35,68.65) 180.06,68.35 UD41.H9 ; UC1.R32 171.97,54.88 v5(171.97,54.29) ; UD43.H3 143.62,72.95 v6(143.91,72.66) ; v6(152.81,55.61) 152.68,55.61 UC1.BE32 ; UC1.AH36 163.24,60.56 CC83.1 ; v6(192.79,57.98) 192.47,57.67 UD42.D5 ; UD42.L2 195.35,53.12 v6(195.45,53.22) ; v6(147.79,71.84) 147.52,72.11 UD43.P4 ; UD43.D4 141.02,72.14 v6(140.72,71.83) ; v6(190.52,51.41) 190.11,51.82 UD42.N8 ; v6(161.1,71.05) 161.1,71.13 UD44.L5 ; 155.69,58.46 UC1.AY36 ; v6(159.15,68.65) 158.84,68.34 UD44.H9 ; UD43.C12 v6(140.37,65.32) ; UD43.K12 145.11,65.65 v6(145.11,65.36) ; UD44.D5 156.24,71.36 v6(155.92,71.05) ; UD44.L2 160.79,73.98 v6(161.06,74.25) ; UD43.H5 143.62,71.35 v6(143.31,71.04) ; UD44.D6 156.24,70.56 v6(155.84,70.16) ; v6(184.25,72.64) 183.96,72.34 UD41.P4 ; v6(143.37,69.53) 143.62,69.28 UD43.H8 UD43.H9 ; v6(186.33,69.49) 185.91,69.07 UD41.U8 ; v6(155.9,71.86) 156.24,72.2 UD44.D4 ; UD44.J5 159.49,71.4 v6(159.83,71.06) ; v6(139.07,69.78) UD43.A8 ; v6(140.65,70.14) 141.02,70.51 UD43.D6 ; UD42.D6 191.7,57.67 v6(192,57.97) ; UD44.N8 162.09,69.09 v6(162.45,69.44) ; v6(181.66,71.83) 181.36,71.52 UD41.K5 UD41.K6 ; UD41.J10 180.71,67.3 180.96,67.05 v6(181.01,67.05) ; UD42.P6 191.69,51.17 192.03,50.83 v6(192.03,50.82) ; v6(158.5,71.05) 158.84,71.39 UD44.H5 ; RD28.1 187.01,76.42 v6(186.68,76.08) ; UD42.D4 193.26,57.67 v6(193.63,58.04) ; v6(147.24,69.51) 146.87,69.14 UD43.N8 ; CD55.1 181.98,76.08 182.35,75.72 182.35,74.27 v6(182.37,74.25) 182.66,73.96 UD41.M2 182.57,73.75 182.09,73.75 UD41.L2 ; UD44.K5 160.14,71.39 v6(160.46,71.06) ; UD41.H5 180.06,71.35 v6(179.73,71.02) ; CD70.1 161.39,76.29 161.14,76.04 161.14,74.33 v6(161.06,74.25) ; v6(143.3,70.21) 143.62,70.53 UD43.H6 ; UD44.K6 160.14,70.53 v6(160.46,70.21) ; v6(163.76,55.56) 163.53,55.32 UC1.AH32 ; v6(161.06,74.25) 161.44,73.87 UD44.M2 ; v6(145.24,71.05) 145.24,71.1 144.92,71.41 UD43.K5 ; UD41.J5 180.71,71.1 180.69,71.09 180.69,70.82 180.71,70.81 UD41.J6 180.71,70.51 v6(181.02,70.19) ; UD43.G5 142.97,71.39 v6(142.63,71.04) ; v6(144.61,71.04) 144.27,71.38 UD43.J5 ; v6(183.68,69.54) 183.31,69.17 UD41.N8 ; v6(177.15,70.23) 177.46,70.54 UD41.D6 ; v6(160.12,55.76) UC1.AN32 ; CC84.1 166.04,60.52 CC45.1 CC46.1 168.02,60.52 168.28,60.26 UC1.Y36 ; UD44.K8 160.14,69.1 v6(160.51,69.46) ; UD43.G2 142.97,74.02 v6(142.66,74.33) 142.32,73.99 UD43.F2 ; UD42.E8 190.12,57.02 v6(190.41,57.31) ; v6(158.5,70.21) 158.84,70.55 UD44.H6 ; CC34.1 160.85,58.41 160.73,58.29 UC1.AM36 ; UD44.J10 159.49,67.33 v6(159.78,67.04) ; v6(177.76,69.53) 178.11,69.19 UD41.E8 ; UD43.K8 144.92,69.12 v6(145.27,69.46) ; UD42.P4 193.27,51.17 v6(193.62,50.82) ; 152.26,61.48 151.88,61.48 151.66,61.7 CC44.1 ; UD43.D5 141.02,71.34 v6(140.72,71.04) ; v6(144.6,68.66) 144.27,68.33 UD43.J9 ; UD43.G12 142.59,65.46 v6(142.59,65.15)
  BOTTOM w0.381: RD10.1 183.29,62.97 184.21,63.9 184.21,64.99
  BOTTOM w0.508: CC41.1 164.9,60.4 164.54,60.76 164.54,63.41 ; 151.07,58.91 151.82,58.91 CC39.1 ; 155.69,58.46 155.69,58.67 155.37,58.99 CC35.1 155.33,60.42 ; 163.25,63.38 CC83.1
  vias: v3(170.27,53.94) v6(138.58,68.03) v6(144.62,67.02) v6(145.24,66.23) v6(148.49,65.41) v6(149.8,66.26) v6(149.85,69.51) v6(149.85,68.54) v6(153.69,69.15) v6(153.69,68.11) v6(155.55,65.21) v6(157.87,74.26) v6(163.1,66.24) v6(164.98,68.63) v6(165,66.27) v6(174.96,66.3) v6(175.01,67.97) v6(175.21,69.5) v6(176.77,65.32) v6(178.04,65.34) v6(179.1,73.42) v6(179.3,65.24) v6(180.17,65.04) v6(181.69,66.2) v6(181.62,65.35) v6(182.33,65.4) v6(183.62,65.37) v6(185.85,51.54) v6(185.93,52.7) v6(186.07,58.43) v6(186.3,68.67) v6(186.25,66.31) v6(186.29,53.5) v6(186.41,50.27) v6(187.25,59.99) v6(187.22,53.46) v6(187.25,48.84) v6(189.28,48.71) v6(189.74,60.12) v6(192.02,55.36) v6(192.02,54.09) v6(192.03,53.44) v6(195.32,55.67) v6(196.95,56.11)
+1.2V_DDRP: length 30.6
  IN2 w0.254: v4(194.53,70) 195.29,70.77 195.48,70.77 196.68,71.97 198.59,71.97 198.84,71.72 198.84,67.53 199.48,66.89 199.48,66.26 198.41,65.19 v6(198.41,65.18)
  IN3 w0.254: v6(198.41,65.18) 199.57,66.33 199.57,66.6 198.91,69.03 198.91,71.64 198.62,71.94 196.57,71.94 195.45,70.81 194.61,70.81 194.04,70.24 v5(194.04,70.17) 194.21,70 v4(194.53,70)
  BOTTOM w0.508: v6(195.73,60.43) 195.73,62.42 194.99,63.17 PCM32.1 PRM25.1
  vias: v3(199.48,61.56)
+1.2V_DTH: length 1.9
  TOP w0.081: v3(24.95,34.92) 24.95,35.38 v6(25.3,35.73)
  TOP w0.508: v6(25.3,35.73) 25.77,35.73 RM1.1
+1.2V_DTH_OUT: length 0.5
  TOP w0.081: 28.28,37.3 v1(28.28,37.81)
+1.05V_MPHYPLL: length 3.3
  TOP w0.127: v1(139.98,35.82) 141.1,36.94 LC3.2
  IN1 w0.254: v4(144.39,35.75) 144.63,35.99 v2(144.63,36.64)
  IN3 w0.254: v4(144.39,35.75) 144.64,36.01 v5(144.75,36.01)
+1.05V_PRIM: length 143.6
  TOP w0.254: RE538.2 44.78,32.45 44.78,32.91 v2(45.01,33.14) ; v6(144.22,46.52) 143.85,46.16 CC55.1 ; v6(130.98,34.37) 130.96,34.36 130.96,34 132.81,32.15 132.81,27.78 131.72,26.7 131.72,20.22 132.35,19.59 133.83,19.59 135.47,17.95 135.47,15.75 136.75,14.47 RC251.1
  IN1 w0.254: v2(45.01,33.14) 45.17,33.3 45.17,34.29 45.97,35.1 47.55,35.1 49.02,33.62 53.99,33.62 56.32,31.29 v4(65.77,31.29)
  IN2 w0.254: v4(65.77,31.29) 66.26,30.81 66.26,30.68 66.29,30.64 66.29,23.17 73.18,16.29 80.27,16.29 81.12,17.13 110.97,17.13 111.51,17.67 113.56,17.67 113.61,17.62 113.63,17.62 114.66,16.58 115.39,16.58 116.22,17.41 118.97,17.41 121.12,19.56 121.12,20.83 121.69,21.41 121.69,22.05 122.85,23.2 122.85,30.09 126.71,33.95 130.56,33.95 v6(130.98,34.37)
  BOTTOM w0.089: 146.11,45.02 146.19,45.1 146.19,45.4 146.11,45.48
  BOTTOM w0.102: 146.93,48.02 v5(147.16,47.79) 146.94,47.56 ; 146.94,43.81 v5(147.16,43.59) 146.93,43.35 ; 146.93,48.39 v5(147.17,48.63)
  BOTTOM w0.203: UZ1.7 143.13,30.68 v6(142.75,31.07) ; v5(143.91,45.27) v5(143.26,45.27)
  BOTTOM w0.254: v6(142.75,31.07) 142.73,31.07 v6(142.34,31.45)
  vias: v2(146.06,45.47) v2(146.26,45.15) v3(116.29,28.54) v4(129.17,35.4) v4(129.68,35.54) v4(139.15,30.05) v4(139.5,29.73) v4(142.2,43.13) v4(142.27,47.59) v4(142.26,46.77) v4(142.75,47.36) v4(143.56,47.35) v4(143.6,46.57) v4(144.06,47.41) v4(145.43,47.32) v4(145.57,46.5) v4(145.65,45.72) v4(146.16,46.63) v4(146.22,47.33) v4(146.22,45.81) v4(146.63,46.33) v4(146.83,47.44) v4(146.93,48.22) v5(141.67,42.46) v5(141.96,44.43) v5(141.96,43.59) v5(141.96,42.75) v5(142.61,47.79) v5(142.61,46.95) v5(142.61,46.11) v5(142.61,45.27) v5(142.61,43.59) v5(142.61,42.75) v5(143.15,43.17) v5(143.26,47.79) v5(143.26,43.59) v5(143.26,42.75) v5(143.91,47.79) v5(143.91,46.95) v5(143.91,46.11) v5(143.91,43.59) v5(143.91,42.75) v5(144.56,47.79) v5(144.56,46.11) v5(144.56,45.27) v5(144.56,44.43) v5(144.56,43.59) v5(144.56,42.75) v5(144.68,46.57) v5(144.71,48.28) v5(144.72,43.15) v5(144.87,45.84) v5(145.1,48.28) v5(145.05,42.37) v5(145.21,48.63) v5(145.21,46.95) v5(145.21,46.11) v5(145.21,44.43) v5(145.21,43.59) v5(145.21,42.75) v5(145.86,48.63) v5(145.86,46.95) v5(145.86,46.11) v5(145.86,42.75) v5(146.51,47.79) v5(146.51,44.43) v5(146.51,43.59) v5(146.51,42.75) v6(115.74,27.18) v6(115.74,26.6) v6(115.74,26.04) v6(115.74,25.45) v6(116.38,27.82) v6(116.38,27.23) v6(116.38,26.67) v6(116.38,26.09) v6(116.36,25.49) v6(131.56,34.37) v6(133.31,29.65) v6(133.31,29.07) v6(133.88,29.65) v6(133.88,29.07) v6(134.47,29.65) v6(134.47,29.07) v6(135.05,29.65) v6(135.05,29.07) v6(135.64,29.65) v6(135.64,29.07) v6(137.95,29.94) v6(137.95,29.36) v6(138.14,28.82) v6(138.52,29.87) v6(138.71,29.3) v6(142.72,27.74) v6(142.87,46.53) v6(142.93,48.21) v6(143.31,27.74) v6(143.6,48.22) v6(143.62,43.15) v6(144.23,48.2) v6(144.25,43.16) v6(146.79,44.83)
+1.05V_PRIMP: length 22.5
  TOP w0.081: v6(125.42,16.6) v1(125.42,17.08)
  IN2 w0.254: v6(138.77,25.55) 138.93,25.4 138.93,20.12 138.43,19.62 132.82,19.62 131.62,18.42 127.59,18.42 125.77,16.6 v6(125.42,16.6)
  BOTTOM w0.508: PCH12.1 124.66,17.28 PRH05.1 v6(125.42,16.6)
  vias: v6(138.14,25.55)
+1.05V_VCCDSW: length 3.5
  TOP w0.254: v2(145.23,49.9) 145.02,49.9 144.53,49.41 144.53,49.26 143.95,48.68 v1(143.84,48.68)
  IN1 w0.254: v4(144.87,49.97) 145.15,49.97 v2(145.23,49.9)
  IN3 w0.254: v4(144.87,49.97) 145.07,49.97 145.4,50.3 v5(145.86,50.3)
+1.05V_XDP: length 8.7
  TOP w0.081: v1(135.93,14.65) 135.93,13.16 136.19,12.9 RC251.2
  TOP w0.254: JXDP1.43 136.33,8.62 136.63,8.92 JXDP1.44 136.63,10.59 136.75,10.72 RC538.1 CC107.1 CC108.1 136.75,12.53 136.75,12.53 RC251.2
+1.05V_XTAL: length 1.3
  BOTTOM w0.127: CC57.1 v1(128.69,36.34)
+1.8V_PRIM: length 232.2
  TOP w0.254: v2(36.42,39.21) 36.8,39.58 36.8,41.81 36.38,42.23 R26.1
  TOP w0.508: 136.8,34.57 136.11,35.27 135.22,35.27 133.86,36.63 133.86,39.34 135.22,40.7 135.22,45.79 ; v6(54.15,20.87) 53.85,20.87 RE7.1 ; v2(152.01,28.27) 150.77,27.03 150.77,24.42 149.89,23.54 149.89,21.49 ; 149.89,21.49 141.02,21.49 140.65,21.87 140.65,30.12 v2(140,30.77) ; 149.89,21.49 151.18,21.49 154.91,17.76 159.51,17.76 v3(161.73,15.53) 162.22,15.05 162.22,11.26 162.27,11.2 162.27,10.5 162.65,10.12 162.65,5.36 162.65,5.3 163.23,4.72 169.63,4.72 169.76,4.85 169.76,4.85 169.95,5.04 170.71,5.04 170.98,4.77 191.46,4.77 192.62,5.93 192.62,7.01 193.45,7.84 193.45,8.32 193.87,8.75 194.8,8.75
  IN1 w0.254: v2(141.16,47.28) 141.05,47.39 v4(140.6,47.39) 140.6,47.64 140.72,47.75 v2(140.72,47.93) ; v2(36.42,39.21) 36.36,39.21 34.67,37.51 34.36,37.51 34.11,37.26 34.11,36.64 33.93,36.47 v2(33.93,36.24) ; v2(49.89,45.6) 50.02,45.73 50.08,45.73 v4(50.17,45.83)
  IN1 w0.508: v2(152.01,28.27) 153.86,28.27 154.6,29.01 161.67,29.01 v6(162.07,28.61) ; 137.53,33.34 137.53,33.18 139.18,31.53 139.18,31.52 139.54,31.17 139.55,31.17 139.95,30.77 v2(140,30.77) ; v4(39.3,56.89) 39.2,56.99 39.2,58.34 38.7,58.84 38.7,60.72 37.49,61.93 37.49,62.17 v2(36.5,63.16)
  IN2 w0.508: v4(39.3,56.89) 39.14,56.73 39.04,56.73 38.53,56.22 38.53,50.39 40.63,48.3 41.2,48.3 42.75,46.75 43.95,46.75 45.35,45.36 v4(46.14,45.36) ; v4(130.42,72.3) 125,72.3 122.97,70.28 122.97,69.01 121.95,67.99 121.95,65.4 120.61,64.06 119.75,64.06 119.24,63.55 119.24,62.4 118.33,61.48 118.33,60.87 113.61,56.15 113.61,55.65 106.87,48.91 v4(106.87,46.06) ; v6(49.82,36.29) 49.1,35.57 42.44,35.57 41.64,34.77 41.64,33.76 40.84,32.95 40.84,31.8 39.68,30.64 39.68,29.49 41.12,28.05 43.14,28.05 44.46,29.37 46.46,29.37 46.75,29.66 49.47,29.66 51.85,27.28 52.77,27.28 53.48,26.58 53.48,26.18 53.92,25.73 53.92,24.77 53.13,23.98 53.13,21.85 54.11,20.87 v6(54.15,20.87)
  IN3 w0.508: v6(134.51,72.2) 134.45,72.14 130.58,72.14 v4(130.42,72.3)
  BOTTOM w0.254: UC1.CP23 134.77,49.33 v6(134.45,49.33) ; PRZ15.1 162.29,27.92 162.46,28.09 PRZ54.1 162.67,28.32 162.38,28.61 v6(162.07,28.61)
  vias: v2(33.26,36.26) v2(33.56,36.49) v2(120.29,52.16) v2(120.74,51.69) v2(134.77,46.25) v2(134.92,46.5) v2(135.31,46.42) v2(137.25,33.94) v2(137.63,33.94) v4(32.77,35.29) v4(33.24,35.39) v4(100.36,37.05) v4(100.74,37.43) v4(120.32,51.77) v4(135.14,46.07) v4(135.61,46.15) v5(135.05,45.74) v5(140.38,46.62) v5(140.66,46.95) v5(140.72,46.59) v6(75.1,35.51) v6(75.73,35.57) v6(76.34,35.41) v6(76.58,34.85) v6(106.95,45.4) v6(109.66,44.62) v6(110.2,44.88) v6(114.76,40.49) v6(115.37,40.48) v6(126.33,44.21) v6(126.89,44.08) v6(130.04,46.01) v6(130.61,46.02)
+1.8V_PRIM_UV2: length 4.1
  IN2 w0.508: v6(120.38,50.02) 120.37,50 117.06,50 v6(116.86,50.21)
  BOTTOM w0.081: v6(116.86,50.21) v1(116.51,49.86)
+1.8V_PRIMP: length 24.6
  TOP w0.081: v6(64.78,25.39) 64.22,25.95 v1(64.22,26.89)
  TOP w0.254: v6(66.92,19.07) 67.27,19.42 PC1811.2 67.77,19.65 PR1806.1
  IN1 w0.254: v6(64.78,25.39) 67.29,27.9 74.57,27.9 76.77,25.71 76.77,25.39
  BOTTOM w0.254: v6(64.78,25.39) 66.92,23.25 v6(66.92,19.07)
  vias: v2(76.64,25.01) v2(76.97,25.01)
+1.8VALW_1.0V:
  vias: v1(117.02,45.95)
+1.8VALW_EC: length 7.7
  TOP w0.254: UE1.B19 50.1,21.43 v6(49.4,22.13) ; v6(51.71,19.42) 51.72,19.43 52.16,19.43 CE13.1 52.6,19.87 RE7.2
  IN2 w0.254: v6(49.4,22.13) 50.04,21.49 50.04,19.67 50.3,19.42 v6(51.71,19.42)
+1.8VS: length 79.6
  TOP w0.127: v2(70.02,71.12) 69.5,71.12 v3(69.1,70.73)
  TOP w0.254: v2(72.01,72.56) 71.89,72.68 RS5.1 ; Q28.5 72.97,71.12 73.19,70.91 73.19,70.47 72.94,70.22 71.96,70.22 71.05,71.12 Q28.2 v2(70.02,71.12) ; CS44.1 CS43.1 RS4.1 69.12,76.45 68.86,76.2 68.86,75.24 v2(69.11,74.99) 69.23,74.87 RS6.1 ; 57.23,38.13 QN7.2 ; 57.23,38.13 56.38,38.13 56.07,38.44 RN92.1 ; 57.23,38.13 QN7.5 ; RS7.1 v2(69.79,72.95) ; RN92.1 55.55,38.44 54.61,39.39 54.37,39.39 54,39.75 54,40.6 54.27,40.86 v2(54.38,40.86) ; RN92.1 55.84,37.83 RN3.1
  IN1 w0.254: v4(69.73,71.41) 69.62,71.52 69.62,72.79 v2(69.79,72.95) 69.79,73.77 69.18,74.37 69.18,74.56 69.11,74.63 v2(69.11,74.99) ; v4(69.73,71.41) 69.97,71.66 71.11,71.66 v2(72.01,72.56) ; v4(69.73,71.41) v2(70.02,71.12) ; v2(51.81,44.42) 52.56,44.42 52.98,44.01 52.98,41.32 53.43,40.86 v2(54.38,40.86) 54.57,40.86 55.78,42.07 56.73,42.07 57.49,42.83 57.49,43.87 56.3,45.05 56.3,48.4 55.22,49.48 55.22,50.54 v4(55.87,51.19)
  IN2 w0.254: v4(55.87,51.19) 56,51.31 58.02,51.31 58.7,50.64 60.76,50.64 62.16,52.04 62.16,55.84 64.82,58.51 64.82,59.42 65.14,59.74 67.22,59.74 67.64,60.16 69.05,60.16 72.74,63.85 72.74,70.25 71.58,71.41 v4(69.73,71.41)
+1.8VS_DGPU_AON: length 83.9
  TOP w0.203: RV72.2 120.02,42.44 v2(120.02,42.07) ; RV90.2 116.67,45.92 v2(116.43,45.92) ; v6(106.59,75.03) 106.46,74.83 105.01,74.83 104.78,74.6 104.4,74.6 104.29,74.72 RV51.1 RV384.1 ; RV4998.1 113.94,45.66 v2(113.71,45.44) ; RV80.1 97.64,65.88 97.64,65.9 RV84.1 97.19,65.88 97.19,65.87 97.05,65.73 RV81.1 ; v6(98.92,75.22) 98.79,75.35 RV382.1
  TOP w0.254: v2(120.02,42.07) 120.02,42.01 121.67,40.36 121.67,39.77 122.12,39.32 UV23.5 122.8,38.6 122.83,38.6 CV397.1 123.47,38.45 123.89,38.87 123.89,42.56 123,43.45 123,51.07 123.88,51.94 123.88,52.62 122.8,53.7 122.8,54.87 121.69,55.98 121.69,56.07 121.53,56.23 121.53,56.74 119.99,58.27 119.89,58.27 119.23,58.93 v1(118.71,58.93) v2(118.21,58.93) ; UV10.5 114.57,43.56 113.37,43.56 112.71,42.9 112.35,42.9 111.87,43.38 111.87,44.75 UV26.5 v2(112.71,44.97)
  IN1 w0.254: v2(118.21,58.93) 118.14,58.85 118.14,57.54 v2(118.22,57.46) ; v2(112.71,44.97) 113.37,44.97 113.71,45.31 v2(113.71,45.44) 114.36,46.08 116.27,46.08 v2(116.43,45.92) 116.63,45.72 116.63,45.41 117.79,44.25 118.1,44.25 118.15,44.2 118.21,44.2 120.02,42.4 v2(120.02,42.07)
  IN1 w0.508: 108.95,73.8 108.95,72.64 115.14,66.46 115.27,66.33 115.27,62.33 115.14,62.2 115.14,61.4 116.12,60.42 116.12,59.84
  BOTTOM w0.203: RV205.2 RV206.2 RV208.2 98.52,72.98 97.94,72.98 v6(97.92,73) 97.92,73.5 98.66,74.24 RV69.2 ; RV77.2 v6(112.9,75.61) ; v6(106.59,75.03) 106.59,75.25 106.43,75.41 106.43,75.84 105.86,76.41 104.41,76.41 RV398.1 ; v6(99.95,76.19) 99.96,76.18 100.25,76.18 100.26,76.18 100.55,76.18 100.56,76.18 RV61.1 ; RV68.1 120.15,56.13 120.15,56.58 v6(120.14,56.59) ; v6(98.92,75.22) 98.98,75.22 RV4991.2 RV91.2 ; RV389.1 106.52,74.06 v6(107.89,74.06)
  BOTTOM w0.254: UV1.G10 100.66,64.46 v6(100.31,64.1) ; v6(99.86,63.7) UV1.G12 ; UV12.5 v6(116.5,75.53)
  vias: v2(116.5,59.38) v2(116.62,59.7)
+1.8VS_DGPU_AON_UV26: length 5.8
  TOP w0.081: RV4998.2 114.46,46.2 114.46,46.6 114.19,46.88 QV150.6 113.94,47.16 113.65,47.16 113.16,46.66 112.42,46.66 112.12,46.36 111.71,46.36 111.12,45.77 110.37,45.77 UV26.2
+1.8VS_DGPU_MAIN: length 39.3
  TOP w0.203: v2(116.82,40.95) 116.78,40.99 RV5001.2
  IN1 w0.254: v6(113.58,59.17) 112.24,59.17 108.95,55.88 108.95,49.62 103.49,44.16 103.49,43.09 103.24,42.84 v4(102.98,42.84) ; v2(116.82,40.95) 116.54,41.23 115.39,41.23 115.19,41.03 114.54,41.03 114.19,40.68 v4(114.19,40.68)
  IN3 w0.254: v5(102.99,41.81) 103.06,41.87 103.06,42.76 v4(102.98,42.84) ; v4(114.19,40.68) 114.14,40.68 113.89,40.42 v5(113.89,40.4)
  BOTTOM w0.254: v6(101.66,64.63) UV1.G9 ; UV1.G8 v6(101.87,66.18) ; v5(113.89,40.4) 113.64,40.64 109.12,40.64 108.76,41 103.8,41 v5(102.99,41.81)
  vias: v1(114.25,59.12) v6(114.11,59.72)
+1.8VS_R: length 0.6
  TOP w0.081: v1(51.21,41.34) 51.21,41.52 51.24,41.55 51.24,41.98
+1.8VS_SX9324: length 2.9
  TOP w0.254: RS4.2 69.29,75.69 69.58,75.4 70.95,75.4 71.4,74.96 U16.A2
+1.8VU: length 32.1
  IN3 w0.254: v4(165.02,72.64) 164.69,72.31 v5(164.69,72.24) ; v4(186.23,67.04) 186.23,67.11 v5(185.91,67.44) ; v5(193.23,59.62) 193.23,59.64 v4(193.57,59.98) ; v4(149.8,71.04) 149.8,71.11 v5(149.47,71.44) ; v4(192.15,60.07) 192.08,60.07 v5(191.63,59.62) ; v5(139.05,67.44) 138.97,67.44 v4(138.71,67.17) ; v5(154.29,70.64) 153.97,70.31 v4(153.97,70.28) ; v5(149.47,72.24) 149.8,71.91 v4(149.8,71.84) ; v5(175.51,72.24) 175.34,72.07 v4(174.81,72.07) ; v4(165.02,73.44) 164.69,73.11 v5(164.69,73.04) ; v5(149.47,70.64) 149.8,70.31 v4(149.8,70.24) ; v4(164.94,71.01) 164.94,71.11 164.69,71.35 v5(164.69,71.44) ; v4(153.97,71.84) 154.29,72.16 v5(154.29,72.24) ; v4(153.97,72.64) 154.29,72.96 v5(154.29,73.04) ; v4(138.75,71.84) 138.75,71.91 v5(139.07,72.24) ; v5(193.23,49.22) 193.23,49.02 v4(193.56,48.69) 194.03,49.15 v5(194.03,49.22) ; v4(186.23,73.44) 185.91,73.11 v5(185.91,73.04) ; v4(188.38,48.71) 188.43,48.76 v5(188.43,49.22) ; v5(192.43,49.22) 192.1,48.89 v4(192.03,48.89) 191.95,48.89 v5(191.63,49.22) ; v5(188.43,59.63) 188.35,59.63 v4(188.03,59.95) ; v5(175.51,73.04) v4(175.18,73.36) ; v4(186.23,72.64) 185.91,72.31 v5(185.91,72.24) ; v4(175.17,71.01) 175.17,71.1 v5(175.51,71.44) ; v4(153.86,67.15) 154.16,67.44 v5(154.27,67.44) ; v5(192.43,59.62) 192.46,59.62 v4(192.91,60.07) ; v5(139.07,70.64) 138.75,70.31 v4(138.75,70.24) ; v4(175.26,67.04) 175.26,67.22 v5(175.48,67.44) ; v4(138.75,72.64) 138.75,72.71 v5(139.07,73.04) ; v5(185.91,70.64) 185.91,70.71 v4(186.23,71.04) ; v5(185.91,71.44) 185.92,71.44 v4(186.21,71.73) ; v4(175.18,70.24) 175.18,70.31 v5(175.51,70.64) ; v5(164.69,67.44) 164.94,67.19 v4(164.94,67.04) ; v4(153.97,71.04) 153.97,71.11 v5(154.29,71.44) ; v5(149.47,73.04) 149.47,73.11 v4(149.8,73.44) ; v4(138.75,71.04) 138.75,71.11 v5(139.07,71.44) ; v5(194.03,59.62) v4(194.35,59.94) ; v4(164.97,70.22) 164.97,70.33 164.69,70.61 v5(164.69,70.64) ; v5(149.47,67.44) v4(149.86,67.05)
  BOTTOM w0.254: CD135.1 CD136.1 188.7,47.82 188.43,48.1 v5(188.43,49.22) ; v5(154.27,67.44) 153.68,67.44 153.13,66.89 CD130.1 ; CD127.1 149.48,67.44 v5(149.47,67.44) ; CD140.1 CD134.1 186.83,61.27 188.43,59.67 v5(188.43,59.63)
  vias: v3(137.69,73.43) v6(138.2,73.71) v6(138.22,73.1)
+1.8VU_OUT: length 1.4
  TOP w0.081: RZ28.1 139.49,72.08 140.03,72.61 v1(140.3,72.61)
+1.35VGPUP: length 28.3
  TOP w0.254: 67.42,43.4 67.42,41.87 v1(67.4,41.85) ; v2(62.57,55.91) PRW13.1
  IN1 w0.254: v4(61.63,55.36) 62.18,55.91 v2(62.57,55.91)
  IN3 w0.254: v4(61.63,55.36) 61.96,55.36 65.06,52.26 65.06,50.36 66.26,49.16 66.26,44.31 67.86,42.71 73.42,42.71 74,43.3 74,44.93 v6(74.93,45.86)
  vias: v2(71.4,47.37) v2(71.39,46.58) v2(71.39,46.2) v2(71.42,46.97) v2(71.8,46.61) v2(71.79,46.15) v2(71.85,47.38) v2(71.82,46.99) v2(72.2,47) v2(72.18,46.6) v2(72.23,47.39) v2(72.21,46.18) v2(75.44,45.22) v2(75.67,45.47) v2(76.28,46.09) v2(76.47,53.74) v2(76.48,48.94) v2(76.52,46.33) v2(76.5,45.87) v2(76.7,48.73) v2(76.71,49.18) v2(76.74,46.12) v2(76.87,54.13) v2(76.93,48.97) v2(77.14,46.93) v2(77.37,47.17) v2(77.36,46.71) v2(77.59,46.96) v2(78,47.75) v2(78.23,48) v2(78.22,47.54) v2(78.45,47.78)
+1.35VGS_PGOOD: length 96.2
  TOP w0.081: PUW01.9 67.58,56.95 v2(66.49,58.04) ; v2(75.15,40.02) 75.15,39.87 v2(76.91,38.11) ; v2(110.41,42.32) 111.49,42.32 112.3,41.5 v1(112.59,41.5) 112.88,41.21 115.26,41.21 116.23,40.24 116.64,40.24 117.59,41.19 UV11.2 118.25,41.83 118.69,42.28 118.69,42.93 119.23,43.47 120.67,43.47 120.84,43.64 UV25.1
  IN1 w0.064: v2(76.91,38.11) 79.07,38.11 79.62,37.56 80.06,37.56 83.87,33.75 86.52,33.75 87.36,32.9 89.85,32.9 90.15,33.2 90.86,33.2 90.99,33.33 96.58,33.33 97.8,34.55 97.8,35.1 99.73,37.03 99.73,37.23 104.77,42.28 110.37,42.28 v2(110.41,42.32) ; v2(66.49,58.04) 66.49,58.27 67.84,59.62 72.2,59.62 73.88,57.94 74.38,57.94 75.21,57.11 75.21,56.29 76.61,54.89 78.13,54.89 78.26,54.76 79.97,54.76 81.62,53.11 81.62,49.11 81.24,48.73 81.24,47.14 76.54,42.45 75.46,42.45 75.02,42 74.19,42 73.56,41.37 73.56,40.73 73.84,40.45 74.39,40.45 74.83,40.02 v2(75.15,40.02)
+1.35VS_VRAM: length 79.4
  TOP w0.178: v2(83.08,68.11) 83.09,68.12 83.2,68.2 UV6.R5
  TOP w0.254: v6(87.95,49.07) 87.55,48.67 UV8.P1 ; 81.56,69.07 81.6,69.03 v6(81.6,68.46) ; UV6.F1 85.68,76.27 v6(85.68,76.34) ; v6(93.17,40.14) 93.17,40.71 UV8.B3 ; v6(78.35,42.4) 78.94,42.4 UV8.T14 ; UV6.P3 82.69,70.2 82.69,69.62 v6(82.69,69.62) ; UV6.G11 91.18,69.11 v6(91.18,69.1) 91.18,68.5 UV6.H12 ; UV8.G4 UV8.H3 ; v6(85.54,73.59) UV6.H3 ; UV6.E5 v6(89.27,73.8) ; v6(91.34,65.4) 91.06,65.67 UV6.L14 UV6.L13 ; UV8.G13 UV8.H12 84.61,39.02 v6(84.07,39.02) ; UV6.B12 94.6,71.92 v6(94.6,72.5) ; v6(88.8,37.87) 88.8,37.55 UV8.C10 ; v6(85.27,37.92) UV8.F12 ; v6(92.35,67.9) 92.84,67.9 UV6.G14 ; UV8.C5 91.39,40.15 90.82,40.15 v6(90.79,40.18) ; UV6.C10 v6(92.49,72.85) ; v6(83.84,69.6) 84.36,69.6 UV6.N5 ; v6(88.99,47.98) 88.6,47.59 UV8.M1 UV8.L2 ; UV8.E10 88.06,38.48 v6(88.1,38.53) ; UV6.B14 v6(96.19,70.28) ; v6(87.77,73.55) 87.26,73.55 UV6.G4 ; UV6.K12 v6(90.05,66.77) ; v6(90.17,40.8) 90.17,41.19 UV8.E5 ; v6(85.02,75.59) 85.32,75.29 UV6.G1 ; UV8.M3 87.36,46.51 87.02,46.51 v6(86.92,46.4) ; UV6.F3 86.64,74.72 v6(86.61,74.75) ; UV6.D14 94.57,69.49 v6(94.97,69.09) ; v6(92.02,42.38) 91.99,42.36 UV8.D3 ; UV6.L1 83.26,73.14 v6(82.96,73.44) ; v6(92.37,44.52) 92.37,44.51 UV8.F1 ; UV6.P14 89.31,63.59 v6(89.31,63.59) ; v6(89.67,47.42) 89.22,46.97 UV8.L1 ; UV6.T1 v6(80.06,70.57) ; v6(94.83,42.16) 94.54,42.16 UV8.B1 ; UV6.C5 v6(90.46,74.88) ; UV6.M14 90.05,65.04 v6(90.42,64.66) ; v6(84.28,46.51) 84.64,46.87 UV8.R5 ; UV6.L4 v6(84.96,71.85) UV6.K3 ; v6(81.12,71.62) 81.41,71.33 UV6.P1 ; UV6.F14 93.49,68.5 93.81,68.18 v6(93.81,68.13) ; v6(94.07,43.7) 93.82,43.7 UV8.D1 ; UV6.N10 86.95,66.8 v6(86.75,67) ; UV8.F14 v6(84.26,36.41) ; v6(88.03,36.26) UV8.B12 ; v6(82.18,44.56) 81.81,44.19 UV8.R10 ; UV8.N5 v6(85.31,45.38) ; UV8.G14 84.02,37.35 v6(83.64,36.98) ; UV8.N10 v6(83.47,43.53) ; v6(81.23,38.76) 81.81,39.34 UV8.L14 ; v6(86.13,66.35) 86.13,65.72 UV6.R10 ; 86.65,63.98 v6(86.13,63.98) ; UV6.D12 v6(92.93,70.76) ; UV6.T14 v6(88.16,62.47) ; UV6.G2 v6(85.49,74.72) ; UV8.D14 v6(85.34,35.23) ; UV6.D3 v6(88.35,76.39) ; UV6.E10 v6(91.32,71.76)
  IN1 w0.178: v6(81.6,68.46) 82.24,68.46 82.59,68.11 v2(83.08,68.11)
  BOTTOM w0.178: UV1.L26 93.84,52.9 94.42,52.9 v6(94.83,53.31) 94.88,53.36 94.88,53.85 UV1.L24 ; v6(86.97,56.31) 87.07,56.31 87.25,56.14 88.52,56.14 88.76,55.89 89.19,55.89 89.58,56.28 UV1.E26 ; RV2440.2 87.64,48.78 87.93,49.07 v6(87.95,49.07) ; v6(84.96,71.85) 84.96,72.22 RV2439.2
  BOTTOM w0.203: v6(89.67,47.42) 90.5,47.42 RV2453.2
  BOTTOM w0.254: UV1.K21 v6(96.34,56.59) 96.16,56.78 UV1.J21 95.28,56.91 v6(94.86,56.91) ; v6(86.13,66.35) 86.02,66.24 CV764.1 ; CV617.1 87.5,73.29 v6(87.77,73.55) ; CV717.1 83.31,43.53 v6(83.47,43.53) ; CV715.1 83.53,41.67 v6(83.53,41.9) ; v6(90.17,40.8) 90.69,41.32 CV761.1 ; UV1.L22 97.13,55.05 UV1.M21 UV1.N21 ; CV765.1 91.32,71.63 v6(91.32,71.76) ; v6(84.65,48.67) 84.58,48.6 CV759.1 ; UV1.B26 v6(89,58.01) UV1.C25 ; UV1.F14 97.75,62.14 v6(97.77,62.12) 97.72,62.07 UV1.G15 v6(97.72,60.94) 97.21,60.94 UV1.G16 ; v6(89.37,52.77) 90.36,52.77 90.84,53.25 90.84,53.41 UV1.H26 ; v6(94.83,42.16) 94.38,42.16 CV760.1 ; CV609.1 81.6,67.9 v6(81.6,68.46) ; v6(96.02,59.24) 96.02,59.75 UV1.G18 v6(95.97,60.4) ; UV1.G14 98.34,62.18 v6(98.98,62.18) 98.98,62.68 UV1.G13 ; v6(85.31,45.38) 85.46,45.38 CV712.1 ; CV613.1 88.37,65.35 v6(88.37,65.11) ; CV610.1 88.34,76.37 v6(88.35,76.39) ; v6(86.13,63.98) 86.6,63.5 CV618.1 ; v6(94.97,69.09) 94.64,69.42 CV614.1 ; CV766.1 92.61,72.85 v6(92.49,72.85) ; v6(90.46,74.88) 90.46,75.14 CV616.1 ; v6(93.64,55.65) UV1.H24 ; v6(94.95,58.01) 94.26,58.01 UV1.G21 94.26,58.59 v6(94.23,58.62) UV1.F21
  BOTTOM w0.35: UV1.E23 91.87,58.06 91.87,58.61 v6(91.92,58.66)
  vias: v3(104.27,45.25) v6(78.14,53.15) v6(78.65,52.67) v6(78.71,53.64) v6(79.16,52.21) v6(79.21,53.16) v6(79.62,51.78) v6(79.72,52.7) v6(79.8,53.35) v6(80.1,51.37) v6(80.18,52.27) v6(80.11,42.98) v6(80.35,52.86) v6(80.56,50.94) v6(80.66,51.86) v6(80.81,52.43) v6(81.12,51.43) v6(81.78,42.47) v6(82.32,72.83) v6(83.48,52.11) v6(83.48,39.62) v6(83.82,71.92) v6(85.79,47.57) v6(86.56,50.31) v6(86.92,45.27) v6(87.23,66.27) v6(87.42,36.81) v6(88.58,44.71) v6(88.92,66.81) v6(90.25,43.04) v6(91.76,45.13) v6(92.32,69.09) v6(92.85,71.91) v6(95.52,58.6) v6(97.58,55.56) v6(98.36,61.56) v6(101.78,50.85) v6(101.76,50.27)
+3.3V_TBT: length 1.1
  TOP w0.081: v1(22.63,62.27) 22.98,61.92 RT606.2
+3.3V_TBT_ANA: length 3.4
  IN1 w0.254: v4(24.1,59.26) 24.06,59.3 21.52,59.3 v2(21.27,59.05)
  IN3 w0.254: v5(24.39,59.55) v4(24.1,59.26)
+3.3V_TBT_ANA_PCIE: length 0.4
  IN3 w0.254: v5(24.39,56.95) v4(24.1,57.24)
  vias: v2(23.75,57.77) v2(24.31,57.77)
+3.3V_TBT_ANA_USB2: length 2.9
  IN1 w0.254: v4(23.27,58.69) 23.05,58.92 21.73,58.92 v2(21.29,58.47)
  IN3 w0.254: v4(23.27,58.69) 23.3,58.69 v5(23.74,58.25)
+3.3V_TBT_FLASH_R: length 19.3
  TOP w0.203: v2(31.67,51.78) 31.67,51.78 32.01,51.78 32.42,52.18 RT3.2 RT4.2 ; RT2.2 31.63,52.63 31.65,52.62 31.65,52.55 v2(31.67,52.53) ; UT2.8 40.08,57.45 40.08,56.84 40.55,56.37 40.55,53.97 39.58,52.99 38.86,52.99
  TOP w0.254: 38.29,52.5 v1(36.97,52.5) 35.14,52.5 32.93,50.29 v2(31.67,50.29)
  IN1 w0.254: v2(31.67,50.29) 31.67,50.3 v2(31.67,51.78) v2(31.67,52.53)
+3.3V_TBT_LC: length 23
  TOP w0.254: RT9.2 v1(35.46,51.13) 34.55,51.13 33.01,49.59 v2(29.34,49.59)
  IN1 w0.254: v2(29.34,49.59) 28.79,50.14 24.13,50.14 23.56,50.71 23.56,51.29 23.59,51.32 v2(23.59,51.67) 23.75,51.67 24.07,51.35 24.75,51.35 25.49,52.09 25.49,52.56 v4(25.23,52.82)
  IN3 w0.254: v5(28.71,53.47) 28.61,53.57 25.61,53.57 25.24,53.2 25.24,52.83 v4(25.23,52.82)
  BOTTOM w0.254: v5(28.71,53.47) 28.94,53.7 UT1.V6
+3.3V_TBT_S0: length 0.8
  IN3 w0.064: v4(28.66,59.27) v5(28.94,59.55) ; v5(28.94,56.95) v4(28.64,57.25)
  vias: v2(25.96,59.2) v2(26.84,59.2) v2(27.59,59.21) v2(27.93,59.2) v5(30.94,58.6) v5(30.94,58.14)
+3.3V_TBT_SX: length 31.7
  TOP w0.203: v2(33.26,52.32) 33.09,52.32 32.08,51.31 v1(31.8,51.31) 31.16,51.31 30.32,50.47 29.77,50.47 29.6,50.65 RT592.2 RT502.2 29.14,50.69 28.94,50.48 28.54,50.48 v2(28.28,50.74) 28.28,51.07 RT503.2 ; v2(26.09,53.21) 26.33,52.97 RT372.2
  IN1 w0.254: v4(21.91,59.77) 21.86,59.72 21.23,59.72 20.36,58.85 20.36,57.16 21.44,56.08 21.44,54.55 21.96,54.04 22.93,54.04 23.47,53.5 24.35,53.5 24.6,53.75 25.55,53.75 v2(26.09,53.21) ; v2(28.28,50.74) 28.23,50.69 26.2,50.69 25.94,50.94 25.94,52.31 26.09,52.46 v2(26.09,53.21) ; v2(33.26,52.32) 33.26,52.62 v4(33.3,52.67) ; v2(26.09,53.21) 27.53,53.21 28.64,54.33 v4(28.64,54.7)
  IN3 w0.254: v4(33.3,52.67) 33.62,52.67 v5(33.66,52.63) ; v4(21.91,59.77) 22.38,59.3 23.34,59.3 v5(23.74,58.9) ; v5(28.94,55) v4(28.64,54.7)
  vias: v2(21.73,60.12) v2(22.06,60.12)
+3.3V_WLAN:
  vias: v3(123.72,72.54) v6(122.98,74.38) v6(122.98,73.79) v6(122.98,73.21) v6(123.51,74.08) v6(134.37,78.74) v6(134.37,78.11) v6(134.33,77.43) v6(134.33,76.8)
+3V_DVDD: length 249.4
  TOP w0.254: v2(194.54,10.36) 194.65,10.25 JIO1.6 ; v6(38.04,34.75) v1(38.75,35.46) 38.75,37.31 41.2,39.76 41.2,40.17 42.29,41.26 v6(42.44,41.26)
  IN1 w0.254: v4(120.61,20.23) 120.61,20.58 122.83,22.8 124.05,22.8 128,26.75 129.46,26.75 130.8,28.09 137.52,28.09 138.61,27 144.16,27 144.78,27.62 148.91,27.62 149.5,27.03 149.5,25.36 150.14,24.73 153.41,24.73 154.05,24.08 159.02,24.08 163.12,19.99 163.94,19.99 164.17,20.21 164.17,25.27 164.42,25.52 166.42,25.52 167.35,26.45 167.35,27.14 167.79,27.59 184.72,27.59 187.99,24.33 187.99,22.25 187.79,22.06 187.79,16.7 187.17,16.07 187.17,15.57 187.42,15.31 187.94,15.31 188.82,14.43 188.82,12.02 190.48,10.36 v2(194.54,10.36)
  IN2 w0.254: v6(42.44,41.26) 42.5,41.32 50.53,41.32 51.43,40.41 51.75,40.41 53.41,38.75 58.13,38.75 64.57,32.3 65.43,32.3 66.68,31.06 66.68,23.33 73.34,16.67 80.11,16.67 80.96,17.51 110.79,17.51 111.33,18.05 113.73,18.05 113.95,17.83 118.85,17.83 120.61,19.6 v4(120.61,20.23) ; v4(30.4,61.75) 30.4,60.47 30.89,59.98 30.89,50.21 31.28,49.82 31.28,48.28 36.4,43.16 36.4,38.01 37.13,37.28 37.97,37.28 39,36.24 39,35.71 v6(38.04,34.75)
  IN3 w0.254: v4(29.6,69.41) 29.6,66.29 28.24,64.93 28.24,64.12 28.64,63.73 28.64,62 28.89,61.75 v4(30.4,61.75)
  vias: v2(29.63,70.13) v2(29.63,69.83)
+3V_FFS: length 4.7
  TOP w0.081: v1(23.25,77.56) 23.9,78.21 25.01,78.21
  TOP w0.305: US2.10 26.88,78.3 ; US2.9 27.38,78.22 ; US2.2 v2(27.38,75.01)
  vias: v2(26.36,74.85)
+3V_FPR: length 4.8
  BOTTOM w0.081: v1(97.23,6.42) 97.79,6.98 Q27.2
  BOTTOM w0.508: 95,8.37 97.43,8.37 97.79,8.01 Q27.2
+3V_HDA: length 15.5
  TOP w0.127: v1(145.14,48.39) 145.15,48.38 v2(145.15,47.94)
  IN2 w0.254: v4(149.36,60.19) 149.36,55.82 148.72,55.18 148.72,54.73 148.28,54.29 147.85,54.29 147.13,53.57 147.13,51.22 146.35,50.44 146.35,48.94 146.01,48.61 146.01,48.24 v4(146.06,48.2)
  IN3 w0.254: v5(145.86,47.79) 146.06,47.98 v4(146.06,48.2) ; v4(149.36,60.19) 149.57,59.98 v5(149.57,59.86)
  BOTTOM w0.203: v5(149.57,59.86) 149.47,59.96 RC51.1
  vias: v2(145.48,47.94)
+3V_OSC: length 1.2
  TOP w0.081: RE553.1 33.55,18.11 v1(33.69,17.97)
+3V_SPI:
  vias: v3(41.11,9.44) v6(43.19,10.07) v6(43.86,9.88)
+3V_TEMP: length 3
  TOP w0.254: R53.2 C6906.1 C28.1 134.06,49.83 133.78,49.55 U3.1
+3V_WWAN: length 125.3
  TOP w0.203: QN4.2 60.05,37.87 60.31,38.13 60.62,38.13 61,38.51 v2(61,38.76) 61,39.39 60.78,39.61 59.93,39.61
  TOP w0.254: 61,38.51 61.35,38.16 61.35,37.04 61.53,36.86 QN8.2 ; v2(28.5,6.57) 28.45,6.57 28.1,6.91 RN197.1 ; v6(58.25,44.08) 58.01,44.08 57.76,43.82 RN74.2 ; QN8.5 63.21,36.86 62.96,37.1 62.96,37.75 v2(63.34,38.13) 64.97,39.76 v3(64.97,41) v2(64.97,42.43) ; QN4.5 60.05,39.49 59.93,39.61 58.86,39.61 58.61,39.36 v2(58.61,38.98)
  IN1 w0.254: v2(63.49,45.19) 63.49,43.51 64.57,42.43 v2(64.97,42.43) ; v4(35.08,51.21) 34.99,51.12 34.99,44.55 36.32,43.22 36.32,41.53 35.55,40.77 35.55,39.83 34.25,38.53 33.87,38.53 32.27,36.93 30.05,36.93 29.18,36.05 29.18,33.8 31.41,31.57 31.41,29.19 29.73,27.51 29.73,23.9 29.73,23.9 29.73,22.97 31.18,21.52 31.18,17.71 32.89,15.99 32.89,14.07 31.39,12.57 31.39,7.22 v2(30.8,6.62) 30.75,6.57 v2(28.5,6.57) ; v2(58.61,38.98) 58.81,39.18 59.33,39.18 59.75,38.76 v2(61,38.76) 62.72,38.76 v2(63.34,38.13)
  IN2 w0.508: v4(42.1,70.2) 42.1,70.13 42.54,69.7 42.54,68.57 42.49,68.53 42.49,65.53 44.35,63.67 44.35,63.29 44.95,62.69 44.95,58.74 46.26,57.43 46.26,53.84 47.61,52.49 47.61,51.05 46.82,50.27
  IN3 w0.254: v4(35.08,51.21) 35.13,51.21 35.21,51.29 35.29,51.29 35.4,51.4 40.54,51.4 41.02,50.92 42.18,50.92 42.58,50.51 44.9,50.51 45.27,50.14 v6(45.42,50.14)
  IN3 w0.508: v4(42.1,70.2) 42.26,70.36 v5(42.48,70.36)
  BOTTOM w0.356: v5(42.48,70.36) 42.24,70.6 37.58,70.6 36.41,69.43 CN41.1 CS49.1 RN67.1
  vias: v6(45.69,49.63) v6(46.11,50.09) v6(46.13,49.24) v6(46.5,49.69) v6(46.53,48.83) v6(65.48,48.33) v6(65.46,47.69) v6(65.48,46.98)
+3V_WWAN_R: length 1.3
  TOP w0.081: RZ5.1 43.7,44.47 v1(43.62,44.4)
+3VALW: length 664.8
  TOP w0.203: CM47.2 18.08,75.23 18.32,74.99 UM4.13
  TOP w0.254: v6(123.15,52.29) 123.08,52.29 122.82,52.54 122.82,52.83 122.2,53.45 122.2,54.63 121.09,55.73 121.09,55.82 120.87,56.05 120.87,56.55 119.75,57.67 118.58,57.67 117.62,58.63 117.62,59.9 116.44,61.07 116.44,62.69 117.92,64.17 v2(123.8,64.17) ; RE84.1 RE82.1 42.61,34.16 42.73,34.27 42.93,34.27 RE86.1 43.24,34.59 43.24,34.82 v6(43.31,34.89) 43.53,35.11 44.61,35.11 RE76.1 44.85,34.69 RE526.1 ; v6(55.16,23.25) 54.87,23.55 RE58.1 ; v6(54.89,29.68) 54.89,29.57 54.95,29.51 RE70.1 54.94,29.03 54.94,28.47 RE66.1 55.27,28.47 55.53,28.21 55.53,27.13 RE68.1 ; JAPS1.3 132.95,73.41 132.7,73.65 131.33,73.65 130.95,73.26 JAPS1.7 130.95,71.93 131.22,71.65 131.22,71.05 130.12,69.95 128.74,69.95 127.59,68.8 125.24,68.8 124.77,68.33 124.77,66.86 125.02,66.6 v2(125.4,66.6) ; v6(37.72,39.65) 37.95,39.88 R89.1 ; 47.78,41.53 47.49,41.82 UZ9.4 ; RE67.1 53.36,27.02 RE87.1 RE74.1 RE71.1 RE69.1 53.24,29.51 53.24,29.7 v6(53.02,29.91) ; UC9.5 134.75,51.42 134.33,51 134.33,50.57 134,50.24 v2(133.63,50.24) ; v6(115.34,17.27) 115.34,17.22 113.67,15.55 113.67,15.08 112.09,13.5 112.09,12.22 111.4,11.52 109.77,11.52 PR41.2
  TOP w0.381: v6(55.03,33.89) 55.03,33.8 54.37,33.14 RE5.1 ; 47.78,41.53 48.01,41.3 CZ236.1 48.01,40.19 47.62,39.8 47.23,39.8 v2(46.85,39.42) ; v6(108.78,27.75) 108.85,27.82 108.85,28.6 109.2,28.95 109.74,28.95 109.99,28.69 UC18.5 ; v2(58.63,41.9) 58.63,40.5 57.96,39.83 RN89.1 ; v6(102.17,24.6) 101.97,24.4 98.87,24.4 98.44,24.83 PR101.1 ; RE83.1 45.27,18.31 v6(45.23,18.35) ; RE23.1 37.79,30.91 v2(38.28,30.91) 38.56,30.91 38.83,31.19 39.39,31.19 40.05,30.53 40.92,30.53 41.03,30.42 v6(41.15,30.42) ; v2(38.75,29.84) 38.75,29.84 RE21.1 ; v2(42.46,32.65) 42.52,32.59 42.96,32.59 RE18.1 43.08,32.46 RE77.1 ; v6(128.46,13.87) 128.01,13.87 127.8,14.07 U10.5 127.8,14.43 129.03,15.66 U7.5 ; PR1814.1 74.21,22.05 74.4,21.86 v6(74.51,21.86) ; RE177.1 60.45,16.46 v6(60.47,16.44) ; CM47.2 v2(17.54,75.68) ; RE19.1 v6(51.77,16.75) 51.76,16.76 RE88.1
  TOP w0.508: PR5.1 v6(116.4,16.54) ; RN84.2 55.56,44.1 57.27,45.81 v2(57.59,45.81) ; v6(96.37,9.6) 96.37,8.65 97.1,7.91 97.85,7.91 98.36,7.4 98.36,6.89 99.62,5.63 99.62,5.12 100.29,4.45 100.29,3.76 v6(100.24,3.71) 99.33,3.71 99.27,3.77 50.59,3.77 49.27,5.08 46.3,5.08 44.31,7.07 v6(43.79,7.07) ; v6(39.33,13.12) 39.33,11.99 39.8,11.52 RC561.2 ; RZ22.1 35.01,14.56 34.71,14.26 34.71,12.14 34.16,11.6 32.22,11.6 ; v6(141.57,17.08) 141.29,17.08 v2(140.27,18.1) ; v6(4.18,29.75) 3.9,30.02 3.9,31.42 4.5,32.02 6.22,32.02 6.69,31.55 8.29,31.55 9.18,32.44
  IN1 w0.254: v2(125.4,66.6) 125.09,66.6 124.83,66.35 124.83,66.35 124.79,66.3 124.79,65.9 124.83,65.86 124.83,65.32 123.8,64.29 v2(123.8,64.17) ; v4(39.48,67.67) 39.39,67.76 v2(39.39,68.02) ; v6(123.15,52.29) 124.22,52.29 126.39,50.12 126.71,50.12 127.17,49.66 133.37,49.66 133.63,49.91 v2(133.63,50.24)
  IN1 w0.508: v2(42.46,32.65) 42.53,32.72 v4(42.95,32.72) ; v2(140.27,18.1) 140.25,18.12 v4(139.66,18.12) ; v2(61.87,53.04) 61.87,53.39 60.59,54.68 58.48,54.68 v4(58.45,54.7) ; v2(38.28,30.91) 38.56,30.63 38.56,30.38 38.75,30.18 v2(38.75,29.84) 38.4,29.49 36.55,29.49 36.23,29.17 36.23,28.66 37.54,27.35 37.54,26.72 v4(37.8,26.46) 38.03,26.69 38.29,26.69 38.89,27.28 v2(38.89,27.28) ; v4(134.56,12.8) 136.17,12.8 136.49,12.48 137.3,12.48 v4(137.97,13.15) ; v2(46.85,39.42) 46.38,39.42 46.04,39.77 v2(45.28,39.77) ; v4(62.57,57.67) 62.58,57.66 v2(63.4,57.66) ; v2(58.63,41.9) 58.63,42.28 59.58,43.23 60.06,43.71 60.06,45.26 59.88,45.44 ; v2(38.54,23.98) 38.37,23.98 v4(38.19,24.16) ; v4(199.22,62.3) 199.22,61.43 199.81,60.83 199.81,57.88 198.29,56.35 198.29,45.84 198.8,45.33 204.06,45.33 205.19,44.19 205.19,39.46 204.69,38.95 204.69,36.86 203.48,35.65 200.38,35.65 199.87,35.14 v4(199.87,34.03) 199.87,33.76 197.36,31.25 197.29,31.25 196.78,30.74 v4(196.14,30.74) ; 59.88,45.44 60.25,45.81 60.25,50.05 59.47,50.84 59.47,51.94 58.45,52.95 v4(58.45,53.31) ; 59.88,45.44 59.51,45.81 v2(57.59,45.81)
  IN2 w0.381: 106.63,27.18 106.95,27.5 108.52,27.5 v6(108.78,27.75) ; v4(37.8,26.46) 37.61,26.27 37.61,24.74 v4(38.19,24.16)
  IN2 w0.508: v4(137.97,13.15) 137.97,12.89 138.6,12.26 160.87,12.26 v4(162.82,10.31) ; v4(62.57,57.67) 61.89,57.67 60.62,56.41 58.45,56.41 ; 58.45,56.41 57.95,56.92 52.15,56.92 51.4,57.67 51.4,59.48 50.19,60.69 50.19,63.14 49.68,63.64 49.67,63.64 48.38,64.93 48.38,66.32 47.73,66.98 v4(47.73,68.32) ; 58.45,56.41 v4(58.45,54.7) v4(58.45,53.31) ; v4(47.73,68.32) 47.55,68.32 v4(46.36,69.5) ; v4(47.73,68.32) 52.17,68.32 52.22,68.26 v4(52.87,68.26) 53.27,67.87 v4(55.55,67.87) ; v4(192.91,11.62) 192.91,14.97 192.45,15.43 192.45,17.54 193.24,18.33 v4(193.24,19.79) 192.91,20.12 191.88,20.12 190.39,18.63 190.39,17.91 190.75,17.55 190.75,16.41 189.41,15.07 189.41,10.4 188.48,9.47 185.02,9.47 183.88,10.61 183.88,13.6 182.89,14.58 v4(181.95,14.58) 181.66,14.28 181.66,10.9 180.37,9.61 177.99,9.61 176.19,11.41 176.19,13.76 175.49,14.46 v4(174.31,14.46) 174.57,14.2 174.57,12.54 173.83,11.8 173.83,9.82 173.38,9.37 167.98,9.37 166.6,10.75 166.6,12.21 166.08,12.74 v4(165.85,12.74) ; v6(74.51,21.86) 75.51,21.86 75.77,21.61 77.72,21.61 79.29,20.03 80.3,19.02 89.43,19.02 90.04,18.41 93.86,18.41 v6(93.87,18.42) ; v4(157.39,16.84) 157.3,16.75 157.3,16.2 156.86,15.77 155.56,15.77 154.55,16.78 150.41,16.78 149.83,16.2 146,16.2 145.39,16.81 144.58,16.81 144.03,16.26 142.16,16.26 141.57,16.85 v6(141.57,17.08) ; v4(196.14,30.74) 196.58,30.29 197.42,30.29 199.3,28.41 199.3,21.27 198.27,20.24 194.23,20.24 v4(193.92,20.54) ; v4(192.18,72.26) 192.18,71.98 191.79,71.59 191.29,71.59 190.02,70.32 190.02,67.46 193.27,64.21 193.27,62.8 193.78,62.3 v4(199.22,62.3) ; v6(4.18,29.75) 4.72,29.2 v6(4.72,9.46) ; 31.76,13.38 31.76,7.65 33.5,5.91 v4(37.73,5.91) 42.59,5.91 43.75,7.07 v6(43.79,7.07)
  IN3 w0.064: v4(192.18,72.26) 191.57,72.87 191.4,72.87 v5(191.36,72.91)
  IN3 w0.254: v4(139.66,18.12) 139.85,18.32 v5(139.85,19.8) ; v4(157.39,16.84) 157.3,16.75 v5(157.3,16.45)
  IN3 w0.508: v5(53.04,76.82) 53.04,77.94 53.54,78.44 54.21,78.44 54.73,77.92 54.73,76.91 55.35,76.29 v5(55.35,76.11) 56.59,76.11 57.59,75.11 57.59,69.37 57,68.78 55.61,68.78 v5(55.41,68.58) 55.41,68.31 55.55,68.17 55.55,67.87 v4(55.55,67.87) ; 165.28,12.29 165.28,11.52 164.86,11.1 164.44,11.1 163.64,10.31 v4(162.82,10.31) ; 23.49,77.03 25.91,79.45 37.47,79.45 v4(39.03,77.89) 39.04,77.88 39.04,76.53 42.72,72.85 42.72,71.89 45.1,69.5 v4(46.36,69.5) ; v4(199.22,62.3) 199.01,62.3 v5(198.76,62.54) ; v5(200.42,34.65) 199.87,34.1 v4(199.87,34.03) ; v5(42.95,32.08) v4(42.95,32.72) 42.43,32.72 42.32,32.83 41.41,32.83 40.92,32.34 39.17,32.34 38.07,33.44 34.84,33.44 34.59,33.19 31.02,33.19 v5(30.16,34.05) ; v5(52.99,68.63) 52.99,68.38 v4(52.87,68.26) ; v4(47.73,68.32) 47.37,67.96 43.98,67.96 43.42,68.51 42.2,68.51 41.86,68.17 39.98,68.17 v4(39.48,67.67) ; v4(196.14,30.74) v5(195.69,30.29)
  BOTTOM w0.081: v5(191.36,72.91) 191.18,72.73 191.18,72.7 191.16,72.68 PRM27.2
  BOTTOM w0.254: PRV23.2 v5(53.04,76.82) ; UC5.5 122.67,51.98 122.93,52.24 122.97,52.24 123.02,52.29 v6(123.15,52.29)
  BOTTOM w0.381: R5.1 97.04,10.27 v6(96.37,9.6) ; RPD84.1 29.92,34.29 v5(30.16,34.05)
  BOTTOM w0.508: 28.58,11.98 28.58,10.51 27.52,9.45 25.7,9.45 DB3.2 22.47,9.21 10.7,9.21 10.45,9.46 v6(4.72,9.46) ; v6(60.47,16.44) 60.01,16.91 53.15,16.91 52.44,17.62 ; v6(117.32,10.59) 117.36,10.56 117.36,8.91 115.57,7.12 115.57,5.8 113.68,3.91 100.44,3.91 v6(100.24,3.71) ; PRM26.2 198.33,62.11 v5(198.76,62.54) ; v6(116.4,16.54) 116.07,16.54 v6(115.34,17.27)
  vias: v2(18.64,75.68) v2(19.4,67.32) v2(19.41,67.64) v2(19.79,67.31) v2(19.8,67.64) v2(33.31,62.58) v2(33.39,62.09) v2(33.67,62.4) v2(33.92,62.17) v2(37.24,6.04) v2(37.33,5.61) v2(39.53,77.7) v2(41.94,77.41) v2(194.14,11.77) v2(194.4,11.52) v3(41.67,37.78) v3(44.55,40.83) v3(93.48,23.26) v4(17.54,76.13) v4(18.64,76.09) v4(19.42,66.86) v4(19.92,66.85) v4(23,75.97) v4(23.61,75.98) v4(32.42,62.55) v4(32.83,62.19) v4(119.88,48.27) v4(120.19,47.93) v4(120.56,47.6) v4(120.75,48.84) v4(121.08,48.46) v4(121.56,47.82) v4(192.91,10.91) v5(120.16,48.71) v5(120.28,48.33) v5(120.36,48.92) v5(120.46,48.58) v5(120.58,48.06) v5(120.73,48.35) v5(120.85,47.8) v5(120.97,48.1) v5(121.27,47.6) v5(121.39,48.2) v5(165.63,13.02) v5(165.81,13.24) v5(173.91,14.46) v5(173.9,14.02) v5(181.6,14.53) v5(181.6,14.16) v6(30.65,15.44) v6(30.65,14.86) v6(30.65,14.27) v6(31.24,15.44) v6(31.24,14.86) v6(31.24,14.27) v6(31.83,15.44) v6(31.83,14.86) v6(31.83,14.27) v6(32.41,15.44) v6(32.41,14.86) v6(32.41,14.27) v6(39.76,36.78) v6(40.11,37.34) v6(40.27,36.55) v6(40.57,37.02) v6(40.85,36.48) v6(41.13,36.97) v6(50.58,32.95) v6(51.18,32.89) v6(53.69,29.91) v6(55.59,33.92) v6(55.54,33.36) v6(56.1,33.38) v6(56.44,29.46) v6(92.5,23.75) v6(92.82,24.41) v6(93.1,23.87) v6(93.38,24.4) v6(93.67,23.88) v6(93.94,24.41) v6(94.23,23.93) v6(94.53,24.41)

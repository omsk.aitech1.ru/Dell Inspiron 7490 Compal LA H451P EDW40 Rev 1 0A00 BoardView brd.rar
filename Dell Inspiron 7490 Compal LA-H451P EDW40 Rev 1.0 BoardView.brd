# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.05V_MPHYPLL on TOP (solid shape): 143.55,36.94 144.86,36.94 144.89,36.92 144.89,36.46 143.08,36.46 142.96,36.59 140.82,36.59 140.74,36.67 140.74,37.51 140.85,37.61 142.88,37.61
+1.05V_PRIM on TOP (solid shape): 114.85,29.69 114.85,29.17 115.11,28.91 116.4,28.91 116.58,28.74 116.58,28.73 116.8,28.51 116.8,25.55 116.48,25.24 115.6,25.24 115.47,25.36 115.47,25.94 115.09,26.31 112.4,26.31 112.37,26.34 112.37,27.96 112.46,28.05 113.65,28.05 113.75,28.15 113.75,29.65 113.82,29.72 114.82,29.72
+1.05V_PRIM on TOP (solid shape): 146.74,45.13 146.86,45.13 147.05,44.93 147.05,44.08 146.98,44.01 146.04,44.01 145.93,44.01 145.88,43.96 145.88,43.86 145.88,43.58 145.83,43.52 145.3,43.52 145.27,43.5 145.19,43.5 144.48,42.78 143.49,42.78 143.47,42.8 143.47,42.84 143.42,42.89 143.42,42.98 143.41,42.98 143.41,43.06 143.12,43.35 142.57,43.35 142.42,43.5 142.42,44.32 142.53,44.43 144.45,44.43 145.2,45.18 145.36,45.18 145.44,45.26 145.44,45.82 145.48,45.86 146.01,45.86
+1.05V_PRIM on TOP (solid shape): 142.02,35.99 142.02,33.49 142.02,33.48 142.94,32.55 142.94,30.17 142.72,29.95 141.39,29.95 140.84,30.51 140.84,33.54 140.86,33.55 140.94,33.61 141,33.69 141.02,33.74 141.03,33.8 141,34 140.86,34.13 140.86,34.34 140.94,34.41 140.99,34.5 141.01,34.72 140.89,34.92 140.87,34.95 140.86,34.98 140.86,35.04 140.87,35.24 140.71,35.36 140.71,35.97 140.81,36.07 141.93,36.07
+1.05V_PRIM on BOTTOM (solid shape): 132.25,35.04 132.25,34.23 131.63,33.61 131.11,33.61 130.72,34 130.72,35.08 130.8,35.16 132.13,35.16
+1.05V_PRIM on BOTTOM (solid shape): 143.65,28.69 143.65,27.62 143.52,27.5 142.05,27.5 142,27.55 142,27.98 142.05,28.03 142.28,28.03 142.53,28.28 142.53,28.28 143.04,28.79 143.55,28.79
+1.05V_PRIM on BOTTOM (solid shape): 143.01,30.98 143.01,30.98 142.81,30.77 142.81,30.52 142.91,30.42 143.65,30.42 143.68,30.39 143.68,30.17 143.63,30.13 142.66,30.13 142.61,30.18 142.61,30.49 142.28,30.83 142.16,30.83 142.14,30.84 141.95,30.84 141.95,31.57 142.43,31.57
+1.05V_PRIM on BOTTOM (solid shape): 139.03,29.81 139.03,29.5 138.95,29.43 138.95,29.25 138.9,29.2 138.9,28.97 138.47,28.54 138.27,28.54 138.2,28.61 138.12,28.59 138.03,28.59 138,28.6 136.94,28.6 136.88,28.54 136.8,28.54 136.64,28.37 136.64,28.37 136.64,28.01 136.49,27.85 135.55,27.85 135.55,28.37 133.57,28.37 133.57,27.83 133.03,27.83 132.89,27.97 132.89,29.75 133.08,29.94 133.62,29.94 133.77,29.88 133.91,29.94 134.28,29.94 134.43,29.88 134.57,29.94 134.87,29.94 135.01,29.88 135.16,29.94 137.44,29.94 137.68,30.17 137.93,30.17 137.95,30.19 138.65,30.19
+1.05V_PRIM on BOTTOM (solid shape): outline of 1011 points within 141.14,42.22 147.36,48.81
+1.05V_PRIM on IN1 (solid shape): 147.23,48.33 147.23,44.67 147.13,44.57 146.69,44.57 145.4,45.86 145.4,45.98 144.95,46.43 144.95,47.36 145.14,47.55 145.94,47.55 146.39,48 146.39,48.47 146.46,48.54 147.02,48.54
+1.05V_PRIM on IN1 (solid shape): 131.86,34.47 131.86,32.74 132.53,32.08 132.53,30.46 133.08,29.91 136.23,29.91 137.38,31.06 138.98,31.06 141.51,28.53 143.94,28.53 144,28.47 144,27.31 143.94,27.26 139.89,27.26 138.88,28.26 138.82,28.76 138.37,28.54 131.66,28.54 131.25,28.95 131.25,31.03 130.67,31.61 130.67,34.5 130.78,34.62 131.71,34.62
+1.05V_PRIM on IN2 (solid shape): 144.5,48.39 144.5,47.98 144.48,47.96 144.48,46.33 142.55,44.4 142.55,43.06 142.23,42.74 141.89,42.74 141.54,43.1 141.54,47.22 142.85,48.53 144.36,48.53
+1.05V_PRIM on IN2 (solid shape): outline of 1152 points within 137.69,28.56 147.37,48.45
+1.05V_PRIM on IN3 (solid shape): outline of 327 points within 141.49,42.01 147.66,48.81
+1.05V_PRIM on IN1: 115.47,28.86 115.47,25.3 115.66,25.11 117.06,25.11 117.88,25.94 117.88,26.38 118.58,27.08 118.58,28.86 123.02,33.3 124.29,33.3 125.88,34.89 129.35,34.89 129.91,35.45 129.91,35.88 129.63,36.16 124.8,36.16 123.91,35.27 121.88,35.27
+1.05V_PRIM on VCC: 115.55,20.12 115.15,20.52 115.15,26.94 117.97,29.75 122.86,29.75 135.66,42.55 135.66,47.53 137.01,48.88 146.1,48.88 146.23,49.01 146.6,49.01 147.06,48.55 147.06,32.86 141.92,27.72 141.92,20.58 141.55,20.22 141.55,20.22 141.45,20.12
+1.05V_PRIMP on TOP (solid shape): 139.22,25.82 139.22,22.12 139.19,22.1 137.69,22.1 137.66,22.13 137.66,22.81 137.73,22.88 137.73,25.9 137.79,25.96 139.08,25.96
+1.05V_PRIMP on BOTTOM (solid shape): 138.04,28.42 138.04,27.73 138.28,27.48 138.28,26.27 138.48,26.07 140.28,26.07 140.38,25.97 140.38,25.28 140.27,25.17 138.94,25.17 138.74,24.96 138.74,22.1 138.6,21.96 136.22,21.96 136.21,21.97 135.57,21.97 135.22,22.32 135.22,25.43 134.8,25.84 132.94,25.84 132.68,26.1 132.68,27.56 132.79,27.67 136.64,27.67 136.8,27.84 136.8,28.28 136.99,28.48 137.98,28.48
+1.05V_XTAL on BOTTOM (solid shape): 134.31,38.12 135.06,38.12 135.06,37.72 135.05,37.7 134.99,37.63 134.91,37.6 134.84,37.63 134.52,37.7 134.36,37.41 134.33,37.34 134.26,37.3 133.52,37.3 131.53,35.32 130.83,35.32 130.25,35.89 129.48,35.89 129.37,35.99 129.37,37.15 129.4,37.17 129.77,37.17 130,37.4 131.84,37.4 131.91,37.48 131.91,37.81 132.35,38.24 134.18,38.24
+1.8V_PRIM on TOP (solid shape): 34.23,36.8 34.23,36.13 34.16,36.06 32.07,36.06 31.94,36.18 31.94,36.9 32.04,37 34.03,37
+1.8V_PRIM on TOP (solid shape): 50.69,45.96 50.69,44.62 50.66,44.59 50.66,44.11 50.57,44.02 49.66,44.02 49.59,44.08 49.59,45.99 49.7,46.09 50.56,46.09
+1.8V_PRIM on TOP (solid shape): 136.1,72.54 136.1,71.84 136.03,71.77 135.09,71.77 134.76,71.44 134.36,71.44 134.31,71.49 134.31,72.53 134.43,72.64 135.99,72.64
+1.8V_PRIM on TOP (solid shape): 137.79,34.01 137.79,33.85 137.41,33.47 137.06,33.47 136.17,34.37 136.17,34.63 136.63,35.09 136.71,35.09
+1.8V_PRIM on TOP (solid shape): 36.11,63.89 36.11,63.41 36.23,63.29 36.59,63.29 36.63,63.25 36.63,63.05 36.57,62.98 36.21,62.98 36.16,62.93 36.16,62.26 36.03,62.13 36.03,60.11 35.99,60.07 35.41,60.07 35.36,60.13 35.36,63.91 35.45,64.01 36,64.01
+1.8V_PRIM on TOP (solid shape): 120.42,52.22 120.42,52.06 120.43,52.05 120.43,51.96 120.52,51.87 121.75,51.87 121.8,51.82 121.8,51.23 121.79,51.23 121.79,50.68 121.77,50.66 121.15,50.66 121.14,50.67 121.14,51.31 121.06,51.4 120.33,51.4 120.29,51.43 120.29,51.46 120.17,51.59 120.17,52.22 120.23,52.29 120.36,52.29
+1.8V_PRIM on TOP (solid shape): 76.32,36.12 76.7,36.12 77.18,35.65 77.18,34.13 76.86,33.81 76.86,30.92 77.32,30.46 77.32,30.45 78.99,28.78 78.99,27.2 78.91,27.12 78.54,27.12 78.53,27.12 78.53,27.66 78.52,27.67 78,27.67 77.99,27.66 77.99,27.13 77.98,27.12 77.74,27.12 77.73,27.12 77.73,27.49 77.77,27.53 77.73,27.57 77.73,27.67 77.2,27.67 77.19,27.66 77.19,27.12 77.18,27.12 74.9,27.12 74.49,27.52 74.49,29.7 74.73,29.94 74.73,35.97 74.88,36.13 76.32,36.13
+1.8V_PRIM on TOP (solid shape): 109.63,45.12 109.9,45.03 110.14,45.17 110.36,45.17 110.61,44.93 110.61,43.19 110.51,43.09 108.94,43.09 108.84,42.99 108.71,42.65 109,42.44 109.13,42.44 109.18,42.49 110.08,42.49 110.16,42.45 110.18,42.37 110.29,42.12 110.56,42.15 111.42,42.15 112.57,41 115.24,41 115.7,40.54 115.7,40.22 115.66,40.19 115.66,40.19 115.36,39.89 111.14,39.89 109.59,41.45 109.48,41.45 109.45,41.47 107.39,41.47 106.91,41.96 106.91,42.8 107.53,43.43 107.68,43.5 107.76,43.65 109.28,45.17 109.58,45.17
+1.8V_PRIM on TOP (solid shape): 141.43,48.07 141.43,46.94 141.4,46.87 141.34,46.83 141.26,46.81 141.2,46.77 140.96,46.53 140.96,46.33 140.74,46.11 139.08,46.11 138.98,46.2 138.85,46.2 138.34,46.2 137.35,46.2 137.34,46.22 137.34,46.6 136.85,46.6 136.85,46.21 136.63,46.21 136.34,46.22 136.27,45.94 136.27,45.93 136.27,45.8 136.02,45.55 135,45.55 135,45.55 134.72,45.55 134.65,45.62 134.65,46.73 134.96,47.04 139.01,47.04 139.2,46.98 139.4,47.04 139.95,47.04 140.2,46.79 140.61,46.79 140.65,46.83 140.68,46.83 140.77,46.92 140.92,46.92 140.92,47.16 140.94,47.18 140.94,47.37 140.96,47.4 140.96,47.64 140.92,47.69 140.92,47.76 140.85,47.76 140.73,47.88 139.99,47.88 139.9,47.97 139.9,48.16 139.92,48.19 141.31,48.19
+1.8V_PRIM on BOTTOM (solid shape): 131.17,48.88 131.17,45.67 131.14,45.67 131.14,45.16 131.17,45.16 131.17,44.9 131.14,44.9 131.14,44.49 131.04,44.39 130.87,44.39 130.86,44.4 129.6,44.4 129.57,44.43 129.57,45.36 129.81,45.6 129.81,46.57 130.52,47.29 130.52,48.83 130.6,48.91 131.13,48.91
+1.8V_PRIM on BOTTOM (solid shape): 120.76,45.91 120.76,43.45 120.76,43.45 120.76,42.51 120.56,42.31 120.56,42.25 120.52,42.21 120.52,41.28 120.75,41.05 122.7,41.05 122.72,41.05 123.17,41.49 123.17,41.84 123.68,42.36 123.68,44.27 123.95,44.54 125.3,44.54 125.3,44.52 126.52,44.52 126.52,44.54 126.93,44.54 127.11,44.36 127.11,44.03 126.67,43.6 126.3,43.6 126.15,43.45 125.73,43.45 124.68,42.4 124.68,41.98 124.07,41.37 124.07,41.34 124.02,41.3 124.02,40.73 123.43,40.13 120.94,40.13 120.94,40.13 114.55,40.13 114.44,40.24 114.44,40.51 114.61,40.68 114.62,40.68 114.72,40.78 114.87,40.93 116.59,40.93 116.66,40.87 118.87,40.87 119.01,41.01 119.6,41.01 119.85,41.27 119.85,42.9 120.02,43.07 120.02,43.18 120.03,43.19 120.03,43.4 120.02,43.41 120.02,44.29 119.77,44.54 119.32,44.54 119.14,44.72 119.14,45.33 119.7,45.33 119.7,45.84 119.14,45.84 119.14,46.14 119.24,46.24 120.43,46.24
+1.8V_PRIM on BOTTOM (solid shape): 141.08,47.64 141.22,47.52 141.41,47.52 141.44,47.53 141.54,47.44 141.54,45.63 141.5,45.54 141.41,45.53 141.03,45.27 141.41,45 141.5,44.99 141.54,44.91 141.54,44.29 141.26,44.01 140.45,44.01 140.2,44.26 140.2,44.6 140.28,44.69 140.29,44.69 140.44,44.93 140.24,45.13 140.2,45.14 140.2,45.41 140.23,45.49 140.3,45.52 140.53,45.75 140.3,45.97 140.23,46 140.2,46.08 140.2,47.41 140.35,47.56 140.42,47.59 140.49,47.57 140.71,47.51 140.9,47.64
+1.8V_PRIM on IN1 (solid shape): 108.13,45.19 110.15,45.19 110.37,44.98 110.37,44.71 110.01,44.36 107.57,44.36 106.32,45.61 106.32,46.02 106.69,46.39 106.93,46.39
+1.8V_PRIM on IN1 (solid shape): 138,34.01 138,33.29 137.87,33.15 136.46,33.15 136.37,33.24 136.37,33.7 136.71,34.04 136.71,34.04 136.8,34.13 137.89,34.13
+1.8V_PRIM on IN1 (solid shape): 135.83,46.24 135.83,45.92 135.78,45.87 135.14,45.87 135.1,45.83 134.4,45.83 134.32,45.75 129.65,45.75 129.54,45.86 129.54,46.31 129.56,46.33 130.37,46.33 130.42,46.38 134.33,46.38 134.63,46.67 135.4,46.67
+1.8V_PRIM on IN1 (solid shape): 34.07,36.53 34.07,36.31 33.78,36.02 33.78,35.48 33.3,35.01 32.6,35.01 32.5,35.11 32.5,35.51 32.5,35.52 32.54,35.52 32.73,35.68 32.67,35.92 32.64,35.99 32.66,36.07 33.27,36.67 33.93,36.67
+1.8V_PRIM on IN2 (solid shape): 134.92,49.63 134.92,49.16 134.64,48.88 134.05,48.88 134.04,48.91 133.72,49.08 133.46,48.82 132.81,48.17 132.81,47.9 128.52,43.61 126.49,43.61 126.09,44.01 126.09,44.32 128.14,46.38 128.59,46.38 128.72,46.51 128.79,46.51 128.88,46.45 128.88,46.35 129.16,45.86 129.45,46.35 129.45,46.45 129.54,46.51 129.93,46.51 132.83,49.41 132.84,49.4 133.43,49.4 133.44,49.41 133.55,49.41 133.82,49.68 133.89,49.68 133.92,49.72 134.84,49.72
+1.8V_PRIM on IN2 (solid shape): outline of 146 points within 98.85,36.14 107.48,46.94
+1.8V_PRIM on VCC: 57.12,34.49 56.34,35.26 49.26,35.26 48.93,35.59 48.93,35.6 48.88,35.65 48.88,36.61 50.81,38.54 50.81,40.47 50.22,41.07 34.25,41.07 33.44,40.26 33.44,35.19 33.16,34.91 33.15,34.91 33.11,34.87 32.47,34.87 32.13,35.21 32.13,46.37 32.56,46.81 57.2,46.81 63.32,40.68 100.81,40.68 101.17,40.33 101.18,37.53 98.15,34.51
+1.8V_PRIM on IN2: 112.38,46.15 112.41,46.12 112.41,45.96 112.38,45.88 112.3,45.86 111.98,45.67 112.03,45.3 112.06,45.27 110.91,44.11 109.44,44.11 109.19,44.37 109.19,44.61 111.12,46.55 111.12,47.95 117.01,53.84 123.82,53.84 123.89,53.77 123.89,51.74 123.45,51.3 120.67,51.3 120.62,51.26 120.21,51.26 119.91,51.56 119.91,52.25 119.93,52.28 119.93,52.67 119.66,52.95 118.91,52.95 118.78,52.82 118.75,52.8 118.73,52.77 117.21,51.26 116.78,51.26 116.77,51.26 116.67,51.27 116.58,51.26 116.57,51.26 115.96,51.26 114.8,50.1 114.26,50.1 112.39,48.23 112.39,46.69 112.38,46.68
+1.8V_PRIM_UV2 on TOP (solid shape): 121.01,50.64 121.01,50.47 121.02,50.46 121.02,50.37 121.13,50.26 121.82,50.26 121.83,50.25 121.83,49.49 121.78,49.44 119.73,49.44 119.37,49.81 119.37,50.33 119.47,50.43 120.17,50.43 120.43,50.7 120.96,50.7
+1.8V_PRIM_UV2 on TOP (solid shape): 117.23,50.43 118.01,50.43 118.07,50.37 118.07,49.19 118.02,49.14 118.02,49.14 117.79,49.23 117.56,49.14 116.57,49.14 116.48,49.23 116.48,50.28 116.52,50.32 116.54,50.35 116.7,50.51 117.15,50.51
+1.8V_PRIMP on TOP (solid shape): 74.3,28.01 74.3,27.15 74.47,26.98 77.26,26.98 77.33,27.04 77.33,27.53 77.34,27.54 77.58,27.54 77.59,27.53 77.59,27 77.61,26.98 78.11,26.98 78.12,26.99 78.12,27.52 78.15,27.54 78.38,27.54 78.4,27.52 78.4,26.99 78.41,26.98 79.68,26.98 79.79,26.86 79.79,26.36 79.58,25.78 79.79,25.2 79.79,24.25 79.69,24.14 75.24,24.14 75.02,23.92 75.02,23.03 74.92,22.93 74.34,22.93 74.12,23.15 72.71,23.15 72.47,23.39 72.47,26.85 72.59,26.98 73.15,26.98 73.27,27.09 73.27,28.03 73.3,28.07 74.24,28.07
+1.8VALW_1.0V on BOTTOM (solid shape): 118.97,47.33 118.97,44.63 118.88,44.54 117.79,44.54 117.57,44.32 117.57,44.24 117.4,44.06 116.56,44.06 116.49,44.13 116.49,45.75 118.19,47.45 118.86,47.45
+1.8VS on TOP (solid shape): 51.95,44.5 51.95,43.1 51.91,43.07 50.89,43.07 50.79,43.17 50.79,44.54 50.89,44.64 51.81,44.64
+1.8VS_DGPU_AON on TOP (solid shape): 117.36,59.78 117.36,58.47 118.74,57.1 119.93,57.1 120.47,56.56 120.47,56.21 120.31,56.05 120.31,54.66 120.34,54.63 120.85,54.63 121.09,54.39 121.09,53.2 120.43,52.54 120.23,52.54 120.04,52.35 120.04,51.74 119.98,51.68 119.49,51.68 119.42,51.75 119.42,52.68 119.53,52.8 119.85,52.8 119.98,52.92 119.98,53.5 119.79,53.68 119.79,56 119.63,56.16 119.44,56.44 119.12,56.32 118.56,56.32 116.78,58.1 116.78,58.11 116.67,58.22 116.67,58.71 116.37,59.01 116.37,59.86 116.43,59.93 117.21,59.93
+1.8VS_DGPU_AON on TOP (solid shape): outline of 98 points within 97.58,63.38 100.55,68.92
+1.8VS_DGPU_AON on IN1 (solid shape): outline of 932 points within 96.91,62.52 117.05,78.12
+1.8VS_DGPU_MAIN on TOP (solid shape): 115.02,59.86 115.02,56.59 115.63,55.98 116.08,55.98 116.17,55.89 116.17,55.2 116.08,55.11 115.16,55.11 115.02,54.97 115.02,54.93 115,54.91 115,53.68 115.35,53.33 115.53,53.33 116.19,52.67 117.77,52.67 118.05,52.39 118.05,51.72 118.02,51.69 115.43,51.69 115.38,51.74 115.38,52.1 114.8,52.67 114.44,52.67 114.23,52.46 113.66,52.46 113.63,52.49 113.63,52.54 113.63,53.37 113.9,53.64 113.9,55.12 114,55.22 114,56 113.24,56.75 113.24,59.67 113.58,60.01 114.87,60.01
+1.8VS_DGPU_MAIN on TOP (solid shape): 103.61,68.14 103.65,68.1 103.65,67.6 103.6,67.55 103.2,67.55 103.04,67.65 102.86,67.58 102.83,67.55 102.6,67.55 102.09,67.04 102.09,66.53 102.25,66.38 102.64,66.38 102.8,66.54 103.13,66.54 103.55,66.12 103.55,66.07 103.1,65.62 102.87,65.62 102.8,65.69 102.36,65.26 102.36,65.11 102.02,64.76 102.02,64.62 102.25,64.39 102.25,63.66 102.21,63.63 101.51,63.63 101.46,63.68 101.46,68.08 101.51,68.14 103.57,68.14
+1.8VS_DGPU_MAIN on IN3 (solid shape): outline of 543 points within 101.38,58.97 114.5,65.12
+1.8VS_R on TOP (solid shape): 51.15,42.67 51.77,42.67 51.8,42.64 51.8,41.97 51.64,41.8 49.76,41.8 49.59,41.96 49.59,42.66 49.72,42.79 51.04,42.79
+1.8VU on TOP (solid shape): 139.47,74.31 139.47,72.76 139.44,72.73 138.77,72.73 138.65,72.86 137.72,72.86 137.71,72.87 137.62,72.87 137.44,73.05 137.44,74.08 137.85,74.49 139.28,74.49
+1.8VU on BOTTOM (solid shape): 175.7,73.14 175.7,70.47 175.65,70.42 174.64,70.42 173.34,71.72 173.34,73.27 173.39,73.32 175.53,73.32
+1.8VU on BOTTOM (solid shape): 175.73,67.63 175.73,67.25 175.63,67.15 174.12,67.15 174.01,67.04 173.33,67.04 173.31,67.06 173.31,67.53 173.36,67.58 175.12,67.58 175.3,67.76 175.6,67.76
+1.8VU on BOTTOM (solid shape): 194.3,49.27 194.3,47.11 194.22,47.03 193,47.03 192.95,47.08 192.95,47.85 192.61,48.2 191.6,48.2 191.33,48.48 191.33,49.31 191.46,49.44 194.12,49.44
+1.8VU on BOTTOM (solid shape): 166.89,67.66 166.89,66.74 166.23,66.74 165.75,67.22 164.61,67.22 164.55,67.28 164.48,67.32 164.45,67.33 164.45,67.6 164.5,67.65 166.33,67.65 166.38,67.71 166.84,67.71
+1.8VU on BOTTOM (solid shape): 139.28,67.63 139.28,67.32 139.22,67.27 138.85,67.27 138.3,66.72 138.3,65.67 137.6,64.96 136.98,64.96 136.96,64.97 136.96,65.39 136.99,65.41 137.42,65.41 137.93,65.93 137.93,66.94 138.73,67.73 139.18,67.73
+1.8VU on BOTTOM (solid shape): 153.3,73.22 154.42,73.22 154.48,73.16 154.48,70.5 154.4,70.42 153.58,70.42 153.33,70.67 153.33,72.22 152.8,72.75 152.79,72.75 152.75,72.8 152.04,72.8 152.01,72.83 152.01,73.77 152.04,73.79 152.73,73.79
+1.8VU on BOTTOM (solid shape): 188.02,68.16 188.02,67.22 187.92,67.12 185.88,67.12 185.86,67.15 185.8,67.25 185.72,67.31 185.69,67.33 185.69,67.53 185.81,67.65 186.58,67.65 187.11,68.19 188,68.19
+1.8VU on BOTTOM (solid shape): 195.06,61.97 195.06,61 194.25,60.19 194.25,59.53 194.18,59.46 193.48,59.46 193.39,59.37 191.53,59.37 191.35,59.55 191.35,59.91 191.4,59.96 191.66,59.96 192.44,60.75 192.44,61.91 192.7,62.17 194.86,62.17
+1.8VU on BOTTOM (solid shape): 167.53,74.54 167.53,73.95 167.42,73.85 166.94,73.85 166.87,73.78 166.87,73.06 166.83,73.02 166.06,73.02 165.34,72.3 165.34,70.63 165.14,70.42 164.48,70.42 164.35,70.55 164.35,73.07 165.32,74.03 165.32,74.51 165.49,74.69 167.37,74.69
+1.8VU on BOTTOM (solid shape): 188.1,72.92 188.17,72.92 188.17,72.92 188.22,72.87 188.36,72.87 188.4,72.82 188.4,71.92 188.37,71.88 186.9,71.88 186.5,71.48 186.5,70.49 186.4,70.4 185.79,70.4 185.64,70.55 185.64,73.24 185.71,73.32 186.55,73.32 186.8,73.57 188.1,73.57
+1.8VU on BOTTOM (solid shape): 151.33,77.47 151.33,76.42 151.08,76.17 151.08,74.26 150.85,74.03 150.85,72.95 150.71,72.81 150.17,72.81 149.92,72.56 149.92,70.58 149.77,70.42 149.42,70.42 149.16,70.68 149.16,73.14 149.3,73.28 149.77,73.28 150.05,73.55 150.05,73.85 150.04,73.85 150.04,75.57 150.42,75.94 150.42,77.51 150.56,77.65 151.15,77.65
+1.8VU on BOTTOM (solid shape): 138.17,76.02 138.17,75.68 138.13,75.64 138.14,75.64 138.14,75.45 138.28,75.45 138.59,75.13 138.51,75.05 138.51,73.57 138.63,73.45 138.63,73.23 138.86,73.23 138.88,73.21 139.16,73.21 139.23,73.14 139.23,72.49 139.27,72.45 139.27,70.54 139.15,70.42 137.88,70.42 137.5,70.8 137.5,72.1 137.38,72.23 136.79,72.23 136.77,72.25 136.77,73.19 136.82,73.24 137.33,73.24 137.45,73.37 137.45,74.52 137.36,74.61 136.82,74.61 136.77,74.66 136.77,75.71 136.85,75.78 137.36,75.78 137.36,76.03 137.47,76.15 138.04,76.15
+1.8VU on IN2 (solid shape): outline of 11371 points within 136.31,48.3 195.84,76.65
+1.8VU_OUT on TOP (solid shape): 138.46,72.45 138.58,72.33 139.43,72.33 139.43,71.78 139.39,71.73 138.68,71.73 138.68,71.71 137.56,71.71 137.49,71.79 137.49,72.57 137.57,72.65 138.26,72.65
+1.35VGPUP on TOP (solid shape): 77.3,54.19 77.3,54.05 76.35,53.09 76.35,52.67 77.45,51.57 77.48,51.57 77.85,51.94 77.85,51.94 78.17,51.62 78.17,51.62 77.79,51.22 78.24,50.77 78.3,50.71 78.32,50.71 78.7,51.09 78.71,51.09 79.02,50.78 79.02,50.76 78.65,50.38 78.65,50.37 79.74,49.27 79.74,48.27 79.43,47.96 79.06,47.96 75.92,44.81 75.92,44.52 75.35,43.96 75.35,43.7 75.42,43.63 75.42,43.25 75.41,43.25 74.96,43.25 74.69,43.51 74.6,43.51 74.6,43.52 73.29,43.52 72.44,42.66 67.03,42.66 66.75,42.95 66.75,46.34 68.25,47.84 72.8,47.84 73.65,48.7 73.65,49.07 74.45,49.86 74.99,49.86 75.62,49.23 76.43,50.04 75.8,50.67 74.99,49.86 74.45,49.86 75.08,50.49 75.08,52.84 76.8,54.55 76.94,54.55
+1.35VGPUP on IN1: 79.96,47.55 79.94,47.55 79.75,47.45 79.65,47.26 79.65,47.24 76.43,44.03 74.58,44.03 73,42.45 70.56,42.45 68.92,44.09 68.92,48.07 71.15,50.3 71.87,50.3 71.88,50.29 72.59,50.29 74.63,52.32 74.63,52.88 76.4,54.65 76.89,54.65 77.58,53.96 77.58,52.99 80.4,50.16 80.4,48
+1.35VS_VRAM on TOP (solid shape): 77.95,54.44 78.73,54.26 79.53,54.26 79.56,54.26 81.28,52.54 81.3,52.54 82.49,51.34 80.46,49.32 79.88,49.32 78.84,50.36 78.84,50.39 79.2,50.76 79.2,50.78 78.71,51.28 78.69,51.28 78.31,50.9 78.29,50.9 77.98,51.21 77.98,51.23 78.35,51.6 78.35,51.63 77.85,52.12 77.84,52.12 77.47,51.76 77.44,51.76 76.56,52.64 76.56,53.05
+1.35VS_VRAM on TOP (solid shape): 82.58,41.58 82.63,41.49 82.63,41.4 82.63,41.4 82.62,41.25 82.68,41.11 82.7,41.05 82.68,40.98 82.59,40.72 82.71,40.48 82.71,40.36 82.69,40.3 82.69,40.25 82.69,39.87 81.18,38.37 80.7,38.37 80.61,38.43 80.62,38.54 80.68,38.63 80.7,38.74 80.7,38.76 81.15,39.21 81.26,39.21 82.13,40.09 82.13,40.75 82.09,40.91 81.96,41.03 81.91,41.11 81.95,41.2 82.04,41.3 82.07,41.41 82.07,41.49 82.11,41.57 82.21,41.58 82.35,41.55 82.48,41.58
+1.35VS_VRAM on TOP (solid shape): 90.52,41.63 90.59,41.66 90.66,41.63 90.72,41.59 90.78,41.57 90.82,41.56 90.83,41.5 90.77,41.45 90.56,41.24 90.56,40.75 90.7,40.49 91,40.47 91.07,40.48 91.13,40.45 91.35,40.32 91.59,40.41 91.64,40.46 91.7,40.4 91.69,40.37 91.67,40.3 91.67,40.22 91.7,40.05 91.82,39.91 91.82,39.87 91.79,39.83 91.76,39.8 91.73,39.76 91.72,39.73 91.58,39.73 91.57,39.74 91.29,39.8 91.07,39.62 90.99,39.56 90.9,39.59 89.75,40.75 89.72,40.86 89.81,40.92
+1.35VS_VRAM on TOP (solid shape): 89.83,67.69 90.01,67.62 90.2,67.67 90.23,67.69 90.37,67.55 90.35,67.52 90.31,67.32 90.4,67.14 90.42,67.07 90.4,67.01 90.32,66.75 90.48,66.53 90.53,66.47 90.52,66.4 90.47,66.34 90.47,66.13 90.62,65.98 91.02,65.98 91.03,65.98 91.27,65.95 91.45,66.1 91.52,66.15 91.6,66.12 91.73,66 91.73,65.13 91.6,65.01 91.18,65.01 89.85,66.34 89.85,66.8 89.79,67.01 89.62,67.15 89.55,67.22 89.57,67.31 89.63,67.41 89.63,67.53 89.62,67.56 89.65,67.6 89.71,67.64 89.76,67.69 89.79,67.7
+1.35VS_VRAM on TOP (solid shape): 88,67.93 88.06,67.87 88.06,67.85 88.26,67.65 88.54,67.71 88.58,67.74 88.68,67.63 88.85,67.54 89.05,67.54 89.14,67.52 89.18,67.45 89.21,67.35 89.28,67.28 89.32,67.2 89.27,67.11 89.15,66.98 89.11,66.8 89.11,66.11 89.28,65.93 89.2,65.84 89.14,65.91 88.91,66 88.68,65.91 88.61,65.88 88.54,65.9 88.54,65.91 88.5,65.99 88.54,66.07 88.64,66.18 88.67,66.33 88.67,66.8 88.48,67.1 88.13,67.04 88.08,67.08 88.03,67.14 88.04,67.22 88.01,67.57 87.67,67.64 87.66,67.64 87.59,67.64 87.58,67.67 87.56,67.71 87.53,67.74 87.5,67.81 87.53,67.88 87.82,68.17 88,68.17
+1.35VS_VRAM on TOP (solid shape): 89.16,64.41 89.24,64.37 89.32,64.29 89.43,64.25 89.46,64.23 89.47,64.19 89.65,63.85 90.02,63.91 90.05,63.94 90.1,63.95 90.13,63.9 90.13,63.43 88.42,61.71 88.42,61.62 88.23,61.43 87.04,61.43 86.54,61.94 86.51,62.05 86.6,62.11 86.77,62.21 86.81,62.4 86.83,62.48 86.91,62.52 86.93,62.52 86.97,62.5 86.97,62.44 87.23,61.98 87.45,62.46 87.43,62.54 87.47,62.6 87.58,62.84 87.48,63.07 87.45,63.14 87.47,63.21 87.5,63.25 87.56,63.3 87.63,63.3 87.86,63.33 87.95,63.54 87.97,63.62 88.05,63.65 88.06,63.65 88.1,63.63 88.1,63.57 88.08,63.29 88.31,63.11 88.32,63.11 88.55,62.88 88.88,62.88 88.88,63.21 88.65,63.43 88.65,63.45 88.62,63.54 88.57,63.62 88.54,63.69 88.56,63.76 88.65,63.99 88.55,64.21 88.51,64.25 88.58,64.31 88.61,64.35 88.68,64.39 88.76,64.37 88.92,64.31 89.08,64.38
+1.35VS_VRAM on TOP (solid shape): outline of 82 points within 85.93,46.35 90.22,50.75
+1.35VS_VRAM on TOP (solid shape): outline of 91 points within 83.78,44.53 87.9,47.82
+1.35VS_VRAM on TOP (solid shape): outline of 117 points within 77.66,69.5 85.35,75.12
+1.35VS_VRAM on TOP (solid shape): outline of 126 points within 85.17,62.85 88.78,67.3
+1.35VS_VRAM on TOP (solid shape): outline of 656 points within 97.14,34.04 104.57,52.24
+1.35VS_VRAM on TOP (solid shape): outline of 233 points within 88.96,39.21 95.25,46.02
+1.35VS_VRAM on TOP (solid shape): outline of 701 points within 75.76,38.15 83.91,45.59
+1.35VS_VRAM on TOP (solid shape): outline of 836 points within 91.07,57.6 98.46,64.29
+1.35VS_VRAM on TOP (solid shape): outline of 960 points within 80.58,31.55 90.89,40.37
+1.35VS_VRAM on TOP (solid shape): outline of 1599 points within 81.8,67.27 96.95,79.84
+1.35VS_VRAM on BOTTOM (solid shape): outline of 85 points within 93.51,57.27 99.57,63.02
+1.35VS_VRAM on BOTTOM (solid shape): outline of 117 points within 94.48,50.01 102.94,57.54
+1.35VS_VRAM on BOTTOM (solid shape): outline of 3735 points within 77.1,34.82 96.45,77.01
+1.35VS_VRAM on IN2 (solid shape): outline of 8517 points within 77.34,34.81 102.81,78.12
+3.3V_TBT on TOP (solid shape): 23.47,61.67 23.47,60.52 23.41,60.46 23.41,60.06 23.38,60.03 22.63,60.03 22.51,60.15 22.51,60.78 22.73,60.99 22.73,61.69 22.76,61.72 23.42,61.72
+3.3V_TBT_FLASH_R on TOP (solid shape): 38.95,53.11 38.95,51.59 38.81,51.45 38.81,50.78 38.95,50.64 38.95,50.21 38.91,50.17 37.71,50.17 37.51,50.37 37.51,52.04 38.17,52.7 38.17,53.06 38.24,53.13 38.83,53.13 38.84,53.14 38.91,53.14
+3.3V_TBT_LC on TOP (solid shape): 23.82,51.85 23.82,51.55 23.32,51.55 23.1,51.51 22.92,51.38 21.51,51.38 21.45,51.45 21.45,51.69 21.48,51.72 23.23,51.72 23.24,51.71 23.34,51.71 23.36,51.73 23.36,51.85 23.41,51.9 23.77,51.9
+3.3V_TBT_S0 on TOP (solid shape): 25.84,60.49 25.84,60.34 25.92,60.25 27.54,60.25 27.62,60.17 27.62,59.89 28.12,59.39 28.22,59.39 28.27,59.38 28.32,59.39 28.69,59.39 28.71,59.37 28.71,58.94 28.66,58.89 23.67,58.89 23.5,58.73 22.56,58.73 22.46,58.83 22.46,58.84 21.96,58.84 21.92,58.88 21.92,59.25 22.05,59.37 22.19,59.37 22.57,59.76 23.35,59.76 23.54,59.94 23.54,60.41 23.7,60.57 25.76,60.57
+3.3V_TBT_S0 on IN1 (solid shape): 28.93,59.48 28.93,59.08 28.66,58.81 28.39,58.81 28.29,58.7 28.29,58.67 28.28,58.66 28.23,58.48 28.29,58.3 28.29,57.87 28.54,57.61 28.75,57.61 28.85,57.52 28.85,57.11 28.83,57.09 28.74,57.09 28.71,57.08 28.64,57.07 28.58,57.08 28.55,57.09 28.39,57.09 28.3,57.18 28.3,57.41 28.11,57.6 28.11,57.61 28.03,57.77 27.88,57.84 27.86,57.84 27.81,57.89 27.81,58.63 27.6,58.84 27.57,58.84 27.56,58.85 25.84,58.85 25.61,59.08 25.61,59.54 25.72,59.65 28.01,59.65 28.04,59.62 28.04,59.6 28.26,59.38 28.5,59.58 28.53,59.65 28.6,59.67 28.73,59.67
+3.3V_TBT_S0 on IN3 (solid shape): 29.98,59.97 30.09,59.86 30.12,59.79 30.09,59.71 30.08,59.39 30.41,59.39 30.48,59.42 30.55,59.39 31.21,58.74 31.21,58.08 31.05,57.93 30.26,57.93 30.26,57.97 30.22,58.09 30.15,58.19 30.11,58.26 30.14,58.34 30.14,58.82 29.66,58.78 29.58,58.74 29.51,58.77 29.39,58.89 28.44,58.89 28.06,58.51 28.06,58.13 28.14,58.04 28.19,58.04 28.2,58.04 28.29,58.02 28.38,58.04 28.39,58.04 28.71,58.04 28.81,57.93 28.84,57.85 28.8,57.78 28.72,57.58 28.83,57.4 28.86,57.38 28.86,57.22 29.1,56.98 29.1,56.87 29.06,56.84 29.03,56.81 28.85,56.81 28.8,56.83 28.76,56.84 28.43,57.17 28.43,57.37 28.53,57.73 28.17,57.84 27.88,57.84 27.88,58.63 27.95,58.7 27.95,58.73 28.24,59.01 28.24,59.02 28.59,59.37 28.59,59.48 28.62,59.52 28.62,59.76 28.65,59.78 29.14,59.78 29.36,59.55 29.36,59.54 29.76,59.39 29.61,59.78 29.59,59.78 29.48,59.89 29.47,59.94 29.52,59.97
+3.3V_TBT_SX on TOP (solid shape): 21.44,61.65 21.44,60.99 22.34,60.09 22.34,59.7 22.21,59.57 21.96,59.57 21.75,59.36 21.25,59.36 21.23,59.38 21.23,59.83 20.75,59.83 20.75,59.83 20.53,59.83 20.49,59.86 20.49,60.83 20.67,61.01 20.67,61.72 20.7,61.75 21.34,61.75
+3.3V_WLAN on TOP (solid shape): 135.2,78.94 135.2,78.72 135.79,78.13 138.84,78.13 138.96,78.26 139.47,78.26 139.6,78.13 139.6,76.92 139.47,76.8 136.98,76.8 136.55,77.22 135.41,77.22 134.66,76.47 133.97,76.47 133.9,76.54 133.9,79.02 134.07,79.18 134.96,79.18
+3.3V_WLAN on TOP (solid shape): 124.24,74.43 124.24,71.16 123.67,70.6 122.16,70.6 122.16,71.56 122.13,71.56 122.06,71.6 122.04,71.69 122.03,71.84 121.96,71.97 121.96,74.61 122.01,74.66 124,74.66
+3.3V_WLAN on BOTTOM (solid shape): 134.68,79.04 134.68,76.65 134.61,76.57 133.24,76.57 133.16,76.65 133.16,77.36 133.26,77.46 133.83,77.46 133.97,77.59 133.97,78.85 134.22,79.1 134.62,79.1
+3.3V_WLAN on BOTTOM (solid shape): 124.5,77.18 124.5,75.08 124.45,74.99 124.34,74.99 124.28,75.02 124.2,75.03 124,75.03 123.72,74.75 124,74.47 124.2,74.47 124.28,74.48 124.34,74.51 124.45,74.51 124.5,74.43 124.5,73.6 124.38,73.48 124.36,73.48 124.28,73.52 124.2,73.53 124,73.53 123.92,73.52 123.85,73.49 123.84,73.48 123.82,73.48 123.67,73.33 123.67,72.71 123.57,72.61 122.85,72.61 122.75,72.72 122.75,76.46 122.64,76.58 122.18,76.58 122.09,76.67 122.09,77.37 122.16,77.44 122.81,77.44 122.82,77.44 124.24,77.44
+3.3V_WLAN on IN1 (solid shape): outline of 634 points within 121.75,72.97 135.01,79.54
+3V_DVDD on TOP (solid shape): 30.39,71.27 30.39,69.66 30.34,69.61 29.58,69.61 29.25,70.13 28.84,70.58 28.84,71.28 29,71.44 30.22,71.44
+3V_FFS on TOP (solid shape): 27.56,78.71 27.56,78.2 27.51,78.16 26.23,78.16 26.16,78.09 26.16,76.83 26.06,76.73 26,76.73 25.79,76.62 25.73,76.38 25.73,76.26 25.79,76.14 25.8,76.11 25.78,76.08 25.73,75.98 25.72,75.6 26.18,75.14 26.5,75.14 26.57,75.08 26.57,74.67 26.5,74.6 25.74,74.6 25.63,74.71 25.65,74.75 25.63,74.96 25.45,75.07 25.4,75.12 25.4,75.77 24.81,75.77 24.81,76.99 24.8,76.99 24.8,77.78 24.82,77.8 24.82,78.54 25.03,78.75 27.52,78.75
+3V_FFS on IN1 (solid shape): 28.09,76.67 28.09,74.96 27.97,74.83 27.22,74.83 27.1,74.95 27.1,75.08 27.04,75.19 27.04,75.38 26.88,75.94 26.72,75.38 26.72,75.19 26.65,75.04 26.69,74.89 26.69,74.76 26.57,74.64 26.31,74.64 26.19,74.77 26.19,76.18 26.23,76.32 26.19,76.46 26.19,76.54 26.5,76.86 27.9,76.86
+3V_FPR on BOTTOM (solid shape): 94.97,10.83 95.45,10.83 95.45,10.77 96.11,10.77 96.61,10.77 96.63,10.74 96.63,10.31 96.27,9.95 96.19,9.95 95.95,9.7 95.93,9.7 95.93,8.08 95.77,7.93 94.25,7.93 94.11,8.07 94.11,8.6 94.05,8.66 94.05,8.69 94.07,8.75 94.08,8.81 94.08,9.6 94.07,9.65 94.05,9.72 94.05,11.19 94.06,11.2 94.6,11.2
+3V_HDA on TOP (solid shape): 145.69,47.9 145.69,47.66 145.45,47.42 145.45,46.14 145.4,46.08 144.92,46.08 144.85,46.15 144.85,46.74 144.68,46.91 143.85,46.91 143.75,47.01 143.75,47.78 143.84,47.87 144.8,47.87 145.01,48.07 145.52,48.07
+3V_OSC on TOP (solid shape): 32.85,19.67 32.85,17.97 32.75,17.87 31.33,17.87 31.05,18.15 31.05,18.91 31.13,18.99 31.69,18.99 31.79,19.09 31.79,19.65 31.84,19.7 32.83,19.7
+3V_SPI on TOP (solid shape): 44.46,10.48 44.46,9.51 44.4,9.45 42.15,9.45 41.94,9.23 40.08,9.23 39.84,9.48 39.83,9.48 39.66,9.65 39.66,10.12 39.45,10.34 39.45,10.81 39.51,10.87 40.86,10.87 40.94,10.94 40.94,11.07 41.08,11.22 43.72,11.22
+3V_SPI on BOTTOM (solid shape): 44.45,10.79 44.77,10.54 45.09,10.79 45.1,10.82 45.6,10.82 46.03,10.39 46.02,10.35 46.8,9.57 46.8,9.55 46.82,9.47 46.88,9.39 46.88,8.35 46.8,8.27 46.11,8.27 45.99,8.4 45.99,9.13 45.81,9.31 42.79,9.31 42.63,9.46 42.63,10.2 42.65,10.22 42.65,10.62 42.86,10.82 44.44,10.82
+3V_WWAN on TOP (solid shape): 65.16,51.48 65.16,51.4 66.09,50.47 66.09,45.77 65.67,45.35 64.66,45.35 64.22,44.92 62.87,44.92 62.72,45.08 62.72,46.6 62.9,46.78 64.4,46.78 64.58,46.95 64.58,51.48 64.65,51.55 65.1,51.55
+3V_WWAN on TOP (solid shape): 47.75,50.14 47.74,50.13 47.74,46.7 47.76,46.67 47.76,46.65 47.61,46.49 47.54,46.51 47.5,46.51 47.31,46.51 47.31,46.58 46.7,46.58 46.7,46.29 45.95,45.54 44.33,45.54 44.29,45.58 44.29,45.64 43.7,45.64 43.57,45.76 43.57,46.49 44.67,47.58 44.67,50.59 44.8,50.73 47.16,50.73
+3V_WWAN on BOTTOM (solid shape): 48.22,50.38 48.22,48.3 48.24,48.3 51.99,44.55 62.15,44.55 64.34,46.74 64.34,50.29 64.42,50.37 67.11,50.37 67.34,50.14 67.34,44.2 64.07,40.93 49.69,40.93 43.64,46.98 43.64,50.54 43.84,50.74 47.87,50.74
+3V_WWAN on IN2 (solid shape): 47.13,50.4 47.13,48.96 46.71,48.53 46.54,48.53 45.22,49.85 45.22,50.49 45.47,50.74 46.79,50.74
+3V_WWAN_R on TOP (solid shape): 46.65,44.87 46.65,44.11 46.55,44.01 44.39,44.01 44.31,44.08 44.31,44.79 44.34,44.82 45.34,44.82 45.51,45 46.52,45
+3VALW on TOP (solid shape): 10.72,33.49 10.72,32.14 10.45,31.88 9.03,31.88 8.87,32.04 8.87,33.3 8.89,33.32 9.67,33.32 10.07,33.73 10.49,33.73
+3VALW on TOP (solid shape): 118.18,11.71 118.18,11.23 118.19,11.23 118.19,11.12 118.35,10.96 118.35,10.54 118.3,10.49 117.27,10.49 117.1,10.65 117.1,11.65 117.24,11.79 118.11,11.79
+3VALW on TOP (solid shape): 20.37,67.55 20.37,61.72 20.28,61.63 20.28,61.01 20.26,60.99 19.77,60.99 19.66,61.1 19.06,61.1 19.01,61.15 19.01,64.35 19.02,64.36 19.02,67.66 19.2,67.84 20.09,67.84
+3VALW on TOP (solid shape): 51.79,33.76 51.79,33.45 51.74,33.29 51.79,33.13 51.79,32.25 51.64,32.1 48.18,32.1 48.11,32.18 48.11,32.59 48.19,32.67 50.09,32.67 50.77,33.35 50.77,33.8 50.88,33.91 51.65,33.91
+3VALW on TOP (solid shape): 37.89,6.29 37.89,5.28 37.75,5.14 37.23,5.14 37.16,5.17 37.13,5.24 37.13,5.25 37.13,5.73 37.1,5.86 37.01,5.96 37.01,6.26 37.1,6.35 37.83,6.35
+3VALW on TOP (solid shape): 46.7,42.71 46.7,41.72 46.05,41.08 46.05,40.13 46.04,40.13 46.04,39.41 44.1,37.46 44.03,37.46 43.99,37.45 43.71,37.45 43.14,36.88 43.14,36.88 42.52,36.26 39.69,36.26 39.47,36.47 39.47,36.89 39.69,37.11 39.69,37.17 43.4,40.89 43.4,41.67 44.52,42.79 46.62,42.79
+3VALW on TOP (solid shape): 33.11,16.82 33.11,14.27 32.63,13.79 32.63,11.2 31.84,10.41 30.91,10.41 29.94,11.37 29.3,11.37 29.07,11.61 29.07,13.84 29.07,13.85 29.59,13.85 29.61,13.87 29.61,14.57 29.6,14.58 29.08,14.58 29.07,14.59 29.07,15.04 29.08,15.05 29.6,15.05 29.61,15.06 29.61,15.77 29.59,15.79 29.07,15.79 29.06,15.8 29.06,16.89 29.15,16.98 32.95,16.98
+3VALW on TOP (solid shape): 193.91,13.2 193.91,12.83 193.76,12.83 193.76,12.17 193.91,12.17 193.91,12.03 193.96,11.97 194.77,11.97 194.91,11.84 194.91,11.58 195.07,11.42 196.05,11.42 196.13,11.34 196.13,11.17 196.03,11.07 194.57,11.07 194.57,11.33 193.76,11.33 193.76,10.92 193.7,10.86 193.7,10.13 193.13,9.55 193.13,8.85 193.07,8.79 193.07,8.35 192.94,8.22 192.68,8.22 192.62,8.28 192.62,13.17 192.69,13.24 193.86,13.24
+3VALW on TOP (solid shape): 35.09,62.99 35.09,62.49 34.66,62.06 34.28,62.06 34.03,61.81 33.41,61.81 33.21,62.02 33.21,62.05 33.29,62.31 33.13,62.54 33.13,62.63 33.23,62.73 33.28,62.85 33.29,62.87 33.32,62.91 33.32,63.03 33.41,63.12 34.97,63.12
+3VALW on TOP (solid shape): 93.34,24.86 94.53,24.86 94.69,24.7 94.69,24.04 93.56,22.9 93.52,22.9 93.12,22.5 91.74,22.5 91.66,22.58 91.66,22.93 91.82,23.09 91.82,23.68 91.87,23.83 91.82,23.98 91.82,24.09 91.79,24.11 91.8,24.14 91.81,24.18 91.82,24.22 91.82,24.73 91.81,24.76 91.8,24.81 91.84,24.85 92.61,24.85 92.61,24.87 93.34,24.87
+3VALW on BOTTOM (solid shape): 165.72,18.49 165.72,14.44 165.87,14.29 166.23,14.29 166.27,14.25 166.27,13.86 165.95,13.55 165.94,13.53 165.94,12.85 165.65,12.56 165.41,12.56 165.39,12.59 165.39,15.63 165.3,15.71 162.33,15.71 161.92,16.12 161.92,16.83 162,16.91 162.3,16.91 162.37,16.84 162.37,16.49 162.42,16.45 163.7,16.45 164.02,16.77 164.02,17.77 163.97,17.82 162.71,17.82 162.45,18.08 162.15,18.08 162.09,18.14 162.09,18.67 162.15,18.73 162.64,18.73 163.01,18.36 163.65,18.36 163.7,18.4 163.7,18.78 163.73,18.81 165.4,18.81
+3VALW on BOTTOM (solid shape): 120.75,48.99 121.22,48.99 121.27,48.94 121.27,48.81 121.28,48.81 121.28,48.46 121.35,48.38 121.5,48.38 121.93,47.95 121.93,47.23 121.91,47.21 120.16,47.21 119.51,47.86 119.51,48.1 119.52,48.1 119.52,48.53 119.56,48.61 119.65,48.63 119.9,48.71 119.9,48.98 119.89,49.09 119.98,49.14 120.59,49.14
+3VALW on BOTTOM (solid shape): outline of 804 points within 27.77,11.56 56.88,37.58
+3VALW on IN1 (solid shape): 34.08,62.17 34.08,61.99 34.03,61.93 32.31,61.93 32.14,62.09 32.14,62.58 32.34,62.77 33.49,62.77
+3VALW on IN1 (solid shape): 194.53,11.65 194.53,11.39 193.89,10.76 193.86,10.76 193.79,10.69 192.81,10.69 192.71,10.79 192.71,11.84 192.78,11.9 194.27,11.9
+3VALW on IN1 (solid shape): 42.23,78.01 42.23,77.35 42.16,77.27 41.72,77.27 41.21,77.78 40.04,77.78 39.65,77.4 38.93,77.4 38.78,77.56 38.78,78.17 38.89,78.28 39.41,78.28 39.66,78.53 41.71,78.53
+3VALW on IN1 (solid shape): 19.13,75.94 19.13,73.73 19.09,73.65 19.01,73.63 18.61,73.3 19.01,72.98 19.09,72.96 19.13,72.88 19.13,72.48 19.09,72.4 19.01,72.38 18.61,72.06 19.01,71.73 19.09,71.71 19.13,71.64 19.13,70.67 19.09,70.66 18.89,70.45 19.05,70.22 19.06,70.17 19.07,70.13 19.05,69.96 19.13,69.81 19.13,69.79 19.13,68.9 20.19,67.84 20.19,66.73 20.06,66.6 19.17,66.6 18.04,67.73 18.04,71.87 18,71.91 18.01,71.94 17.93,72.29 17.58,72.37 17.55,72.36 17.27,72.63 17.27,73.02 17.34,73.12 17.45,73.09 18.03,73.3 17.45,73.52 17.34,73.49 17.27,73.59 17.27,76.24 17.4,76.37 18.7,76.37
+3VALW on IN2 (solid shape): 193.67,11.84 193.67,10.51 193.57,10.42 192.62,10.42 192.5,10.54 192.5,11.92 192.53,11.95 193.57,11.95
+3VALW on IN2 (solid shape): 32.4,16.66 32.4,15.8 32.35,15.79 32.08,15.56 32.14,15.21 32.16,15.15 32.06,14.86 32.16,14.56 32.14,14.5 32.08,14.15 32.35,13.92 32.4,13.91 32.4,13.42 32.14,13.16 29.85,13.16 29.69,13.33 29.69,16.6 29.94,16.85 32.21,16.85
+3VALW on IN2 (solid shape): outline of 249 points within 95.95,9.18 141.85,17.39
+3VALW on IN3 (solid shape): 24.24,76.77 24.24,76.25 23.39,75.4 17.16,75.4 17.16,76.36 17.75,76.94 21.06,76.94 21.55,77.43 23.57,77.43
+3VALW on IN3 (solid shape): 121.82,48.18 121.82,47.77 121.44,47.39 120.43,47.39 119.66,48.16 119.66,48.38 120.38,49.11 120.9,49.11
+3VALW on IN3 (solid shape): 166.09,13.28 166.09,12.72 165.84,12.46 165.84,12.44 165.66,12.26 165.04,12.26 164.92,12.38 164.92,12.85 165.45,13.38 165.99,13.38
+3VALW on IN3 (solid shape): 174.91,14.6 174.91,13.83 174.86,13.77 173.76,13.77 173.7,13.84 173.7,14.57 173.74,14.64 173.77,14.72 173.79,14.73 174.78,14.73
+3VALW on IN3 (solid shape): 194.38,20.53 194.38,19.97 193.71,19.31 192.21,19.31 192.01,19.51 192.01,20.15 192.03,20.17 192.1,20.2 192.17,20.17 192.25,20.12 192.35,20.1 192.75,20.1 193.09,20.43 193.11,20.43 193.31,20.49 193.43,20.65 193.44,20.69 194.21,20.69
+3VALW on BOTTOM: 104.05,14.39 100.79,17.65 92.62,17.65 91.87,18.41 91.87,23.85 91.89,23.87 91.89,24.03 92.5,24.64 95.86,24.64 96.14,24.92 102.57,24.92 106.27,21.21 106.27,17.94 107.98,16.24 111.58,16.24 111.66,16.19 111.67,16.09 112.35,15.03 113.02,16.09 113.03,16.19 113.12,16.24 114.31,16.24 114.65,16.57 114.65,19.31 114.76,19.42 115.31,19.42 115.41,19.32 115.41,17.74 115.6,17.56 115.6,16.54 115.35,16.29 115.35,14.97 114.93,14.55 110.61,14.55 110.45,14.39
+3VALW on VCC: 91.18,23.52 85.71,28.99 52.96,28.99 48.88,33.06 48.88,34.38 49.26,34.76 56.13,34.76 56.91,33.98 98.37,34 101.69,37.32 101.68,40.32 102.01,40.65 102.01,40.65 102.05,40.68 103.4,40.68 117.49,54.78 117.49,55.32 117.86,55.69 119.93,55.69 124.12,51.5 124.12,49.94 120.86,46.68 120.37,46.68 118.98,48.07 117.78,48.07 105.75,36.03 105.75,33.53 95.73,23.52
+3VALW on IN2: 92.05,22.67 91.54,23.17 91.54,24.02 91.54,24.02 91.54,27.19 92.05,27.7 107.13,27.7 107.24,27.59 107.24,24.29 106.52,23.58 106.41,23.5 106.33,23.39 106.3,23.35 94.21,23.35 93.71,22.85 93.47,22.85 93.29,22.67
+3VALW on IN2: 30.37,62.67 30.18,62.64 30.17,62.64 29.86,62.64 29.85,62.64 29.71,62.67 29.57,62.64 29.56,62.64 28.2,64 26.62,64 26.19,64.26 26.1,63.76 26.12,63.65 26.03,63.59 18.47,63.59 18.23,63.83 18.23,67.01 19.06,67.84 22.3,67.84 22.77,67.38 22.77,66.44 24.14,65.06 32.97,65.06 34.01,64.02 34.01,62.09 33.53,61.6 33.53,61 33.31,60.78 33.31,60.67 33.2,60.56 33.2,54.91 32.87,54.57 32.87,53.8 33.11,53.56 33.11,52.9 33,52.63 33.17,52.39 33.17,52.39 33.6,51.97 33.6,51.8 34.1,51.3 34.1,50.74 34.54,50.29 34.54,47.76 34.68,47.62 34.68,47.42 38.48,43.63 38.48,41.17 42.1,37.55 42.1,36.72 41.09,35.72 39.96,35.72 36.66,39.02 36.66,43.27 31.55,48.37 31.55,50.18 31.14,50.59 31.14,60.09 31.14,60.09 31.14,61.68 30.96,61.86 30.93,61.95 31,62.03 31.2,62.5 30.69,62.59 30.62,62.56 30.55,62.59
+3VALW_DSW on TOP (solid shape): 145.74,50.76 145.74,50.29 145.88,50.15 146.28,50.15 146.32,50.11 146.32,49.82 146.19,49.69 145.61,49.69 145.53,49.77 145.53,50.2 145.43,50.3 145.3,50.3 145.23,50.38 145.23,50.73 145.3,50.81 145.69,50.81
+3VALW_DSW on TOP (solid shape): 148,57.95 148,55.21 147.96,55.17 147.08,55.17 147,55.25 147,57.3 146.02,58.28 145.68,58.28 145.67,58.29 145.54,58.33 145.42,58.3 143.23,58.3 143.12,58.4 143.12,59.27 143.16,59.31 146.63,59.31
+3VALW_DSW on TOP (solid shape): 147.49,54.36 147.49,54.05 147.33,53.9 147.33,52.99 146.57,52.22 146.07,52.22 146.02,52.17 146.02,52.12 146.01,52.12 146.01,51.73 145.94,51.73 145.73,51.52 145.73,51.07 145.65,50.99 145.4,50.99 145.31,51.08 145.31,51.64 145.23,51.73 145.22,51.73 145.21,51.76 145.21,51.89 145.28,51.96 145.34,51.96 145.58,51.96 145.68,52.07 145.68,52.12 145.69,52.12 145.69,52.15 145.7,52.16 145.75,52.33 145.69,52.5 145.69,52.58 145.68,52.58 145.63,52.64 144.86,52.64 144.81,52.69 144.79,52.69 144.79,53.03 144.83,53.06 146.45,53.06 146.72,53.33 146.72,54.44 146.75,54.47 147.37,54.47
+3VALW_EC on IN1: 42.75,17.08 41.35,17.08 41.28,17.16 41.28,17.58 41.43,17.73 42.33,17.73 42.76,18.16 42.79,18.16 42.84,18.21 43.08,18.21 43.18,18.11 43.18,17.86 42.98,17.66 42.98,17.31
+3VALW_EC on IN2: outline of 125 points within 41.87,14.9 50.19,25.16
+3VALW_ESPI1 on TOP (solid shape): 40.41,5.94 40.41,4.92 40.31,4.82 38.47,4.82 38.07,5.22 38.07,6.59 38.39,6.91 39.44,6.91
+3VALW_PCH on TOP (solid shape): 31.78,70.92 32.23,70.92 32.31,70.84 32.31,70.47 32.07,70.23 30.62,70.23 30.58,70.28 30.58,70.99 30.62,71.03 31.66,71.03
+3VALW_PCH on TOP (solid shape): 143.5,54.57 143.5,52.5 143.23,52.23 142.63,52.23 142.42,52.44 142.42,53.24 142.9,53.72 142.9,54.59 142.93,54.62 143.46,54.62
+3VALW_PCH on TOP (solid shape): 121.03,74.92 121.03,72.08 121.38,71.72 121.41,71.61 121.48,71.52 121.48,70.21 121.38,70.11 119.98,70.11 119.52,70.57 119.52,71.03 118.4,72.15 118.4,74.92 118.72,75.25 120.69,75.25
+3VALW_PCH on TOP (solid shape): 142.73,59.63 142.73,58.09 142.47,58.09 142.39,58.13 142.37,58.21 142.34,58.38 142.21,58.48 142.01,58.68 140.87,58.68 140.77,58.78 140.77,59.71 140.88,59.82 142.54,59.82
+3VALW_PCH on TOP (solid shape): 140.33,49.81 140.72,49.81 140.76,49.77 140.76,49.47 140.8,49.43 140.95,49.43 141.16,49.21 141.16,48.85 141.18,48.83 142.02,48.83 142.02,48.83 142.67,48.83 142.73,48.77 142.73,48.66 142.55,48.47 142.55,48.07 142.81,47.81 143.14,47.81 143.22,47.73 143.22,46.88 143.21,46.88 141.98,46.88 141.78,47.08 141.78,48.03 141.5,48.32 140.58,48.32 140.33,48.56 140.33,49.44 140.31,49.47 140.05,49.47 140.01,49.52 140.01,49.79 140.03,49.81 140.33,49.81
+3VALW_PCH on TOP (solid shape): outline of 98 points within 135.88,37.26 140.78,44.77
+3VALW_PCH on BOTTOM (solid shape): 119.72,75.15 119.72,72.1 119.6,71.97 119.21,71.97 119.02,72.16 119.02,72.42 119.09,72.48 119.09,73.31 118.33,74.07 118.33,74.64 118.34,74.64 118.34,75.03 118.58,75.27 119.6,75.27
+3VALW_PCH on BOTTOM (solid shape): 122.87,43.87 122.87,41.8 122.87,41.79 122.87,41.4 122.64,41.18 120.8,41.18 120.65,41.33 120.65,42.15 120.89,42.4 120.89,42.85 121.05,43.01 122.18,43.01 122.18,43.5 122.26,43.5 122.32,43.56 122.33,43.56 122.38,43.61 122.38,43.91 122.41,43.94 122.8,43.94
+3VALW_PCH on BOTTOM (solid shape): 135.17,53.7 135.24,53.68 135.24,52.95 135.2,52.95 135.13,52.92 135.06,52.88 134.86,52.88 134.77,52.93 134.68,52.95 134.59,52.95 134.4,52.86 134.32,52.57 134.24,52.54 133.85,52.54 132.93,51.61 132.02,51.61 131.84,51.43 130.93,51.43 130.8,51.3 128.96,51.3 128.9,51.24 128,51.24 128,51.33 128,51.34 128.03,51.41 128.04,51.48 128.04,51.93 128.1,51.99 130.86,51.99 131.45,52.58 131.45,52.85 132.26,53.66 132.85,53.66 133.03,53.48 133.03,53.13 133.15,53 133.18,52.97 133.32,52.84 133.36,52.84 133.37,52.83 133.46,52.78 133.55,52.76 133.81,52.76 133.92,52.79 134.02,52.85 134.11,52.95 134.18,53.04 134.2,53.16 134.2,53.36 134.49,53.65 134.52,53.63 134.71,53.62 134.87,53.73 135.12,53.73
+3VALW_PCH on BOTTOM (solid shape): outline of 358 points within 139.86,48.45 147.36,52.79
+3VALW_PCH on IN1 (solid shape): 143.48,54.76 143.48,54.04 143.44,54 143.24,54 143.24,54 142.77,54 142.31,54.46 142.31,54.9 142.34,54.92 143.32,54.92
+3VALW_PCH on IN1 (solid shape): 143.11,49.4 143.48,49.17 143.84,49.4 144.45,49.4 144.53,49.33 144.53,48.83 144.25,48.56 143.08,48.56 143.07,48.56 142.95,48.59 142.84,48.56 142.83,48.56 142.16,48.56 142.1,48.63 142.1,49.35 142.14,49.4
+3VALW_PCH on IN2 (solid shape): outline of 169 points within 140.56,48.74 143.46,52.7
+3VALW_PCH on VCC: 120.85,40.35 118.58,42.62 118.58,43.68 124.63,49.73 124.63,51.71 120.14,56.2 117.94,56.2 117.58,56.56 117.58,56.57 117.49,56.65 117.49,77.35 117.89,77.74 117.89,77.74 118.04,77.89 118.04,78.1 117.89,78.25 117.67,78.25 117.49,78.07 117.49,80.78 119.98,80.78 120.1,80.71 120.48,80.78 122.11,80.78 122.11,65.41 122.93,64.59 134.42,64.59 135.05,63.96 135.05,61.75 130.61,57.3 130.61,49.46 121.5,40.35
+3VALW_PCH_OUT on BOTTOM (solid shape): 121.96,45.79 121.96,44.79 122.21,44.54 122.21,43.74 121.15,43.74 121.15,44.46 121.2,44.52 121.2,44.72 120.99,44.92 120.99,45.73 121.15,45.89 121.86,45.89
+3VALWP on TOP (solid shape): 23.42,17.61 23.42,17.26 23.63,17.06 28.56,17.06 28.93,16.69 28.93,15.66 28.94,15.65 29.46,15.65 29.48,15.64 29.48,15.2 29.47,15.18 28.94,15.18 28.93,15.17 28.93,14.46 28.94,14.45 29.47,14.45 29.48,14.44 29.48,14 29.46,13.98 28.94,13.98 28.93,13.97 28.93,11.43 28.83,11.33 24.3,11.33 24.09,11.42 23.88,11.33 22.08,11.33 21.94,11.47 21.94,12.35 22.04,12.46 22.61,12.46 22.76,12.61 22.76,17.53 22.95,17.72 23.31,17.72
+3VALWP on BOTTOM (solid shape): 25.74,17.8 25.74,17.63 25.6,17.36 25.74,17.1 25.74,11.62 25.55,11.44 21.91,11.44 21.76,11.58 21.76,17.75 22.02,18 25.53,18
+3VLP on BOTTOM (solid shape): 15.83,18.39 15.83,17.67 15.49,17.32 15.49,16.37 15.52,16.33 15.52,16.05 15.52,16.05 14.63,16.05 14.62,16.06 14.62,16.21 14.79,16.38 14.79,17.59 15.12,17.92 15.12,18.31 15.26,18.44 15.77,18.44
+3VLP on IN1 (solid shape): 65.11,14.84 65.11,14.56 65.04,14.49 64.37,14.49 64.17,14.55 63.97,14.49 62.59,14.49 62.42,14.67 62.42,14.87 62.57,15.03 64.92,15.03
+3VS on TOP (solid shape): 103.94,35.81 103.94,32.71 103.81,32.58 102.09,32.58 102.07,32.6 102.07,34.16 101.8,34.43 101.8,36.25 101.97,36.41 102.01,36.41 102.2,36.6 103.15,36.6
+3VS on TOP (solid shape): 121.13,46.44 121.13,45.28 121,45.15 120.84,45.15 120.68,45.31 120.68,45.69 120.45,45.91 119.72,45.91 119.65,45.98 119.22,45.98 119.15,45.92 118.79,45.92 118.7,46 118.7,46.37 118.78,46.45 120.38,46.45 120.53,46.6 120.97,46.6
+3VS on TOP (solid shape): 21.8,67.73 21.8,62.79 22.35,62.23 22.37,62.16 22.42,62.09 22.42,61.7 22.33,61.62 22.33,60.94 22.28,60.88 21.77,60.88 21.61,61.05 21.61,61.66 21.57,61.69 21.57,61.7 21.39,61.88 21.38,61.88 21.34,61.92 20.82,61.92 20.6,62.14 20.6,67.77 20.66,67.84 21.69,67.84
+3VS on TOP (solid shape): 94.89,27.43 94.89,26.86 94.79,26.7 94.84,26.51 94.84,25.97 93.95,25.08 92.95,25.08 92.75,25.28 92.75,25.98 92.62,26.1 91.94,26.1 91.89,26.16 91.89,26.99 92.24,27.34 92.24,27.7 92.38,27.84 94.48,27.84
+3VS on TOP (solid shape): 135.95,42.6 136.08,42.56 136.21,42.6 136.23,42.61 136.72,42.61 136.74,42.59 136.74,42.15 136.7,42.15 136.7,41.82 136.66,41.81 136.56,41.76 136.49,41.68 136.42,41.68 136.32,41.58 136.32,41.06 136.27,41.01 135.75,41.01 135.64,41.11 135.64,42.35 135.9,42.61 135.94,42.61
+3VS on TOP (solid shape): 136.99,56.39 136.99,56.33 137.05,56.33 137.21,56.17 139.53,56.17 139.59,56.16 139.65,56.17 140.14,56.17 140.48,56.51 140.48,57.08 140.63,57.22 140.63,57.22 140.72,57.31 141.16,57.31 141.21,57.26 141.21,55.79 140.85,55.79 140.74,55.9 140.64,55.9 140.63,55.91 140.46,55.96 140.29,55.9 140.11,55.9 139.93,55.96 139.76,55.9 139.57,55.9 139.4,55.96 139.22,55.9 138.61,55.9 138.61,55.86 137.01,55.86 135.84,57.03 135.76,57.03 135.76,57.04 135.31,57.04 135.31,57.03 134.66,57.03 134.58,57.11 134.58,57.29 134.76,57.48 135.9,57.48
+3VS on TOP (solid shape): 129.15,63.86 130.35,63.86 131.51,62.7 131.97,62.24 131.97,61.64 131.89,61.56 131.85,61.58 131.8,61.61 131.74,61.62 131.59,61.58 131.5,61.44 131.49,61.4 131.36,61.4 131.36,61.63 130.88,62.1 130.87,62.17 130.62,62.39 130.31,62.29 130.27,62.27 130.23,62.27 129.65,62.23 129.88,61.69 130.47,61.11 130.47,60.29 131.08,59.68 131.39,59.37 131.39,58.78 131.2,58.6 130.8,58.6 130.44,58.96 130.44,59.94 130.26,60.11 130.26,61.1 129.55,61.81 129.37,62.07 128.81,62.63 128.16,63.07 127.65,63.32 127.65,63.87 129.14,63.87
+3VS on TOP (solid shape): outline of 85 points within 35.02,33.82 47.33,58.35
+3VS on BOTTOM (solid shape): 120.56,60.35 120.61,60.35 121.96,59 121.96,58.98 122.63,57.29 124,56.11 124,54.72 124,54.72 124.06,54.48 124.27,54.38 124.58,54.38 124.67,54.4 124.75,54.44 125.71,54.44 125.79,54.4 125.87,54.38 126.18,54.38 126.23,54.39 126.29,54.4 126.32,54.42 126.46,54.28 126.46,53.99 126.35,53.89 126.32,53.9 126.25,53.93 126.18,53.94 125.87,53.94 125.79,53.93 125.71,53.88 124.75,53.88 124.67,53.93 124.58,53.94 124.27,53.94 124.19,53.93 124.11,53.88 123.55,53.88 123.54,53.89 123.5,53.89 123.39,54.01 123.39,54.67 122.93,55.13 122.89,55.13 122.47,55.13 121.8,55.8 121.8,56.56 121.58,56.77 120.77,56.77 117.72,59.82 116.19,59.82 116.18,59.85 115.9,60.03 115.61,59.85 115.6,59.82 115.43,59.82 115.23,60.02 115.23,60.18 115.54,60.49 117.27,60.49 118.04,61.26 119.66,61.26
+3VS on BOTTOM (solid shape): outline of 217 points within 67.37,26.16 103.65,42.26
+3VS on IN1 (solid shape): 117.52,42.51 117.52,42.51 119.27,40.76 119.27,40.49 119.06,40.27 118.66,40.27 116.69,42.25 116.69,42.69 116.78,42.78 117.25,42.78
+3VS on IN1 (solid shape): 113.5,52.05 113.5,51.27 114.92,49.84 114.92,49.55 114.72,49.35 114.72,49.35 114.58,49.22 114.09,49.22 112.62,50.68 112.62,52.09 112.81,52.28 113.26,52.28
+3VS on IN1 (solid shape): 42.61,50.96 42.61,48.56 42.48,48.43 40.68,48.43 40.59,48.52 40.59,49.92 40.86,50.19 40.86,50.57 41.11,50.83 41.81,50.83 41.87,50.89 41.87,51.16 41.93,51.21 42.36,51.21
+3VS on IN1 (solid shape): 31.41,70.32 31.41,69.84 31.64,69.61 32.43,69.61 32.52,69.51 32.52,69.16 32.4,69.04 30.1,69.04 30.03,69.11 30.03,69.73 30.05,69.85 30.03,69.97 30.03,70.36 30.12,70.46 31.26,70.46
+3VS on IN1 (solid shape): 37.07,70.8 37.07,70.53 37,70.46 36.17,70.46 35.62,71.01 35.7,71.41 35.31,71.53 35.04,71.79 35.04,72.06 35.27,72.29 35.58,72.29
+3VS on IN1 (solid shape): 24.79,75.05 24.79,74.41 24.73,74.35 24.7,74.27 24.69,74.26 24.44,74.01 24.43,74 24.33,73.94 24.26,73.85 23.14,73.85 23.13,73.89 22.85,74.09 22.56,73.89 22.55,73.85 22.27,73.85 21.85,74.28 21,74.28 20.77,74.05 20.77,72.08 20.62,71.92 20.62,70.61 20.8,70.42 20.8,68.96 21.42,68.34 21.42,67.16 21.28,67.01 20.6,67.01 20.32,67.29 20.32,67.89 19.53,68.68 19.53,69.69 19.57,69.75 19.58,69.81 19.66,69.96 19.64,70.13 19.65,70.32 19.53,70.48 19.53,74.59 20.09,75.15 24.69,75.15
+3VS on IN2 (solid shape): 103.6,37.98 103.6,35.58 103.3,35.28 103.3,35.24 102.65,34.59 102.21,34.59 101.74,35.06 101.74,37.82 102.17,38.25 103.33,38.25

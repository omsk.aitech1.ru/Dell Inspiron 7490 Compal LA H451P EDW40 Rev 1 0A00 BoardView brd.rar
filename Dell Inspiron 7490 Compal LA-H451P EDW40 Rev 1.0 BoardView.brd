# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_SENSE_GPU: length 88.4
  TOP w0.203: PRV47.2 PRV42.1 44.19,59.66 v2(44.41,59.88)
  IN1 w0.203: v4(44.19,60.26) 44.25,60.2 44.25,60.05 v2(44.41,59.88)
  IN3 w0.203: v4(44.19,60.26) 44.27,60.26 44.38,60.37 45.22,60.37 45.39,60.54 48.96,60.54 50.25,61.83 50.38,61.83 50.47,61.83 50.51,61.83 50.98,61.83 51.42,61.38 67.05,61.38 68.53,59.9 69.58,59.9 70.54,60.85 70.54,64.4 73.64,67.5 73.64,76.52 75.59,78.46 76.54,78.46 76.64,78.36 78.49,78.36 79.44,79.31 99.17,79.31 99.87,78.61 101.92,78.61 102.44,78.09 102.44,76.07 105.67,72.84 105.67,70.75 105.13,70.2 104.84,70.2 v5(104.81,70.24)
  BOTTOM w0.203: UV1.F1 105.32,70.2 104.84,70.2 v5(104.81,70.24)
VBAT_CHG: length 3.4
  BOTTOM w0.203: PCB45.1 198.98,27.05 198.67,26.74 197.67,26.74 197.31,26.38 PUB01.31
  BOTTOM w0.254: PCB45.1 PRB39.2
VCC_1.05V: length 4
  BOTTOM w0.254: PCH13.1 125.47,23.87 PRH01.1 ; PCH13.1 125.5,23.05 126.72,21.83 PUH01.17 ; PCH13.1 124.85,22.43 PRH07.2
VCC_1.8V: length 12.8
  TOP w0.254: v2(67.86,21.03) 67.86,21.2 68.76,22.09 PC1809.1 69.16,21.72 PU1801.8 ; v2(74.78,20.71) 75,20.93 v1(75,21.36) 75,22.33 74.7,22.62 PR1802.2
  IN1 w0.254: v2(74.78,20.71) 74.66,20.83 68.07,20.83 v2(67.86,21.03)
VCC_GPU1: length 2.4
  BOTTOM w0.203: PRV20.2 PCV12.1 56.27,74.94 55.79,74.46 PUV02.14
VCC_GPU2: length 2.5
  BOTTOM w0.203: PUV03.14 55.81,67.12 56.21,67.51 PCV35.1 56.21,68.62 PRV26.2
VCC_GT_SENSE: length 47.9
  IN1 w0.203: v4(166.51,26.85) 166.11,26.85 165.71,26.46 156.17,26.46 155.73,26.9 152.44,26.9 152.23,26.69 150.74,26.69 150.43,26.38 v4(150.43,26.35)
  IN3 w0.203: v5(182.32,33.08) 182.16,33.24 181.88,33.24 180.23,31.59 178.29,31.59 177.97,31.26 170.3,31.26 167.6,28.56 167.6,27.95 v4(166.51,26.85) ; v4(150.43,26.35) v5(150.43,26.82)
  BOTTOM w0.076: v5(182.32,33.08) 182.32,32.86 181.79,32.32 v1(181.53,32.32)
  BOTTOM w0.089: UC1.E3 177.04,36.1 176.7,35.75 176.7,34.98 178.48,33.2 179.15,33.2
  BOTTOM w0.203: PRZ41.1 151.92,27.96 150.95,26.99 150.6,26.99 v5(150.43,26.82) ; 179.15,33.2 182.21,33.2 v5(182.32,33.08)
VCC_SA: length 2
  BOTTOM w0.203: PRA01.1 PCA08.1 141.13,20.39 141.2,20.32 141.53,20.32 141.6,20.29 141.6,20.29 141.89,20.29 PUA01.14
VCCDPHY_1P24: length 2.3
  TOP w0.081: v1(141.52,50.89) 141.23,50.6 v2(141.23,49.87)
  TOP w0.254: v2(141.23,49.87) 141.23,49.59 141.49,49.33 CC58.1
  IN3 w0.254: v4(135.42,50.78) v5(135.05,50.78)
VCCDSW_EN: length 136.4
  TOP w0.081: v2(52.06,23.85) 52.06,23.85 52.21,23.99 53.32,23.99 53.54,23.77 53.64,23.77 RE58.2 53.86,23.54 53.86,23.51 54.35,23.02 54.35,22.51 54.81,22.05 55.86,22.05 v2(55.93,22.12) ; v2(67.37,12.77) 67.4,12.8 67.4,14.36 v1(66.81,14.95) 66.81,17.45 PR1809.2
  IN1 w0.064: v4(57.54,23.38) 57.39,23.38 56.78,22.77 56.52,22.77 55.93,22.17 v2(55.93,22.12) ; v4(65.08,12.59) 65.22,12.73 67.33,12.73 v2(67.37,12.77) 71.39,12.77 72.57,11.58 74.34,11.58 74.54,11.79 74.87,11.79 74.89,11.8 83.18,11.8 83.32,11.66 83.9,11.66 83.97,11.58 84.99,11.58 85.6,10.97 90.83,10.97 93,13.14 93,14.39 93.81,15.2 98.68,15.2 99.04,15.56 105.19,15.56 107.91,18.28 107.91,19.08 108.61,19.78 112.93,19.78 113.61,19.1 113.7,19.1 115.35,20.76 115.35,21.67 115.09,21.94 115.09,22.49 115.22,22.62 116.47,22.62 116.55,22.7 116.59,22.7 118.52,24.62 118.52,25.87 119.21,26.57 121.35,26.57 122.08,25.84 124.07,25.84 v6(124.36,26.13) ; v2(50.58,24.43) 50.68,24.43 51.17,23.94 51.99,23.94 52.06,23.88 v2(52.06,23.85)
  IN2 w0.066: v4(65.08,12.59) 63.57,12.59 62.34,13.82 62.34,15.29 60.7,16.93 59.71,16.93 57.74,18.91 57.74,22.9 57.54,23.1 v4(57.54,23.38)
  BOTTOM w0.081: DZ2.2 121.62,50.32 122,49.94 122,49.55 RZ4.1 122.36,49.49 122.36,49.62 122.57,49.82 123.05,49.82 124.92,47.95 124.92,47.38 126.84,45.46 127.24,45.46 127.46,45.24 127.46,43.95 126.94,43.43 126.37,43.43 124.24,41.3 124.24,40.69 123.96,40.41 123.96,35.6 124.14,35.42 124.14,28.57 124.54,28.17 124.54,26.31 v6(124.36,26.13)
  BOTTOM w0.254: PRH08.1 123.93,22.18 123.93,25.69 v6(124.36,26.13)
VCCDSW_EN_UZ4: length 2.3
  BOTTOM w0.081: 122.29,48.76 RZ1419.2 ; 122.29,48.76 122.29,48.25 122.27,48.23 UZ4.3 ; 122.29,48.76 RZ4.2 CZ20.1
VCCGT_B+: length 1.1
  TOP w0.081: PCG05.1 203.72,37.81 v1(203.44,37.53)
  vias: v6(205.32,37.17)
VCCIO_EN: length 3.3
  TOP w0.081: v1(111.21,29.94) 111.29,29.86 111.29,29.11 ; 111.29,29.11 UC18.4 ; 111.29,29.11 112.03,29.11 UZ2.4
VCCSA_B+:
  vias: v3(143.97,16.41) v6(142.3,17.15) v6(143.65,16.87)
VCCSENSE: length 24.8
  IN2 w0.203: v4(150.18,28.09) 149.69,27.6 149.69,24.75 150.34,24.09 v4(150.43,24.09)
  IN3 w0.203: v5(150.29,28.57) 150.22,28.49 150.22,28.13 v4(150.18,28.09) ; v4(150.43,24.09) v5(150.43,23.63)
  BOTTOM w0.089: UC1.AN6 159.25,38.56 159.25,38.27 159.74,37.78 159.74,36.33
  BOTTOM w0.203: 159.74,36.33 159.74,33.77 RC167.2 160.17,33.63 160.25,33.54 160.25,32.52 159.89,32.15 158.35,32.15 157.99,31.79 v1(154.17,31.79) 154.17,31.79 152.56,30.18 151.2,30.18 150.29,29.27 v5(150.29,28.57)
VCCST_PWRGD: length 37.4
  IN1 w0.064: v4(131.69,15.76) 131.58,15.87 v2(130.33,15.87)
  IN2 w0.066: v4(150,32.74) 149.97,32.74 149.01,31.77 147.06,31.77 143.79,28.5 141.47,28.5 140.87,27.9 140.87,27.55 140.87,21.96 140.87,21.96 140.87,18.42 140.14,17.68 134.57,17.68 133.44,16.55 133.44,16.04 133.19,15.8 131.72,15.8 v4(131.69,15.76)
  IN3 w0.064: v4(150,32.74) v5(150,32.4)
  BOTTOM w0.081: v1(149.21,32.4) 149.99,32.4 v5(150,32.4) 150,32.39 151.95,32.39 152.16,32.61 CC119.1 152.14,32.9 151.61,32.9 RC554.2 151.59,33.32 RC99.1
VCCST_PWRGD_CPU: length 6.1
  TOP w0.081: v2(150.48,34.81) v3(150.48,34.36)
  IN1 w0.064: v4(149.94,36.65) 149.94,35.36 v2(150.48,34.81)
  IN3 w0.064: v5(150.29,36.33) 150.26,36.33 v4(149.94,36.65)
  BOTTOM w0.091: RC99.2 151.53,34.15 151.14,34.53 151.14,34.96 150.58,35.52 150.58,36.04 v5(150.29,36.33)
VCCSTG_IO_EN: length 76.8
  TOP w0.081: RZ10.1 149.38,61.06 148.62,60.3 v1(148.62,56.96) 148.62,56.31 148.44,56.14 v2(148.44,55.6) 148.44,55.23 148.19,54.98 145.83,54.98 145.59,55.22 144.07,55.22 143.9,55.39 143.39,55.39 143.39,55.4 141.71,55.4 141.45,55.14 141.45,54.01 140.59,53.14 139.88,53.14 139.66,53.36 139.66,53.88 139.19,54.36 138.36,54.36 138.13,54.13 138.13,53.78 137.44,53.09 136.75,53.09 136.39,52.72 UC9.4
  IN1 w0.064: v4(148.25,54.93) 148.25,55.42 v2(148.44,55.6)
  IN2 w0.066: v4(145.07,51.18) 145.06,51.19 144.97,51.19 144.1,50.33 144.1,49.82 143.34,49.06 142.88,49.06 141.16,47.34 141.16,46.74 140.22,45.8 137.01,45.8 135.73,44.53 135.26,44.53 133.95,43.22 133.89,43.22 131.9,41.23 131.9,40.74 130.56,39.39 130.56,38.04 130.55,38.04 130.55,37.52 131.95,36.12 131.95,34.21 131.68,33.94 131.47,33.94 v4(130.26,32.73)
  IN3 w0.064: v4(130.26,32.73) 130.51,32.98 136.43,32.98 137.76,31.65 138.74,31.65 v5(138.84,31.55) ; v4(148.25,54.93) 148.25,54.67 147.28,53.7 147.28,53.25 147.02,52.99 146.84,52.99 146.68,52.83 146.57,52.83 146.13,52.39 145.83,52.39 145.21,51.77 145.21,51.35 145.07,51.21 v4(145.07,51.18)
  BOTTOM w0.081: RZ2.2 140.94,27.73 140.61,27.4 140.11,27.4 139.73,27.78 139.73,29.55 139.28,30 139.28,31.14 138.87,31.55 v5(138.84,31.55)
  BOTTOM w0.089: UZ1.3 143,29.09 142.71,28.79 142.42,28.79 CZ4.1 142.21,28.31 142.11,28.21 141.37,28.21 140.96,27.8 RZ2.2
VCCSTG_IO_EN_UZ7:
  vias: v1(152.4,61.38)
VDD12_GPU: length 2
  TOP w0.254: PCV47.1 40.19,60.79 39.71,61.27 PUV01.7
VDD_CHG: length 16.2
  IN2 w0.254: v4(193.14,20.74) 193.14,20.61 194.39,19.36 201.01,19.36 v4(201.03,19.38)
  IN3 w0.254: v4(193.14,20.74) 193.03,20.74 192.65,20.35 v5(192.35,20.35) 192.35,20.84 191.38,21.81 v5(191.38,22.25) ; v5(201.03,19.96) v4(201.03,19.38)
  BOTTOM w0.203: PCB28.1 192.86,21.19 193.34,21.67 193.34,22.5 193.7,22.87 PUB01.18
  BOTTOM w0.254: PCB28.1 192.35,21.13 v5(192.35,20.35)
VDD_SENSE_GPU: length 88.6
  TOP w0.203: v2(44.25,61.82) PRV44.2
  IN1 w0.203: v2(44.25,61.82) 44.01,61.58 44.01,61.29 v4(44.25,61.05)
  IN3 w0.203: v4(44.25,61.05) 44.6,60.7 45.09,60.7 45.25,60.87 48.82,60.87 50.15,62.19 51.08,62.19 51.56,61.71 67.19,61.71 68.67,60.23 69.45,60.23 70.21,60.99 70.21,64.54 73.31,67.64 73.31,76.65 75.45,78.79 76.68,78.79 76.78,78.69 78.35,78.69 79.3,79.64 99.3,79.64 100.01,78.94 102.06,78.94 102.77,78.23 102.77,76.21 106,72.97 106,70.61 105.21,69.82 v5(105.21,69.67)
  BOTTOM w0.203: v5(105.21,69.67) 105.2,69.68 UV1.F2
VINSEN_GPU: length 3.2
  TOP w0.254: PUV01.12 42.88,63.26 42.96,63.34 PRV34.1 43.34,63.66 43.5,63.83 PRV32.1 43.5,64.26 43.34,64.43 PCV42.1
VSS_GT_SENSE: length 45.5
  IN1 w0.203: v4(150.43,27.28) 150.47,27.32 151.5,27.32 151.59,27.23 155.87,27.23 156.3,26.79 165.55,26.79 v4(166.38,27.62)
  IN3 w0.203: v5(150.43,27.64) v4(150.43,27.28) ; v4(166.38,27.62) 167.03,28.27 167.03,28.54 170.08,31.59 177.83,31.59 178.22,31.98 180.07,31.98 182.32,34.23 v5(182.32,34.3)
  BOTTOM w0.089: 177.65,34.97 177.38,35.24 177.38,36.21 UC1.D2
  BOTTOM w0.203: v5(182.32,34.3) 181.86,34.76 177.87,34.76 177.65,34.97 ; v5(150.43,27.64) 150.46,27.64 150.55,27.56 150.85,27.56 v1(150.93,27.64) 151.8,28.51 152.52,28.51 152.83,28.2 PRZ40.1
VSSSENSE: length 23.7
  IN2 w0.203: v4(150.71,28.01) 150.91,27.8 150.91,25.61 150.54,25.24 v4(150.37,25.24)
  IN3 w0.203: v5(150.61,28.33) 150.68,28.26 150.68,28.04 v4(150.71,28.01) ; v5(150.37,24.6) v4(150.37,25.24)
  BOTTOM w0.102: 160.62,35.98 160.39,36.22 160.39,36.43 160.3,36.52 160.3,36.78 160.39,36.87 160.39,37.06 160.29,37.16 160.29,37.41 160.39,37.51 160.39,38.03 160.03,38.38 UC1.AN5
  BOTTOM w0.203: 160.62,35.98 160.62,34.7 161.21,34.11 RC168.1 160.8,33.63 160.59,33.42 160.59,32.39 160.02,31.82 158.53,31.82 v1(158.14,31.44) 154.34,31.44 152.73,29.83 151.33,29.83 150.61,29.11 v5(150.61,28.33)
2.7MM_CAM_DET#: length 167
  TOP w0.081: v2(143.52,55.69) 142.05,55.69 141.55,56.19 RC563.1 141.45,55.59 v1(141.24,55.38)
  IN1 w0.064: v2(143.52,55.69) 143.8,55.41 143.8,55.18 v4(144.13,54.85)
  IN2 w0.066: v4(33.38,74.84) 33.38,74.87 34.07,75.56 39.96,75.56 43.72,71.81 43.72,68.42 46.45,65.69 46.45,63.22 46.81,62.86 46.81,58.76 47.44,58.14 47.44,54.33 48.9,52.87 48.9,51.55 49.32,51.13 49.32,47.89 51.78,45.43 52.39,45.43 52.83,45.87 60.78,45.87 61.08,45.57 61.16,45.57 64.26,42.47 64.26,41.23 67.37,38.11 69.01,38.11 71.57,35.55 72.85,35.55 73.92,35.55 74.94,34.53 75.3,34.53 76.76,33.07 76.76,32.92 78.37,31.31 80.33,31.31 81.06,32.04 100.43,32.04 101.01,31.46 110.47,31.46 111.64,32.64 112.7,32.64 112.73,32.61 114.77,32.61 118.74,36.59 118.74,40.3 120.42,41.98 121.08,41.98 122.92,43.82 122.92,44.48 125.44,46.99 125.44,49.69 125.78,50.03 127.74,50.03 128.2,49.57 129.56,49.57 131.99,51.99 131.99,54.36 133.79,56.16 136.86,56.16 137.58,55.45 138.3,55.45 139.07,56.22 139.88,56.22 140.54,55.55 141.88,55.55 142.23,55.21 142.23,55.18 142.47,54.94 144.05,54.94 v4(144.13,54.85)
  IN3 w0.064: v4(144.13,54.85) 143.98,54.85 v5(143.76,54.64) ; v4(33.38,74.84) 33.47,74.75 33.47,72.96 v5(33.55,72.87)
  BOTTOM w0.081: JEDP1.19 v5(33.55,72.87) ; UC1.BY31 143.68,54.67 143.71,54.64 v5(143.76,54.64)
3MM_CAM_DET#: length 141
  IN2 w0.066: v4(33.95,74.77) 34.53,75.34 39.91,75.34 43.53,71.73 43.53,68.34 46.25,65.61 46.25,63.14 46.62,62.78 46.62,58.55 47.25,57.93 47.25,54.25 48.6,52.9 48.6,48 49.75,46.84 49.99,46.84 51.65,45.18 52.41,45.18 52.91,45.67 59.82,45.67 63.94,41.55 63.94,41.26 67.35,37.85 69,37.85 71.49,35.36 72.77,35.36 76.18,31.96 77.37,31.96 78.2,31.12 80.41,31.12 81.14,31.85 100.35,31.85 100.93,31.27 110.55,31.27 111.59,32.31 114.74,32.31 119.08,36.65 119.08,39.73 120.07,40.73 v4(120.23,40.73)
  IN3 w0.064: v5(33.95,73.2) v4(33.95,74.77) ; v5(129.11,42.03) 126.26,42.03 124.99,40.76 124.32,40.76 124.07,41.01 120.51,41.01 v4(120.23,40.73)
  BOTTOM w0.081: JEDP1.18 v5(33.95,73.2) ; v5(129.11,42.03) v1(129.6,42.03) 129.72,41.91 131.4,41.91 131.73,42.23 132.11,42.23 132.63,42.75 RC564.2 133.17,42.98 133.54,42.61 UC1.CR12
+CHARGER_SRC:
  vias: v1(189.06,14.06) v2(189.7,14.15) v2(189.7,13.77) v2(189.7,13.39) v2(190.08,14.15) v2(190.08,13.77) v2(190.08,13.39) v2(190.06,12.96) v2(190.06,12.57) v2(190.05,11.79) v2(190.46,14.15) v2(190.46,13.77) v2(190.46,13.39) v4(191.43,14.44) v4(191.48,13.93) v4(191.48,13.43) v4(191.48,12.92) v4(191.48,12.41) v4(191.45,11.85) v4(191.45,11.34) v4(191.45,10.83) v4(191.99,12.48) v4(192,11.9) v4(191.99,11.39) v4(191.99,10.89) v5(192,14.58) v5(192,14.14) v5(192.02,13.42) v5(192.02,12.92) v5(192.47,12.51) v5(192.84,12.5) v5(193,14.59) v5(192.95,13.45) v5(192.97,12.95) v5(193.02,14.18) v5(193.31,12.53) v5(193.35,12.06)
+DCBAT_LCD:
  vias: v3(39.78,69.26) v3(40.53,72.52) v3(42.48,72.58) v6(41.21,72.22) v6(41.85,72.17)
+DCBAT_LCD_DV13_R: length 9.4
  TOP w0.081: v2(33.31,72.6) 32.85,72.6 QV18.2
  IN1 w0.064: v2(36.78,77.71) 36.3,78.19 35.17,78.19 32.6,75.62 32.6,73.03 33.04,72.6 v2(33.31,72.6)
+DCIN_JACK:
  vias: v3(79.84,11.91) v3(81.56,11.84) v3(83.32,11.9)
+DTH_VDD12: length 0.4
  IN1 w0.064: v2(19.89,39.4) 20.04,39.4 v4(20.19,39.26)
  vias: v2(21.32,45.74) v2(21.32,45.38) v4(19.36,41.81) v4(19.36,41.28) v4(21.31,45.01) v5(19.67,40.81) v5(19.67,40.33) v5(19.71,42.07) v5(19.71,41.46)
+DTH_VDD33: length 2.5
  TOP w0.081: v2(21.72,45.74) 21.72,45.95 21.42,46.25 20.51,46.25 v1(20.15,46.6)
  IN1 w0.064: v2(23.32,38.45) 23.24,38.53 v4(23.24,38.83)
  vias: v2(21.72,45.38) v4(22.19,45.25) v5(22.49,42.98) v5(22.89,45.14) v5(22.91,44.58) v5(23.03,42.98) v5(24.88,44.3) v5(24.88,43.74) v5(24.91,43.18)
+DTH_VDDA12: length 1.2
  TOP w0.081: v1(18.81,45) 19.2,44.61 v2(19.87,44.61)
  vias: v2(20.21,44.61) v4(19.19,43.49) v5(17.27,43.24) v5(17.86,43.45)
+DTH_VDDRX12:
  vias: v2(26.79,44.6) v2(26.72,39.81) v2(27.18,39.8) v2(27.27,44.6) v4(22.4,39.87) v4(22.98,39.87) v4(25.54,43.88) v4(25.61,39.94) v5(21.86,40.22) v5(22.42,40.22) v5(22.98,40.22)
+DTH_VDDTX12: length 3
  TOP w0.081: v1(18.43,46.23) 18.92,45.74 v2(20.92,45.74)
  IN1 w0.064: v2(19.89,39.8) v4(20.24,39.8)
  vias: v2(20.92,45.38) v4(18.75,41.93) v4(18.75,41.38) v4(20.03,45.25) v5(18.21,42.04) v5(18.21,41.43) v5(18.63,40.82) v5(18.63,40.28)
+FB_PLLAVDD: length 4.1
  BOTTOM w0.254: UV1.H22 94.24,56.98 94.65,57.39 96.17,57.39 v6(96.22,57.44) ; UV1.F16 96.61,61.54 v6(97.14,61.54)
  BOTTOM w0.3: 97.75,53.78 v6(98.27,54.3)
  BOTTOM w0.305: 97.75,53.3 97.75,53.78
  vias: v1(95.96,58.02)
+FBA_VREFC0: length 75.6
  TOP w0.381: 95.28,65.11 95.28,65.75 95.57,66.04 RV127.1 95.57,66.86 95.28,67.14 95.28,67.2
  TOP w0.406: v2(94.36,74.88) v3(95.43,74.88) 95.43,74.16 95.67,73.92 96.43,73.92 96.98,73.37 96.98,72.26 97.59,71.65 97.59,70.24 95.28,67.93 95.28,67.2 95.28,67.2 ; UV8.J14 82.71,38.48 82.26,38.04 80.45,38.04 CV741.1 79.97,37.56 CV754.1 79.58,37.95 v2(79.94,38.31) ; 92.47,65.72 91.74,66.45 UV6.J14
  IN1 w0.508: v2(79.94,38.31) v4(79.37,38.87) ; v4(93.71,75.4) 94.23,74.88 v2(94.36,74.88)
  IN3 w0.508: v4(79.37,38.87) 79.74,39.24 79.74,40.06 77.57,42.22 77.57,45.93 82.78,51.13 82.78,60.36 78.77,64.37 78.77,70.46 85.35,77.04 88.62,77.04 89.07,76.59 92.51,76.59 v4(93.71,75.4)
+GPU_CORE: length 51.5
  TOP w0.254: PRV33.1 43.34,61.62 43.75,61.21 44.25,61.21 45.77,59.69 47.36,59.69 49.57,57.47 51.66,57.47 53.85,59.66 56.41,59.66 59.65,62.91 63.08,62.91
  BOTTOM w0.254: v6(103.91,54.42) 103.87,54.46 v4(103.87,55.18) v6(103.87,55.97) v5(103.87,56.6) v6(103.87,57.29) v5(103.87,58.01) v6(103.87,58.74) v5(103.87,59.42) v6(103.87,60.14) UV1.N11 v5(103.88,60.84) v6(103.88,61.54) 103.87,61.55 UV1.M10 ; v5(99.63,56.6) v6(99.63,57.44) v5(99.63,58.01) v6(99.63,58.79) v5(99.63,59.42) 99.63,60.1 v6(99.64,60.11) 99.63,60.11 v5(99.63,60.84) ; v5(102.46,58.01) v6(102.46,58.66) v5(102.46,59.42) v6(102.46,60.17) v5(102.46,60.84) v6(102.46,61.54) v5(102.46,62.25) UV1.K10 ; v5(98.22,56.6) v6(98.93,56.6) ; v6(105.29,58.76) v5(105.29,59.42) v6(105.29,60.13) UV1.P10 ; v5(102.46,52.35) v6(102.46,52.9) v5(102.46,53.77) v6(102.46,54.48) v5(102.46,55.18) ; UV1.V14 v6(105.29,55.92) UV1.U13 ; v5(106.7,58.01) v6(106.7,57.33) ; v5(108.12,58.01) v6(108.12,58.63) ; v5(98.22,59.42) v6(98.22,58.6)
  BOTTOM w0.381: v6(102.46,55.86) UV1.R15
  vias: v2(102.91,55.01) v2(103.47,55.04) v2(104.5,55.06) v2(104.93,55.07) v2(105.68,54.97) v2(106.17,54.96) v2(106.97,54.35) v2(108.17,63.36) v2(109.06,67.42) v2(109.06,66.92) v2(109.08,66.21) v2(109.08,65.71) v2(109.05,65.01) v2(109.05,64.5) v2(109.06,63.78) v2(109.06,63.28) v2(112.77,66.3) v2(112.77,65.8) v2(112.78,65.07) v2(112.78,64.57) v2(112.79,63.93) v2(112.79,63.43) v2(113.68,67.08) v2(113.71,66.34) v2(113.71,65.84) v2(113.76,65.16) v2(113.76,64.66) v2(113.77,63.97) v2(113.77,63.47) v3(66.32,64.23) v4(104.67,55.49) v4(105.91,54.58) v4(106.34,55.45) v4(106.99,55.61) v4(106.93,54.88) v4(108.33,63.88) v4(108.36,62.97) v4(108.43,64.72) v4(108.53,66.15) v4(109.14,70.39) v4(109.41,69.89) v4(109.49,63.85) v4(109.5,64.67) v4(109.5,63.19) v4(109.75,69.36) v4(111.06,68.4) v4(112.23,67.33) v4(112.38,64.82) v4(112.43,63.67) v4(112.57,66.72) v4(113.18,66.25) v4(113.29,64.51) v4(113.37,63.67) v4(113.71,62.19) v4(113.85,65.53) v4(114.11,62.85) v4(114.38,65.01) v5(97.18,57.64) v5(97.67,59.23) v5(97.81,58.33) v5(98.39,59.89) v5(99.27,56.96) v5(99.28,56.25) v5(99.63,55.18) v5(99.9,61.26) v5(100.03,60.53) v5(100.03,58.34) v5(100.04,57.81) v5(100.03,56.9) v5(100.34,60.88) v5(100.37,58.02) v5(100.32,56.58) v5(100.38,55.18) v5(100.67,60.54) v5(100.67,56.84) v5(100.68,56.31) v5(100.72,61.2) v5(100.79,59.83) v5(100.76,55.58) v5(100.81,58.42) v5(101.05,62.25) v5(101.03,61.51) v5(101.05,60.84) v5(101.05,60.16) v5(101.05,59.42) v5(101.05,58.83) v5(101.05,58.01) v5(101.05,56.6) v5(101.05,55.92) v5(101.05,55.18) v5(101.07,54.48) v5(101.05,53.77) v5(101.31,59.82) v5(101.36,55.66) v5(101.77,62.22) v5(102.08,54.93) v5(102.89,56.3) v5(103.46,56.34) v5(103.43,53.45) v5(103.51,57.64) v5(104.33,54.94) v5(104.31,54.09) v5(104.66,54.95) v5(104.92,58.3) v5(105.29,58.01) v5(105.34,54.67) v5(105.58,58.36) v5(105.64,55.48) v5(105.87,55.1) v5(106.4,56.96) v5(106.7,56.6) v5(107.04,56.92) v5(107.11,58.25) v5(107.6,56.8) v5(107.69,58.28) v5(108.11,57.57) v5(108.47,57.27) v5(108.64,57.59) v5(108.73,58.62) v5(108.75,58.23) v5(109,57.86) v5(109.35,58.61) v5(109.34,58.11) v5(109.43,70.77) v5(109.74,70.47) v5(110.27,69.92) v5(110.6,69.6) v5(111.11,69.08) v5(111.43,68.78) v5(111.96,68.24) v5(112.31,67.91) v5(112.79,67.38) v5(113.14,67.09) v5(113.61,66.56) v5(113.99,66.25) v5(114.52,65.69) v5(114.85,65.38) v6(62.64,76.13) v6(62.64,75.49) v6(63.23,76.14) v6(63.23,75.5) v6(63.84,76.16) v6(63.84,75.53) v6(63.82,71.08) v6(63.82,70.44) v6(63.92,66.66) v6(63.92,66.02) v6(63.92,65.39) v6(63.92,64.75) v6(63.94,64.06) v6(63.94,63.42) v6(64.48,76.16) v6(64.48,75.53) v6(64.49,71.12) v6(64.49,70.48) v6(64.62,66.62) v6(64.62,65.99) v6(64.62,65.35) v6(64.62,64.72) v6(64.62,64.08) v6(64.6,63.46) v6(65.11,76.16) v6(65.11,75.53) v6(65.29,70.97) v6(65.3,70.37) v6(65.75,76.16) v6(65.75,75.53) v6(65.93,70.93) v6(65.94,70.37) v6(65.94,69.81) v6(65.94,69.24) v6(65.94,68.68) v6(65.94,68.1) v6(65.94,67.4) v6(66.38,76.16) v6(66.38,75.53) v6(66.57,70.38) v6(66.57,69.82) v6(66.57,69.26) v6(66.57,68.7) v6(66.57,68.1) v6(66.57,67.46) v6(66.6,70.94) v6(67.02,76.16) v6(67.02,75.53) v6(67.09,70.58) v6(67.13,69.81) v6(67.14,68.99) v6(67.13,68.15) v6(67.14,67.34) v6(67.55,70.96) v6(67.55,70.19) v6(67.53,69.42) v6(67.53,68.54) v6(67.54,67.77) v6(67.64,76.16) v6(67.64,75.53) v6(97.48,58.01) v6(98.91,59.45) v6(101.58,55.18) v6(101.74,59.43) v6(103.17,60.85) v6(103.18,58.01) v6(103.16,56.72) v6(104.25,66.18) v6(104.54,58.01) v6(104.61,60.87) v6(104.79,65.62) v6(104.79,62.2) v6(105.32,68.49) v6(105.87,62.11) v6(105.98,67.88) v6(106.02,61.18) v6(106.02,58.1) v6(106.06,56.62) v6(106.54,71.97) v6(106.55,55.99) v6(106.63,61.66) v6(106.71,60.51) v6(106.75,58.65) v6(107.12,66.82) v6(107.15,60.91) v6(107.24,59.87) v6(107.23,56.47) v6(107.3,71.97) v6(107.73,68.62) v6(107.71,66.16) v6(107.73,65.01) v6(107.76,61.53) v6(107.96,69.31) v6(107.93,60.33) v6(107.96,57.1) v6(108,69.95) v6(108.28,71.32) v6(108.27,65.6) v6(108.34,71.99) v6(108.32,66.8) v6(108.34,62.17) v6(108.34,60.97) v6(108.59,70.11) v6(108.52,68.7) v6(108.65,59.31) v6(108.93,69.43) v6(108.93,62.75) v6(108.93,61.53) v6(109.19,68.76) v6(109.22,68.1) v6(109.51,62.18) v6(109.78,66.62) v6(109.77,65.69) v6(109.91,68.64) v6(110.05,62.7) v6(110.13,61.56) v6(110.49,68.46) v6(110.66,62.09) v6(111.21,62.68) v6(111.24,61.51) v6(111.82,62.12) v6(112.09,65.41) v6(112.11,64.2) v6(112.41,62.65) v6(112.84,71.61) v6(112.9,62.07) v6(112.99,70.98) v6(113.48,62.86) v6(113.58,71.81) v6(115.63,71.97)
+GPU_PLLVDD: length 8.9
  TOP w0.127: v6(106.03,63.31) 106.03,62.74 v3(106.43,62.35)
  IN3 w0.254: v6(104.86,64.47) 103.97,65.37 101.56,65.37 100.98,64.78 100.24,64.78 v5(99.93,64.47)
  BOTTOM w0.254: v6(105.43,63.88) UV1.M6 ; UV1.F11 v5(99.93,64.47) ; UV1.N6 v6(106.03,63.31) ; UV1.L6 v6(104.86,64.47)
+IR_B+: length 1.8
  TOP w0.081: v3(41.44,69.33) 41.44,69.55 F2.2
  vias: v2(41.89,71.34) v2(42.04,71.68) v2(42.43,71.41) v4(40.48,73.3) v4(40.79,72.94) v5(39.98,73.67) v5(39.97,73.33) v5(39.95,72.99)
+LCDVDD:
  vias: v2(36.81,69.46) v2(36.8,69.13) v2(36.97,68.75) v2(37.25,69.43) v2(37.25,69.03) v2(42.65,55.88) v2(42.93,55.88) v4(37.3,60.43) v4(37.57,68.69) v4(37.67,69.22) v4(37.76,60.42) v4(42.8,56.3) v4(43.23,56.31)
+LCDVDD_LCD: length 2.7
  TOP w0.254: v3(36.18,71.31) 36.18,71.86 36.63,72.3
  BOTTOM w0.203: JEDP1.6 38.75,72.81 v6(38.93,72.99) 39.15,72.77 JEDP1.5
  vias: v3(37,72.86) v3(38.7,72.42) v6(38.32,73.01)
+LCDVDD_LCD_DV14_R: length 7.9
  TOP w0.081: QV18.5 34.33,72.64 v2(34.28,72.59)
  IN1 w0.064: v2(34.28,72.59) 34.05,72.81 33.63,72.81 33.54,72.9 33.2,72.9 32.79,73.31 32.79,75.24 35.25,77.7 35.44,77.7 v2(35.46,77.71)
+MIC_VCC: length 2.2
  TOP w0.127: F6.2 29.71,73.34 v1(29.49,73.56)
  BOTTOM w0.203: JEDP1.23 31.95,72.62 31.47,73.11 v6(31.44,73.11)
+PEX_IOVDDQ:
  vias: v1(109.63,51.97) v6(104.66,52.44) v6(104.84,51.51) v6(104.92,52.98) v6(105.17,52.06)
+PEX_PLL_HVDD: length 1.5
  BOTTOM w0.254: UV1.AA8 v6(110.07,58.1) ; UV1.AA9 v6(109.52,57.55)
  vias: v1(111.68,57.41)
+PWR_SRC_AC: length 0.8
  TOP w0.081: 183.73,13.68 v1(182.91,13.68)
+RTC_CELL: length 208.6
  TOP w0.254: RE553.2 v6(33.43,17.53)
  TOP w0.305: v2(194.65,7.52) 194.88,7.75 JIO1.1
  TOP w0.381: RE31.2 38.17,20.94 v2(37.85,20.62) 37.75,20.52 37.75,20.09 RE20.1 37.7,19.6 37.96,19.35 RE6.1 38.46,19.23 38.39,19.17 RE546.1 37.66,18.68
  TOP w0.508: 59.58,19.28 60.77,19.28 62.06,20.57 62.06,22.8 Q17.3 ; v2(88.43,13.39) 88.43,12.64 87.38,11.58 v2(87.38,7.2) ; 37.66,18.68 37.55,18.79 36.76,18.79 36.52,18.54 35.7,18.54 33.79,16.63 33.79,12.96 v6(33.34,12.51)
  IN1 w0.254: v6(33.43,17.53) 33.93,17.02 33.93,13.68 33.91,13.66 33.91,13.65 33.34,13.08 v6(33.34,12.51)
  IN1 w0.508: v2(87.38,7.2) 87.44,7.27 v4(87.78,7.27) ; v2(194.65,7.52) 192.94,7.52 v4(192.81,7.65) ; v4(125.63,7.27) v4(124.1,7.27) ; v2(88.43,13.39) v4(87.85,13.39) ; v4(45.95,22.86) 45.95,22.55 46.37,22.14 48.02,22.14 48.91,21.25 50.01,21.25 50.66,20.6 50.84,20.6 51.22,20.22 54.94,20.22 55.17,19.99 57,19.99 ; v2(37.85,20.62) 37.92,20.62 37.99,20.56 39.43,20.56 v4(39.44,20.57) ; 62.72,19.33 63.98,18.07 66.25,18.07 67.46,16.86 68.84,16.86 69.49,16.21 82.99,16.21 83.81,15.4 85.24,15.4 v4(85.31,15.33)
  IN2 w0.508: v4(87.78,7.27) 88.34,6.71 95.4,6.71 96.96,8.27 110.31,8.27 111.21,9.17 122.21,9.17 124.1,7.28 v4(124.1,7.27) ; v4(39.44,20.57) 41.15,20.57 43.44,22.86 v4(45.95,22.86) ; v4(125.63,7.27) 125.63,8.15 126.96,9.48 134.3,9.48 136.54,11.72 138.24,11.72 138.34,11.62 159.01,11.62 164.44,6.19 165.25,6.19 165.95,6.89 174.39,6.89 175.29,6 189.13,6 189.76,6.63 191.8,6.63 v4(192.81,7.65) ; v4(87.85,13.39) 87.69,13.39 87.08,14 87.08,14.44 86.39,15.14 85.5,15.14 v4(85.31,15.33)
  BOTTOM w0.508: v6(33.34,12.51) 33.34,11.41 30.65,8.72 26.84,8.72 25.85,7.72
  vias: v2(58.01,19.64) v2(58.09,19.3) v3(58.93,19.18)
+RTC_CELL_VBAT: length 2.7
  TOP w0.254: RE6.2 39.26,19.47 39.26,20.12 CE12.1 39.89,20.2 40.53,20.84 UE1.A64
+RTC_SOC: length 181.5
  TOP w0.254: v2(145.64,48.66) CC51.1 CC52.1 ; Q17.1 61.32,24.14 61.32,25.12 60.64,25.8 60.64,26.05 C3.1 R63.1 v2(60.61,26.66) ; v6(141.88,55.01) 141.89,55.01 141.99,55.1 143.65,55.1 143.83,54.91 143.83,53.75 144.51,53.08 144.51,52.72 144.25,52.46 144.25,51.78 144.27,51.75 v2(144.27,51.72) ; v2(127.47,22.85) 127.47,25.08 128.51,26.13 129.63,26.13 131.85,28.35 131.85,31.6 v2(129.78,33.67) 128.92,34.52 v3(128.92,38.83) 128.92,41.4 128.02,42.3 128.02,43.79 126.41,45.4 126.41,45.48 126.33,45.56 126.33,48.32 126.14,48.52 126.14,49.43 126.38,49.67 126.38,50.85 126.31,50.92 v6(126.31,51.22)
  IN1 w0.254: v2(129.78,33.67) 130.42,34.3 130.42,34.61 130.7,34.89 131.89,34.89 132.19,34.58 132.19,33.03 133.01,32.22 133.01,30.57 133.39,30.18 135.64,30.18 136.76,31.3 v4(136.76,31.82) ; v4(144.88,49.04) 144.99,48.92 145.18,48.92 145.44,48.66 v2(145.64,48.66) ; v2(127.47,22.85) v4(127.47,22.4) ; v2(144.27,51.72) v4(144.27,51.35) ; v2(60.61,26.66) 61.45,27.5 v4(63.78,27.5)
  IN2 w0.254: v4(144.88,49.04) 144.88,47.99 144.74,47.85 144.74,46.23 142.81,44.3 142.81,42.95 142.31,42.46 141.57,42.46 140.22,41.11 139.47,41.11 139.29,40.94 137,40.94 135.33,39.27 135.33,38.19 136.09,37.43 136.09,36.16 136.76,35.49 v4(136.76,31.82) ; v4(127.47,22.4) 127.24,22.16 126.3,22.16 125.18,21.04 125.18,19.32 123.52,17.66 123.23,17.38 122.62,17.38 119.2,13.96 111.49,13.96 111.05,14.4 99.44,14.4 98.72,13.68 97.36,13.68 97.07,13.39 97.07,13.07 96.57,12.57 95.64,12.57 95.46,12.39 85.01,12.39 83.67,13.72 75.95,13.72 75.25,14.43 72.29,14.43 67.13,19.59 66.96,19.59 64.25,22.29 64.25,24.9 63.8,25.36 63.8,26.69 63.78,26.71 v4(63.78,27.5)
  IN3 w0.254: v4(144.27,51.35) 144.27,50.64 144,50.37 144,49.83 143.74,49.57 143.74,48.97 144.03,48.68 144.5,48.68 144.85,49.04 v4(144.88,49.04) 144.9,49.02 146.07,49.02 v5(146.51,49.47) ; v5(139.2,60.51) 139.2,60.45 140.3,59.35 140.3,57.53 140.02,57.26 140.02,56.76 140.28,56.51 140.59,56.51 141.57,55.52 141.57,55.27 141.83,55.01 141.87,55.01 v6(141.88,55.01)
  BOTTOM w0.203: v5(139.2,60.51) 139.2,60.56 139.41,60.78 143.27,60.78 143.47,60.57 RC87.1 RC77.1 ; RC82.1 v6(126.31,51.22)
+RTC_VCC: length 26.6
  IN2 w0.254: v4(25.31,5.22) 25.31,5.21 23.97,5.21 21.19,7.99 17.79,7.99 14.74,4.94 3.55,4.94 v4(3.04,5.46)
  IN3 w0.254: v5(26.35,5.22) v4(25.31,5.22) ; v5(2.35,5.46) v4(3.04,5.46)
+RTC_VCC_R: length 1.6
  BOTTOM w0.081: RB22.2 26.79,4.62 v1(27.19,5.02)
+SDC_IN: length 6.3
  BOTTOM w0.381: v6(189.38,21.24) 189.26,21.24 188.87,21.62 188.87,23.6 189.14,23.87 PRB05.1
  BOTTOM w0.508: v6(193.26,16) 192.94,16.32 PRB04.1 192.04,16.32 191.34,15.63 PDB02.2
  vias: v3(182.71,17.25) v4(26.76,29.49) v4(27.02,28.56) v4(27.29,29.64) v4(27.21,29.11) v5(25.64,30.32) v5(25.64,29.91) v5(26.01,30.31) v5(26.01,29.9) v5(26.11,29.58) v5(26.33,30.06) v5(26.73,30.06) v5(27.12,30.03) v6(27.38,28.08) v6(27.84,27.55) v6(27.94,28.71) v6(27.94,28.13) v6(28.19,27) v6(28.46,27.49) v6(28.53,28.71) v6(28.53,28.13) v6(29.12,28.9) v6(75.86,20) v6(75.84,19.38) v6(76.47,20) v6(76.53,19.37) v6(77.13,19.95) v6(77.15,19.27) v6(179.36,16.9) v6(179.94,16.91) v6(180.19,16.4) v6(180.51,16.89) v6(180.86,16.39) v6(181.1,16.93) v6(181.75,16.96)
+SIM_PWR: length 136
  TOP w0.381: 60.78,43.79 60.78,44.02 60.4,44.4 60.4,46.65 60.02,47.03 RS2.1
  IN1 w0.508: v2(55.89,49.72) 55.89,49.9 v4(56.51,50.52) 56.51,53.44 57.02,53.95 58.73,53.95 60.1,52.57 60.1,51.1 60.88,50.32 60.88,46.18 61.82,45.24 61.82,43.86 61.27,43.31 v2(60.98,43.31) ; v4(36.1,55.68) 35.87,55.45 35.87,54.06 35.78,53.97 35.78,53.88 35.56,53.66 35.56,51.56 35.67,51.45 35.67,50.97 35.5,50.8 35.5,44.76 36.82,43.43 36.82,41.32 36.06,40.56 36.06,39.62 34.46,38.02 34.08,38.02 32.48,36.42 30.26,36.42 29.75,35.91 29.75,34.03 31.91,31.87 31.91,28.98 30.24,27.3 30.24,24.27 31.78,22.73 31.78,18.06 33.4,16.43 33.4,13.86 32.05,12.51 32.05,6.43 30.66,5.04 26.76,5.04 25.76,4.05 23.34,4.05 22.89,4.5 22.89,6.51 21.48,7.92 17.8,7.92 16.45,6.58 6.1,6.58 v2(5.78,6.26)
  IN3 w0.508: v4(56.51,50.52) 56.51,52.33 55.8,53.05 54.62,53.05 53.6,54.07 50.02,54.07 48.42,55.67 45.15,55.67 44.81,55.33 41.99,55.33 40.89,56.43 39.87,56.43 39.55,56.1 37.14,56.1 36.89,55.85 36.27,55.85 v4(36.1,55.68)
  vias: v1(56.41,49.75) v5(56.51,49.82)
+TBT_SVR_IND:
  vias: v1(34.51,64.04) v2(32.85,64.74) v2(32.85,64.38) v2(32.86,63.98) v2(33.26,64.75) v2(33.26,64.39) v2(33.27,63.99) v4(31.68,64.65) v4(31.68,64.16) v4(32.19,64.16) v4(32.2,64.65) v5(31.8,57.2) v5(31.8,56.74) v5(32.1,57.41) v5(32.1,56.95) v5(32.48,57.54) v5(32.47,57.11) v5(32.85,57.69) v5(32.85,57.3)
+TBT_VBUS_L_PD: length 143.9
  TOP w0.254: PR103.1 104.76,25.52 101.63,22.38 95.28,22.38 92.86,19.97 v6(92.59,19.97)
  IN1 w0.254: v2(26.51,27.24) v4(26.51,26.83)
  IN2 w0.254: v6(108.48,4.73) 107.98,5.23 98.22,5.23 97.7,4.71 86.42,4.71 86.37,4.76 56.59,4.76 52.56,8.79 47.6,8.79 46.41,9.98 44.87,9.98 44.23,9.34 40.87,9.34 39.61,10.59 39.61,11.97 38.5,13.09 36.48,13.09 35.33,11.93 33.11,11.93 32.85,12.19 32.85,13.09 33.27,13.51 33.27,16.7 32.67,17.3 30.45,17.3 28.44,19.31 28.44,24.49 26.51,26.42 v4(26.51,26.83)
  BOTTOM w0.254: v6(108.48,4.73) 108.36,4.85 102.51,4.85 102.01,5.36 102.01,8.79 100.04,10.75 100.04,11.32 99.24,12.12 99.24,14.98 98.5,15.72 93.8,15.72 92.33,17.19 92.33,19.71 v6(92.59,19.97)
  vias: v1(26.19,31.68) v6(24.81,28.33) v6(25.26,28.66) v6(25.72,29.29) v6(25.79,28.37) v6(26.08,33.2) v6(26.07,28.85) v6(26.1,33.83) v6(26.7,33.19) v6(26.71,33.84)
+TBTA_VBUS:
  vias: v3(9.04,67.91) v3(11.25,68.84) v3(11.52,60.99) v4(7.7,66.62) v4(7.72,65.9) v4(7.7,65.15) v4(9.36,66.08) v4(9.33,65.4) v4(9.42,66.68) v5(7.4,67.12) v5(7.4,64.62) v5(7.68,67.12) v5(7.68,64.62) v5(7.97,67.12) v5(7.97,64.62) v5(9.01,67.37) v5(9.02,64.88) v5(9.32,67.37) v5(9.32,64.88) v5(9.63,67.38) v5(9.65,64.88) v6(10.13,64.73) v6(10.48,67.38) v6(10.57,69.82) v6(10.66,69.19) v6(10.76,64.8) v6(10.7,63.22) v6(11.09,67.43) v6(11.21,69.58) v6(11.21,62.83) v6(11.7,69.99) v6(11.71,63.91) v6(33.48,32.58) v6(33.46,32.02) v6(33.49,31.46) v6(33.43,30.89) v6(33.93,30.32) v6(34.02,32.46) v6(34.03,31.88) v6(34.07,31.31) v6(34.26,30.78)
+TP_VDD: length 11.1
  TOP w0.254: 116.15,5.82 116.15,5.23 v3(115.48,4.56)
  BOTTOM w0.508: v6(120.88,5.45) 121.23,5.81 124.2,5.81 125.3,6.91 125.3,11.45
+TP_VDD_P: length 2.6
  TOP w0.081: R6907.1 120.75,11.55 121.32,12.12 v1(121.32,13.59)
+TS_VDD: length 62.5
  TOP w0.254: v2(42.44,54.44) 42.42,54.44 42.39,54.47 F8.2 ; C6905.1 C54.1 C55.1 C53.1 v2(13.97,71.94)
  IN1 w0.254: v4(38.69,70.2) 38.69,68.9 39.01,68.58 39.01,67 38.68,66.67 38.68,65.82 39.05,65.45 41.05,65.45 42.12,64.38 42.12,63.16 43.07,62.22 43.07,60.95 42.44,60.33 42.44,56.92 42.25,56.73 42.25,55.23 42.44,55.04 v2(42.44,54.44) ; v2(13.97,71.94) 13.7,71.94 v4(13.41,71.64)
  IN3 w0.254: v5(13.41,71.09) v4(13.41,71.64) 13,72.05 13,74.7 13.45,75.14 23.49,75.14 24.93,76.58 24.93,77.22 26.1,78.39 34.73,78.39 37.76,75.36 37.76,71.58 38.69,70.65 v4(38.69,70.2)
  BOTTOM w0.254: v5(13.41,71.09) 13.92,71.6 JCAM1.5
  vias: v3(39.93,52.48)
+V_DDR_REF_CA: length 6
  IN2 w0.508: v4(175.65,59.91) 176.41,59.15 v4(176.41,57.97)
  IN3 w0.203: v4(175.65,59.91) 175.65,59.96 v5(176.11,60.42) ; v5(176.41,57.61) v4(176.41,57.97)
  BOTTOM w0.076: 175.53,58.4 175.53,58.4 175.53,57.63 175.63,57.53 176.12,57.53 176.2,57.61 v5(176.41,57.61) 176.41,57.81 175.99,58.23 175.99,58.37
+VCHGR: length 1.3
  TOP w0.081: v1(91.01,11.62) 91.01,11.62 PCB32.1
+VDISPLAY_VCC: length 3.4
  TOP w0.203: RM4.1 v2(23.68,36.61) ; RM3.1 v2(24.84,36.62)
  TOP w0.508: UV17.3 v6(29.9,39.21)
  IN1 w0.254: v2(23.68,36.61) 23.68,36.77 v4(23.46,37) ; v2(24.84,36.62) 25.11,36.89 v4(25.11,37.54)
  vias: v3(14.82,48.67) v6(13.49,48.79) v6(14.05,48.91) v6(14.02,48.24)
+VREFCA: length 110.6
  IN1 w0.508: 142.42,77.67 141.97,77.22 141.97,73.49 143.61,71.85 v4(143.88,71.85) ; 180.78,77.67 180.78,73.57 180.07,72.86 180.07,72.6 v4(180.05,72.58)
  VCC w0.508: v6(158.48,71.83) 158.48,74.77 156.76,76.5 146.41,76.5 v6(145.08,77.83)
  IN2 w0.508: v4(190.45,65.29) 190.45,62.38 192.18,60.65 194.64,60.65 196,59.29 196,56.16 196.84,55.32 v6(196.84,55.29)
  IN3 w0.254: v5(180.06,72.24) 180.06,72.57 v4(180.05,72.58) ; v5(143.62,72.24) 143.62,72.11 v4(143.88,71.85)
  IN3 w0.508: v5(193.23,55.07) 193.42,55.26 193.49,55.26 193.63,55.4 194.78,55.4 195.19,54.99 196.53,54.99 v6(196.84,55.29) ; v5(181.36,64.01) 181.9,64.56 189.72,64.56 v4(190.45,65.29) 188.49,67.25 188.49,70.39 189.45,71.34 189.45,75.49 v6(187.54,77.4)
  BOTTOM w0.254: UD44.H4 158.84,72.19 v6(158.48,71.83)
  BOTTOM w0.305: CD60.1 196.85,55.28 v6(196.84,55.29)
  BOTTOM w0.508: CD82.1 158.21,77.99 158.72,78.5 167.3,78.5 167.92,77.88 171.94,77.88 172.55,78.5 179.34,78.5 179.35,78.49 186.02,78.49 186.53,77.98 ; 176,61.88 v1(176,62.87) 176,63.29 176.91,64.21 181.16,64.21 v5(181.36,64.01)
  vias: v4(142.77,78.55) v5(143.05,76.72)
+VREFDQ_A: length 17.3
  IN2 w0.508: v4(187.29,54.1) 187.29,54.41 187.1,54.6 185.65,54.6 185.22,55.03 185.22,58.03 182.73,60.52 v6(182.73,63.68) 181.53,63.68 180.99,64.21 180.99,66.2 v4(181.03,66.24)
  IN3 w0.254: v4(181.03,66.24) 180.71,66.56 v5(180.71,66.64) ; v5(187.63,54.42) 187.61,54.42 v4(187.29,54.1)
  vias: v1(183.11,60.11)
+VREFDQ_B: length 43
  IN2 w0.508: v4(144.48,66.3) 144.31,66.3 143.8,65.79 143.8,65.07 144.47,64.4 v6(150.77,64.4) 158.59,64.4 158.89,64.1 161.82,64.1 v6(161.88,64.16) ; v6(161.88,64.16) 161.95,64.09 178.87,64.09 v6(179.97,62.99) ; v6(161.88,64.16) 161.88,64.41 161.43,64.87 161.19,64.87 160.65,65.41 160.65,65.75 160.23,66.17 v4(160.23,66.3)
  IN3 w0.254: v5(159.77,66.36) 159.82,66.36 159.88,66.3 v4(160.23,66.3) ; v5(144.27,66.64) 144.48,66.43 v4(144.48,66.3)
  BOTTOM w0.254: UD44.J11 v5(159.77,66.36)
  vias: v1(179.13,62.96)
A4WP_PRESENT: length 3.1
  TOP w0.081: v1(141.49,44.72) 141.49,44.89 v2(141.31,45.07) 140.84,45.55 RC61.2
  IN1 w0.064: v2(141.31,45.07) 141.23,45.15 141.07,45.15 v4(140.9,45.31)
  IN3 w0.064: v4(140.9,45.31) 140.51,45.71 140.33,45.71 v5(140.3,45.75)
  BOTTOM w0.081: v5(140.3,45.75) UC1.CF17
A/BMON_CHG: length 4.6
  BOTTOM w0.203: PCB40.1 197.71,28.5 197.27,28.06 197.27,27.38 196.51,26.62 PUB01.29
  BOTTOM w0.254: PCB40.1 198.17,28.5 PRB35.1 PRB34.1
AC_DIS: length 231.8
  TOP w0.081: v6(195.62,33.64) v1(196.66,32.6) 197.12,32.15 197.12,29.43 197.83,28.72 v6(197.83,7.3)
  IN1 w0.064: v4(45.05,18.89) 45.24,19.08 v2(45.24,19.29)
  IN2 w0.066: v4(45.62,8.35) 45.86,8.35 47.4,6.8 52.25,6.8 55.52,3.53 98.82,3.53 99.44,4.15 100.87,4.15 101.57,3.44 152.38,3.44 152.44,3.51 152.44,9.04 152.53,9.12 152.53,9.12 153.72,10.32 158.47,10.32 162.21,6.58 162.21,4.04 162.28,3.98 170.95,3.98 171.01,3.92 174.41,3.92 174.47,3.98 196.46,3.98 197.83,5.35 v6(197.83,7.3)
  IN3 w0.064: v4(45.62,8.35) 45.43,8.16 43.56,8.16 42.43,7.03 38.57,7.03 37.89,7.71 37.68,7.71 37.43,7.96 37.43,8.36 37.97,8.9 37.97,10.75 39.69,12.47 39.97,12.47 41.64,14.14 42.51,14.14 42.7,14.33 42.7,15.9 42.96,16.16 42.96,16.39 43.08,16.52 43.08,16.8 44.86,18.57 44.86,18.57 45.05,18.76 v4(45.05,18.89) ; v5(188.29,29.64) 188.29,28.96 189.75,27.49 192.06,27.49 193.48,28.91 193.48,29.5 195.62,31.64 v6(195.62,33.64)
AC_PRESENT: length 25.5
  TOP w0.081: v2(144.89,57.57) 144.71,57.75 v1(143.62,57.75) 143.02,57.75 142.91,57.85 RC569.1 ; DV1.2 129.74,65.74 130.09,65.39 130.73,65.39 133.54,62.58 136.37,62.58 136.7,62.26 137.3,62.26 v2(137.45,62.4)
  IN1 w0.064: v4(144.96,56.96) 144.95,56.97 144.95,57.47 144.89,57.53 v2(144.89,57.57) ; v2(137.45,62.4) 137.45,62.5 v4(137.68,62.74)
  IN3 w0.064: v5(140.75,59.32) 140.75,59.37 139.03,61.09 138.74,61.09 138.74,61.09 138.73,61.09 138.51,61.32 138,61.32 137.78,61.53 137.78,62.65 137.69,62.74 v4(137.68,62.74) ; v4(144.96,56.96) 145,56.96 v5(145.24,56.73)
  BOTTOM w0.081: v5(140.75,59.32) 141.99,59.32 142.29,59.02 144.17,59.02 144.48,58.71 145.05,58.71 145.28,58.49 145.28,57.27 UC1.BU35 145.02,56.95 v5(145.24,56.73)
ACAV_IN1: length 12.8
  TOP w0.081: v6(188.37,20.96) 188.3,20.9 v3(188.3,19.9)
  BOTTOM w0.081: PRB20.1 188.37,24.18 v6(188.37,20.96) 188.54,20.79 190.64,20.79 PRB41.1 191.07,20.36 PRB11.2 ; PQB04.1 190.26,26.21 190.95,26.9 PRB22.2
  BOTTOM w0.089: PQB04.1 189.59,25.4 PRB20.1
ACIN_CHG: length 6.8
  BOTTOM w0.203: PUB01.19 193.6,23.27 192.93,22.6 192.93,21.93 192.73,21.73 190.74,21.73 190.39,22.08 PCB26.1
  BOTTOM w0.254: PRB05.2 PRB07.1 PCB26.1
ACOK_CHG: length 2.5
  BOTTOM w0.203: PRB22.1 193.16,26.9 193.68,26.37 193.68,25.54 193.96,25.27 PUB01.24
ADCIN1_L_PD: length 4.2
  IN3 w0.203: v5(27.79,32.58) 27.79,32.56 27.55,32.31 25.88,32.31 v5(25.63,32.06)
  BOTTOM w0.203: v5(25.63,32.06) 25.39,32.3 UPD1.6 ; v5(27.79,32.58) 27.81,32.6 RPD92.2 RPD91.1
ADCIN2_L_PD: length 3.9
  IN3 w0.254: v5(27.95,29.68) 28.04,29.77 28.04,30.16 27.76,30.45 26.48,30.45 26.23,30.7 v5(25.71,30.7)
  BOTTOM w0.152: UPD1.10 v5(25.71,30.7)
ADDR_GPU: length 5.5
  TOP w0.081: PRV37.2 36.54,59.9 v1(36.18,59.54)
  TOP w0.254: PUV01.6 39.31,60.77 PRV46.2 PCV45.1 PRV41.1 36.72,60.72 PRV37.2
ADDR_P_CPU: length 4.1
  BOTTOM w0.203: PRZ15.2 PRZ14.1 161.44,27.16 v1(160.34,26.06) 160.34,25.85 159.81,25.32 159.81,25.08 159.61,24.88 PUZ01.25
ADJ_1.0V: length 4.5
  BOTTOM w0.254: PUF01.8 113.3,43.71 112.81,43.22 112.81,43.09 112.13,42.41 PRF06.1 110.86,42.41 PRF05.2 109.99,42.43 PCF04.2
ADJ_UM2: length 1.4
  TOP w0.081: v1(28.02,34.22) 28.02,34.62 27.79,34.85 27.79,35.56
ADP_CHG:
  vias: v1(193.85,20.55)
ALERT#: length 3.2
  TOP w0.081: U3.6 132.48,42.77 R54.2 132.58,42.42 v1(133.38,41.62)
ALL_SYS_PWRGD: length 28.4
  TOP w0.254: v6(64.17,14.22) v1(64.17,14.81) 64.17,15.35 64.58,15.76 64.58,16.46 64.41,16.63 64.41,17.31 64.41,17.31 ; PQ501.2 47.36,7.27 47.95,6.68 47.95,6.04 48.22,5.78 49.58,5.78 50.9,4.46 51.63,4.46 v6(52.03,4.85)
  IN3 w0.254: v6(64.17,14.22) 64.17,14.01 63.97,13.81 63.97,10.39 58.27,4.7 55.3,4.7 55.23,4.62 52.26,4.62 v6(52.03,4.85)
ALT#_CPU: length 1.8
  BOTTOM w0.114: PUZ01.29 160.63,23.28 PRZ12.1
ALT#_CPU_R: length 1.5
  BOTTOM w0.114: PRZ23.2 161.83,21.8 161.83,22.14 161.79,22.19 PRZ28.1 161.79,22.7 PRZ12.2
ALWON: length 95.6
  TOP w0.081: UE1.B65 41.68,22.43 41.82,22.57 v2(42.06,22.57) ; v2(109.44,5.49) 109.31,5.36 105.32,5.36 104.88,5.8 PQB13.2 ; v1(52.72,4.79) 52.72,5.11 v2(51.93,5.89)
  IN1 w0.064: v2(42.06,22.57) 41.52,22.03 41.52,21.03 41.38,20.89 40.89,20.89 39.76,19.76 38.87,19.76 37.86,18.75 37.86,17.3 37.35,16.79 37.35,15.11 38.42,14.05 38.42,11.8 40.95,9.27 42.82,9.27 43.11,8.98 44.24,8.98 45.7,7.51 49.82,7.51 50.86,6.47 51.35,6.47 v2(51.93,5.89) 51.98,5.85 51.98,5.74 52.11,5.6 52.11,5.44 52.65,4.91 52.89,4.91 53.13,4.66 99.16,4.66 99.61,5.11 100.8,5.11 101.18,5.49 v2(109.44,5.49)
AMBER_LED_BAT: length 54.3
  TOP w0.254: Q31.1 35.51,39.64 33.79,41.35 v1(33.76,41.35) 33.31,41.35 31.88,39.92 v2(30.75,39.92)
  IN1 w0.254: v4(29,39.46) 29.46,39.92 v2(30.75,39.92)
  IN2 w0.254: v4(13.23,57.05) 13.23,57.94 12.01,59.16 7.66,59.16 6.26,57.76 6.26,54.69 7.17,53.78 12.05,53.78 12.82,54.54 18.53,54.54 21.7,51.37 23.87,51.37 27.96,47.28 27.96,40.59 28.81,39.73 28.81,39.64 v4(29,39.46)
  IN3 w0.254: v4(13.23,57.05) 13.25,57.04 v5(13.61,57.04)
AMBER_LED_BAT_R: length 14.1
  IN3 w0.254: v5(13.61,57.95) 13.57,57.95 12.38,59.15 11.49,59.15 11.11,59.53 8.18,59.53 7.61,58.96 6.15,58.96 5.74,58.54 5.74,56.04 v5(4.6,54.9)
  BOTTOM w0.254: LED1.1 v5(4.6,54.9)
ANT1_CS0: length 4.6
  TOP w0.081: v1(68.78,77.55) 70.49,77.55 v6(71.02,77.02) CS47.1 71.25,76.45 71.47,76.23 LS4.1
  BOTTOM w0.081: v6(71.02,77.02) 71.35,77.34 JANT1.1
ANT1_CS0_R: length 0.7
  TOP w0.081: LS4.2 RS9.1
ANT_CTL0: length 5.9
  IN3 w0.064: v5(38.38,67.02) 38.38,66.73 38.46,66.64 38.46,66.64 38.7,66.41 38.7,66.18 39.38,65.5 v5(40.69,65.5)
  BOTTOM w0.081: v1(41.11,66.72) 40.69,66.3 v5(40.69,65.5) ; JANT2.2 38.15,67.95 38.38,67.72 v5(38.38,67.02)
ANT_CTL1: length 6.4
  BOTTOM w0.081: JANT2.3 38.31,68.3 38.59,68.01 38.59,67.66 38.78,67.48 39.2,67.48 40.11,68.38 v1(41.24,68.38) 42.52,69.66 LN10.2
ANTCTL0: length 16.8
  IN1 w0.064: v4(50.51,56.61) 50.51,57.66 50.45,57.72 50.45,58.71 50.25,58.91 50.25,59.8 50,60.06 50,62.7 49.68,63.02 49.46,63.02 49.28,63.21 v4(49.27,63.21)
  IN3 w0.064: v4(50.51,56.61) 50.51,56.82 v5(50.76,57.08) ; v5(41.54,64.94) 41.61,64.86 41.62,64.86 42.55,63.93 48.54,63.93 v4(49.27,63.21)
  BOTTOM w0.081: v5(41.54,64.94) 41.54,64.94 LN9.1
ANTCTL1: length 17.1
  IN2 w0.066: v4(49.92,57.08) 49.92,59.44 48.71,60.65 48.71,63.67 47.8,64.58 47.8,66.25 47.78,66.27 45.42,68.63 v4(45.42,68.87)
  IN3 w0.064: v5(50.26,57.08) v4(49.92,57.08) ; v5(43.7,69.66) 44.21,69.66 45,68.87 v4(45.42,68.87)
  BOTTOM w0.081: v5(43.7,69.66) 43.7,68.62 v1(43.66,68.58)
AUXDCN: length 3
  TOP w0.081: RM48.2 24.91,36.16 25.15,36.4 25.15,37.21 24.91,37.45 UM1.53
AUXDCP:
  vias: v2(25.32,38.45) v4(25.24,38.81) v5(25.24,38.31)
B+: length 16.7
  TOP w0.305: QV18.1 33.13,73.29 v2(33.43,73.59)
  IN1 w0.508: v2(33.43,73.59) 33.58,73.59 33.92,73.93 33.94,73.93 35.91,75.9 41.63,75.9 44.85,72.67 v6(45.34,72.67)
  BOTTOM w0.508: PDB01.2 v6(189.13,16.47) ; 9.55,18.94 9.54,18.93 ; PR302.2 9.55,18.99
  vias: v2(58.43,60.2) v2(58.43,59.82) v2(58.74,60.2) v2(58.74,59.82) v2(59.45,60.19) v2(59.45,59.81) v2(60.24,60.2) v2(60.24,59.82) v3(72.82,11.71) v4(8.58,22.52) v4(8.57,21.56) v4(8.84,16.85) v4(9.38,16.87) v4(9.4,15.05) v4(9.54,21.88) v4(9.56,21.32) v4(9.5,16.34) v4(9.57,15.62) v4(9.62,22.4) v4(9.92,16.9) v4(58.01,60.26) v4(58.01,59.76) v4(59.11,60.02) v4(59.87,60.02) v4(60.54,60.02) v5(8.77,20.51) v5(8.77,19.62) v5(8.77,18.73) v5(8.77,17.85) v5(8.99,22.38) v5(8.99,21.86) v5(8.99,21.4) v5(9.15,16.09) v5(9.17,15.69) v5(9.18,15.33) v5(9.18,14.64) v5(9.16,14.26) v5(201.41,24.59) v6(45.34,72.04) v6(45.34,71.4) v6(45.34,70.77) v6(45.34,70.13) v6(45.98,72.67) v6(45.98,72.04) v6(45.98,71.4) v6(45.98,70.77) v6(45.98,70.13) v6(72.81,12.86) v6(72.81,12.28) v6(73.39,12.86) v6(73.39,12.28) v6(73.98,12.86) v6(73.98,12.28) v6(89.33,14.3) v6(89.79,14.65) v6(93.87,14.14) v6(94.35,14.41) v6(94.6,13.81) v6(94.93,14.37) v6(95.19,13.87) v6(95.49,14.37) v6(96.13,14.37) v6(96.69,14.37) v6(97.27,14.37) v6(97.83,14.37) v6(99.76,12.5) v6(100.29,12.79) v6(136.17,16.41) v6(136.74,16.41) v6(137.43,16.41) v6(138.01,16.41) v6(138.59,16.41) v6(138.65,13.36) v6(138.96,13.87) v6(139.22,16.41) v6(139.22,13.36) v6(139.53,13.87) v6(139.79,16.41) v6(139.79,13.36) v6(140.11,13.87) v6(140.36,13.36) v6(140.68,13.87) v6(140.93,13.36) v6(141.5,13.36) v6(181.53,7.45) v6(182.12,7.45) v6(182.7,7.45) v6(183.28,7.45) v6(183.87,7.45) v6(184.45,7.45) v6(185.04,7.45) v6(185.62,7.45) v6(186.21,7.45) v6(186.79,7.45) v6(187.57,7.45) v6(187.57,6.86) v6(188.15,7.45) v6(188.15,6.86) v6(199.48,55.34) v6(199.48,54.7) v6(199.48,54.07) v6(200.14,54.19) v6(200.88,18.76) v6(200.88,18.12) v6(201.51,18.76) v6(201.51,18.12) v6(202.15,18.76) v6(202.15,18.12) v6(202.78,17.49) v6(203.16,27.4) v6(203.16,26.76) v6(203.16,26.13) v6(203.42,17.49) v6(203.8,27.4) v6(203.8,26.76) v6(203.8,26.13) v6(204.3,26.38) v6(204.3,25.62) v6(204.3,24.98) v6(204.3,24.35) v6(204.3,23.71) v6(204.3,23.08) v6(206.64,30.24) v6(207.1,31.4) v6(207.1,30.82) v6(207.45,30.29) v6(207.66,29.63)
B+_1.2V:
  vias: v2(200.91,56.02) v2(201.36,56.11) v2(201.51,56.85) v2(201.54,56.45) v2(201.74,56.13) v2(201.96,56.76) v2(201.91,56.4) v4(200.49,56.67) v4(200.76,57.1) v4(201,56.49) v5(191.18,68.05) v5(191.24,67.68) v5(191.53,68.03)
B+_1.05V: length 2.4
  BOTTOM w0.081: PCH03.1 129.61,26 129.76,26 v1(130.84,27.08)
  vias: v2(128.36,23.79) v2(128.51,23.54) v4(128.62,24.07) v4(128.84,23.69) v5(128.31,23.97) v5(128.41,23.59) v6(132.14,16.32) v6(132.7,16.3)
B+_1.8V: length 0.9
  TOP w0.081: 70.66,15.79 69.94,15.79 v1(69.8,15.93)
B+_+1.35VGPU:
  vias: v1(71.22,60.91)
BA: length 1.4
  TOP w0.081: PQB12.1 103.08,5.61 v1(103.56,5.13)
BA_PWR: length 154.6
  TOP w0.381: PRB66.2 100.6,5 100.9,4.69 100.9,3.96 101.29,3.58 v1(101.93,3.58) 102.78,3.58 v2(102.85,3.51)
  IN1 w0.381: v6(200.05,29) 203.85,29 205.61,27.24 205.61,21.06 209.85,16.82 209.85,4.86 208.21,3.21 207.59,3.21 207.59,3.22 196.09,3.22 195.9,3.02 195.87,3.02 195.86,3.01 161.63,3.01 v4(161,3.64) ; v2(102.85,3.51) 103.3,3.51 103.35,3.46 105.98,3.46 106.08,3.36 106.37,3.36 106.46,3.27 106.46,3.27 106.56,3.17 114.45,3.17 114.64,3.36 114.66,3.36 114.76,3.46 120.86,3.46 121.47,4.07 121.47,5.74 121.85,6.12 122.64,6.12 123.04,5.72 123.04,5.12 123.42,4.74 152.86,4.74 v4(152.94,4.82)
  IN2 w0.508: v4(152.94,4.82) 152.94,8.22 154.62,9.91 158.29,9.91 161,7.2 v4(161,3.64)
BAT1_LED#: length 22.6
  TOP w0.081: Q15.1 39.82,42.32 39.82,42.21 v2(40.06,41.97) ; v2(39.75,29.24) 39.38,29.24 RE21.2 39.56,28.97 39.84,28.97 40,28.81 40,28.46 40.28,28.18 UE1.A50
  IN1 w0.064: v2(39.75,29.24) 39.36,29.63 39.36,30.69 38.53,31.52 38.01,31.52 37.24,30.76 36.73,30.76 36.72,30.77 36.71,30.77 36.5,30.98 36.5,30.98 36.28,31.2 36.28,31.2 36.07,31.41 36.07,32.93 36.32,33.17 37.43,33.17 38.16,33.9 38.51,33.9 39.14,34.54 39.14,37.12 40.15,38.13 40.15,41.88 v2(40.06,41.97)
BAT1_LED#_R: length 3.1
  TOP w0.081: QZ21.1 36.38,11.48 QZ3.2 36.2,11.48 v1(35.33,12.35)
BAT2_LED#: length 27.4
  TOP w0.081: UE1.B54 41.75,27.93 42.1,27.58 v2(42.1,27.31) ; v1(36.36,31.19) 36.67,30.89 RE23.2 37.18,30.71 v2(36.93,30.46) ; v2(39.86,41.5) 39.72,41.5 39.57,41.65 38.1,41.65 37.85,41.4 Q15.4
  IN1 w0.064: v2(39.86,41.5) 39.74,41.37 39.74,37.99 38.95,37.2 38.95,34.62 38.45,34.11 38.1,34.11 37.35,33.36 36.24,33.36 35.88,33.01 35.88,30.98 36.4,30.46 v2(36.93,30.46) 37.22,30.46 38.09,31.33 38.45,31.33 39.17,30.61 39.17,29.12 39.38,28.91 40.16,28.91 41.6,27.47 41.68,27.47 41.84,27.31 v2(42.1,27.31)
BATGONE_CHG: length 4.9
  BOTTOM w0.081: v1(191.35,28.15) 191.81,27.68 PRB25.1
  BOTTOM w0.203: PUB01.25 194.91,26.4 193.99,27.31 PRB24.1
  BOTTOM w0.254: PRB25.1 PCB34.1 PRB24.1
BATT_PRES#: length 3.7
  TOP w0.081: PR39.1 108.82,11.99 v1(109.54,12.7)
  IN1 w0.064: v2(108.97,11.6) 108.97,11.47 109.12,11.31 v4(109.12,11.14)
  IN3 w0.064: v4(109.12,11.14) 109.16,11.18 109.67,11.18 110.25,11.76 v5(110.71,11.76)
BATT_WHITE_LED_R#: length 6.1
  TOP w0.081: Q3.1 37.35,45.29 36.98,44.92 36.98,44.67 36.29,43.98 Q32.2 ; Q3.1 v1(36.81,46.18) ; Q3.1 37.7,43.51 37.85,43.35 Q15.3
BEEP: length 176.3
  TOP w0.081: v2(43.51,18.03) 43.51,18.32 43.87,18.68 44.27,18.68 44.73,19.15 UE1.A6
  IN1 w0.064: v2(43.51,18.03) 43.08,17.6 43.08,17.13 43.19,17.02 43.42,17.02 43.75,16.69 43.75,16.25 v4(44.04,15.96) ; v2(195.49,8.25) 195.17,8.25 194.72,8.7 193.04,8.7 192.13,9.6 184.54,9.6 183.64,10.5 182.06,10.5 180.14,8.59 171.79,8.59 171.28,9.1 166.22,9.1 165.57,9.74 164.71,9.74 163.08,11.37 160.88,13.57 155.39,13.57 154.9,14.06 154.9,15.69 153.68,16.92 150.72,16.92 147.71,19.92 144.02,19.92 143.46,19.36 140.18,19.36 140.08,19.46 139.12,19.46 138.87,19.21 132.07,19.21 131.42,19.86 125.51,19.86 123.05,17.4 119.77,17.4 116.98,14.61 115.2,14.61 114.56,13.97 108.12,13.97 107.23,13.08 101.34,13.08 99.27,11.01 95.75,11.01 93.04,8.3 90.34,8.3 89.49,9.16 83.4,9.16 82.47,10.09 75.6,10.09 75.3,9.79 71.94,9.79 71.02,10.71 63.53,10.71 60.03,14.21 60.03,14.99 59.56,15.46 59.1,15.46 58.67,15.88 56.34,15.88 55.59,15.14 54.5,15.14 53.16,13.8 49.83,13.8 49.52,13.5 44.36,13.5 v4(44.12,13.74)
  IN3 w0.064: v4(44.04,15.96) 44.12,15.89 v4(44.12,13.74)
BGATE_CHG: length 145
  TOP w0.508: PCB33.1 95.44,7.97 v1(95.83,7.59) 96.2,7.21 v2(96.8,7.21)
  IN1 w0.508: v2(96.8,7.21) 96.89,7.13 v4(97.44,7.13) ; v4(122.17,5.42) 122.17,4.57 122.69,4.04 v4(151.9,4.04)
  IN2 w0.508: v4(201.09,25.57) 201.09,24.07 204.81,20.35 204.81,17.17 204.42,16.77 200.39,16.77 199.49,17.67 195.6,17.67 194.42,16.5 194.42,8.07 191.4,5.04 174.77,5.04 174.18,4.46 171.23,4.46 169.57,6.13 166.27,6.13 165.57,5.42 164.13,5.42 158.69,10.86 153.5,10.86 151.98,9.35 151.98,9.34 151.9,9.26 v4(151.9,4.04) ; v4(122.17,5.42) 122.17,7.52 121.66,8.03 111.69,8.03 110.54,6.88 98,6.88 97.76,7.13 v4(97.44,7.13)
  vias: v5(198.18,26.03) v5(198.29,26.33)
BIA_PWM_EC: length 13.9
  TOP w0.081: v2(52.04,27.08) 52,27.08 51.6,26.68 UE1.A28 ; v2(58.03,30.34) 57.82,30.34 57.4,30.76 57.4,31.28 v1(57.98,31.85) 58.84,32.72 D2.3
  IN1 w0.064: v2(52.04,27.08) 52.04,27.04 52.56,26.53 53.08,26.53 53.69,27.14 53.69,27.14 53.84,27.3 55.99,27.3 55.99,27.3 56,27.3 58.03,29.33 v2(58.03,30.34)
BKLT_CTRL: length 53
  TOP w0.081: v1(59.5,36.11) 58.94,36.67 v2(58.65,36.67) 58.45,36.46 R75.1 58.45,35.83 58.34,35.73 D2.1
  IN1 w0.064: v4(38.71,71.79) 38.72,71.81 38.95,71.81 40.7,70.05 40.7,68.9 42.13,67.48 42.13,67.46 43.27,66.32 43.59,66.32 44.34,65.57 46.08,65.57 46.7,64.95 46.7,64.2 48.08,62.82 48.08,53.57 47.33,52.82 47.33,48.53 46.83,48.03 46.83,42.03 49.21,39.65 49.8,39.65 49.93,39.52 51.48,39.52 53.42,37.58 57.73,37.58 v2(58.65,36.67)
  IN3 w0.064: v4(38.71,71.79) 38.67,71.82 v5(38.35,71.82)
  BOTTOM w0.081: JEDP1.7 v5(38.35,71.82)
BKLT_IN_EC: length 172.1
  TOP w0.081: v2(36.32,67.06) 35.65,67.06 35.22,66.63 D463.2
  IN1 w0.064: v2(36.32,67.06) 36.43,66.95 36.43,65.37 37.47,64.32 37.62,64.32 38.48,63.47 38.48,62.42 39.68,61.22 39.68,59.25 40.18,58.75 40.18,57.4 40.28,57.3 40.28,56.37 39.55,55.63 39.55,53.06 39.14,52.66 39.14,50.9 38.77,50.53 38.77,49.68 38.61,49.51 38.61,46.04 40.54,44.11 40.54,38.77 41.97,37.34 41.97,36.16 40.04,34.23 v4(39.76,34.23) ; v4(46.94,23.5) 46.97,23.47 47.28,23.47 49.08,21.66 50.29,21.66 50.76,21.19 52.01,21.19 52.13,21.31 52.58,21.31 52.63,21.26 53.41,21.26 53.69,21.54 54.31,21.54 54.72,21.13 55.73,21.13 56.28,21.68 57.21,21.68 58.03,22.51 58.65,22.51 58.77,22.38 62.61,22.38 63.14,21.86 66.63,21.86 68.14,20.35 72.98,20.35 v4(73.04,20.28)
  IN2 w0.066: v4(73.04,20.28) 73.04,21.26 74.14,22.36 79.91,22.36 80.76,21.5 81.72,20.54 87.12,20.54 87.57,20.99 89.08,20.99 90.6,19.47 94.4,19.47 94.42,19.45 96.09,19.45 97.72,21.08 103.93,21.08 104.52,20.49 105.23,20.49 105.71,20.97 114.89,20.97 118.28,24.36 119.37,24.36 119.88,24.87 119.88,25.55 121.31,26.98 121.31,29.94 127.06,35.7 127.06,39.05 128.05,40.03 129.03,40.03 129.42,39.65 129.42,39.55 v4(129.36,39.49)
  IN3 w0.064: v4(46.94,23.5) 46.99,23.55 46.99,24.62 48.45,26.09 49.8,26.09 50.25,26.55 50.25,27.82 47.63,30.44 47.63,32.66 46.44,33.85 43.92,33.85 43.71,33.64 40.72,33.64 40.13,34.23 v4(39.76,34.23) ; v4(129.36,39.49) 129.36,39.54 129.33,39.57 v5(129.33,39.82)
  BOTTOM w0.081: UC1.CK11 137.15,41.72 136.53,41.72 136.32,41.63 136.18,41.63 136,41.7 135.83,41.7 135.66,41.63 134.63,41.63 134.54,41.72 133.67,41.72 133.58,41.63 132.67,41.63 RC13.1 132.65,41.45 132.55,41.35 v1(130.73,41.35) 129.84,41.35 129.33,40.84 v5(129.33,39.82)

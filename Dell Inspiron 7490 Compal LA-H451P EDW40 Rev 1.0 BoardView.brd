# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_CTX_C_DRX_N9: length 2.4
  TOP w0.091: v6(118.95,18.99) 119.07,19.11 119.56,19.11 CS7.2
  BOTTOM w0.091: JSSD1.11 118.21,19.03 118.39,19.2 118.73,19.2 v6(118.95,18.99)
PCIE_CTX_C_DRX_N10: length 2.4
  TOP w0.091: CS9.2 119.47,22.22 119.22,22.22 v6(119.01,22.01)
  BOTTOM w0.091: v6(119.01,22.01) 118.83,22.19 118.45,22.19 118.29,22.03 JSSD1.23
PCIE_CTX_C_DRX_N11: length 2.3
  TOP w0.091: v6(118.99,24.98) 119.16,25.15 119.39,25.15 CS11.2
  BOTTOM w0.091: JSSD1.35 118.32,25.03 118.51,25.22 118.76,25.22 v6(118.99,24.98)
PCIE_CTX_C_DRX_N12: length 2.2
  TOP w0.091: v6(118.97,27.98) 119.14,28.16 119.4,28.16 CS13.2
  BOTTOM w0.091: v6(118.97,27.98) 118.81,28.15 118.44,28.15 118.32,28.03 JSSD1.47
PCIE_CTX_C_DRX_N13: length 3.6
  BOTTOM w0.091: UT1.Y22 21.67,52.62 21.44,52.39 21.03,52.39 20.94,52.29 20.94,51.55 20.03,50.64 19.58,50.64 CT3.1
PCIE_CTX_C_DRX_N14: length 3.1
  BOTTOM w0.091: CT5.1 19.68,52.97 19.8,52.97 20.03,53.2 20.03,53.46 20.79,54.22 20.81,54.22 20.82,54.22 21.43,54.22 21.67,54.46 UT1.T22
PCIE_CTX_C_DRX_N15: length 2.9
  BOTTOM w0.091: UT1.M22 21.69,56.3 21.45,56.06 21.01,56.06 20.91,56.16 20.83,56.16 19.81,55.15 19.62,55.15 CT353.1
PCIE_CTX_C_DRX_N16: length 2.8
  BOTTOM w0.091: UT1.H22 21.51,58.37 21.09,58.37 20.98,58.27 20.6,58.27 19.92,57.59 19.65,57.59 CT354.1
PCIE_CTX_C_DRX_P1: length 1.5
  TOP w0.091: RN117.1 53.29,53.7 LN19.1 53.29,53.4 53.44,53.26 53.44,52.7 CN73.2
PCIE_CTX_C_DRX_P9: length 2.4
  TOP w0.091: v6(118.95,19.57) 119.21,19.31 119.58,19.31 CS8.2
  BOTTOM w0.091: v6(118.95,19.57) 118.78,19.41 118.44,19.41 118.32,19.52 JSSD1.13
PCIE_CTX_C_DRX_P10: length 2.3
  TOP w0.091: v6(119.01,22.59) 119.18,22.42 119.52,22.42 CS10.2
  BOTTOM w0.091: v6(119.01,22.59) 118.81,22.39 118.44,22.39 118.31,22.52 JSSD1.25
PCIE_CTX_C_DRX_P11: length 2.2
  TOP w0.091: v6(118.99,25.57) 119.21,25.35 119.45,25.35 CS12.2
  BOTTOM w0.091: v6(118.99,25.57) 118.85,25.42 118.43,25.42 118.33,25.52 JSSD1.37
PCIE_CTX_C_DRX_P12: length 2.3
  TOP w0.091: v6(118.97,28.57) 119.17,28.36 119.38,28.36 CS14.2
  BOTTOM w0.091: JSSD1.49 118.28,28.52 118.45,28.35 118.75,28.35 v6(118.97,28.57)
PCIE_CTX_C_DRX_P13: length 3.6
  BOTTOM w0.091: UT1.Y23 21.39,52.72 21.39,52.81 21.35,52.84 21.11,52.84 20.88,52.62 20.88,52.53 20.83,52.47 20.83,52.47 20.74,52.38 20.74,51.63 19.95,50.84 19.69,50.84 CT2.1
PCIE_CTX_C_DRX_P14: length 3.1
  BOTTOM w0.091: UT1.T23 21.36,54.46 21.45,54.55 21.45,54.64 21.41,54.68 21.09,54.68 20.83,54.43 20.7,54.43 20.26,53.98 20.26,53.98 19.82,53.54 19.82,53.28 19.72,53.17 19.6,53.17 CT4.1
PCIE_CTX_C_DRX_P15: length 2.9
  BOTTOM w0.091: CT355.1 19.65,55.35 19.65,55.35 19.66,55.35 19.69,55.35 19.73,55.35 20.75,56.37 20.88,56.37 21.04,56.53 21.39,56.53 21.45,56.47 21.45,56.36 21.38,56.3 UT1.M23
PCIE_CTX_C_DRX_P16: length 2.8
  BOTTOM w0.091: CT356.1 19.62,57.39 20.01,57.39 20.69,58.06 20.95,58.06 21.11,57.9 21.39,57.9 21.47,57.98 21.47,58.06 21.39,58.14 UT1.H23
PCIE_CTX_DRX_N1: length 109.5
  TOP w0.091: CN72.1 53.67,51.78 53.67,51.65 53.78,51.54 54.64,51.54 55.42,52.32 56.42,52.32 56.43,52.33 56.98,52.33 56.99,52.32 60.71,52.32 60.8,52.41 60.8,52.61 v6(60.71,52.7)
  IN3 w0.079: v5(142.96,37.63) 142.74,37.41 142.38,37.41 141.04,38.74 141.04,39.3 140.6,39.75 139.86,39.75 139.57,39.46 138.43,39.46 138.02,39.87 137.25,39.87 137.03,40.1 135.64,40.1 133.28,37.73 132.59,37.73 132.42,37.57 131.14,37.57 130.85,37.86 128.33,37.86 128.05,37.57 124.32,37.57 123.38,36.64 123.08,36.64 122.92,36.79 120.6,36.79 113.75,29.94 112.45,29.94 112.26,29.74 106.51,29.74 106.26,30 101.5,30 100.08,31.42 83.44,31.42 75.83,39.03 69.73,39.03 64.27,44.49 64.27,49.63 61.55,52.35 61.05,52.35 v6(60.71,52.7)
PCIE_CTX_DRX_N9: length 40.5
  TOP w0.091: CS7.1 120.48,19.07 v7(121.22,19.07) 121.82,19.07 122.48,19.73 v6(122.48,20.61)
  IN3 w0.079: v6(122.48,20.61) 122.41,20.54 122.26,20.54 122.14,20.67 122.14,21.15 121.89,21.4 121.89,21.79 122.12,22.01 123.16,22.01 123.74,21.44 126.18,21.44 126.56,21.83 127.92,21.83 129,22.9 129.07,22.9 129.89,23.73 129.89,24.39 130.22,24.72 130.79,24.72 132.27,26.2 139.44,26.2 141.37,28.14 143.45,28.14 143.53,28.21 143.53,28.21 146.29,30.97 146.29,34.09 146.39,34.2 146.51,34.2 v5(146.61,34.11)
  BOTTOM w0.091: UC1.BR2 146.53,36.09 146.99,35.63 146.99,35.05 147.17,34.87 147.17,34.45 146.92,34.2 146.69,34.2 v5(146.61,34.11)
PCIE_CTX_DRX_N10: length 38
  TOP w0.091: v6(120.81,21.93) 120.56,22.19 120.43,22.19 CS9.1
  IN3 w0.079: v5(146.53,37.63) 146.44,37.54 146.34,37.54 146.06,37.25 146.06,36.69 146.36,36.38 146.36,36 146.13,35.77 145.12,35.77 144.41,35.07 144.41,31.2 143.28,30.06 141.35,30.06 138.86,27.57 131.65,27.57 130.72,26.64 130.72,26.64 130.32,26.25 129.51,25.91 128.92,25.67 128.89,25.66 126.87,25.66 126.15,24.93 124.4,24.93 123.67,24.21 122.68,24.21 122.27,23.8 122.26,23.8 121.98,23.51 120.61,23.51 120.14,23.04 120.14,22.42 120.43,22.13 120.62,22.13 v6(120.81,21.93)
PCIE_CTX_DRX_N11: length 39.2
  TOP w0.091: CS11.1 120.36,25.12 120.63,25.12 v6(120.92,24.82)
  IN3 w0.079: v6(120.92,24.82) 121.12,25.03 121.8,25.03 122.41,25.64 123.91,25.64 124.06,25.49 126.15,25.49 126.71,26.05 128.77,26.05 130.16,26.63 130.48,26.94 131.13,27.6 131.13,27.6 131.49,27.95 136.13,27.95 136.82,28.64 136.82,29.54 137.7,30.42 140.3,30.42 140.33,30.45 143,30.45 143.98,31.43 143.98,32.61 143.77,32.82 143.1,32.82 v5(143.03,32.89)
  BOTTOM w0.076: 147.41,34.5 147.43,34.52 147.43,35.13 147.32,35.24 147.32,35.67 147.44,35.79 147.44,36.54 147.47,36.58 147.47,36.67 147.36,36.94 147.36,37.15 147.54,37.32 147.7,37.32 147.84,37.47 UC1.BN4
  BOTTOM w0.091: v5(143.03,32.89) 143.11,32.8 143.18,32.8 143.54,33.16 143.67,33.16 143.68,33.17 v7(143.9,33.17) 144.12,33.17 144.14,33.16 144.22,33.16 144.97,32.41 145.42,32.41 145.43,32.39 145.87,32.39 147.41,33.94 147.41,34.5
PCIE_CTX_DRX_N12: length 34.8
  TOP w0.091: v6(120.76,27.98) 120.58,28.16 120.33,28.16 CS13.1
  IN3 w0.079: v5(143.47,31.8) 143.4,31.88 142.79,31.88 142.79,31.88 142.14,31.88 141.29,31.03 140.09,31.03 140.06,31 137.46,31 136.51,30.05 132.98,30.05 131.47,28.54 131.24,28.54 130.1,27.39 130.09,27.39 129.85,27.15 129.55,27.02 129.53,27.01 128.95,26.77 128.93,26.76 128.62,26.64 125.38,26.64 124.8,27.22 122.56,27.22 121.61,28.16 120.94,28.16 v6(120.76,27.98)
  BOTTOM w0.076: 148.16,34.01 148.16,35.71 148.1,35.77 UC1.BN2 ; 148.18,33.99 148.18,33.97
  BOTTOM w0.091: v5(143.47,31.8) 143.69,31.8 143.9,31.59 146.26,31.59 v7(146.58,31.91) 147.37,32.69 147.39,32.69 147.8,33.11 147.8,33.13 148.18,33.5 148.18,33.97 ; 148.16,34.01 148.18,33.99
PCIE_CTX_DRX_N13: length 171.6
  IN3 w0.079: v5(149.88,33.23) 149.79,33.33 149.7,33.33 149.59,33.21 149.59,32.71 149.36,32.48 149.36,31.1 150.29,30.17 150.29,29.45 151.43,28.31 151.43,23.21 150.46,22.24 150.46,21.12 149.89,20.55 149.2,20.55 148.58,19.93 141.13,19.93 140.84,19.63 140.84,18.28 140,17.45 138.46,17.45 138.46,17.45 133.24,17.45 133.2,17.49 126.32,17.49 125.78,18.02 124.88,18.02 124.39,17.54 120.15,17.54 120.02,17.67 114.24,17.67 111.38,20.53 104.44,20.53 104.22,20.76 96.23,20.76 95.77,21.22 92.02,21.22 91.56,20.76 89.76,20.76 89.57,20.94 87.27,20.94 87.12,20.79 81.96,20.79 78.1,24.66 78.1,30.34 76.12,32.31 73.74,32.31 73.58,32.47 71.59,32.47 71.34,32.71 70.38,32.71 65.28,37.81 64.79,37.81 62.96,39.65 62.96,40.33 60.1,43.18 58.25,43.18 54.65,46.78 47.56,46.78 47.39,46.96 45.64,46.96 44.08,48.52 40.22,48.52 39.33,49.41 25.8,49.41 24.69,50.53 20.4,50.53 20.22,50.7 19.06,50.7 v5(18.88,50.52)
  BOTTOM w0.076: 148.39,33.99 148.39,36.25 148.14,36.5 148.14,37.04 UC1.BM4
  BOTTOM w0.091: v5(149.88,33.23) 149.09,33.23 v7(148.6,33.72) 148.39,33.94 148.39,33.99
PCIE_CTX_DRX_N14: length 168.2
  IN3 w0.079: v5(149.55,34.22) 149.46,34.31 149.4,34.31 149.01,33.91 149.01,32.98 148.77,32.74 148.77,30.84 149.57,30.05 149.57,30.04 149.59,30.02 149.59,21.87 148.24,20.52 140.09,20.52 139.38,19.81 139.38,19.13 138.34,18.09 126.75,18.09 126.2,18.63 124.66,18.63 124.15,18.12 120.77,18.12 120.61,18.29 114.53,18.29 111.14,21.68 97.36,21.68 96.79,22.24 91.99,22.24 91.22,21.47 90.08,21.47 89.55,22 85.75,22 85.59,21.84 81.76,21.84 78.68,24.92 78.68,30.61 76.4,32.9 74.83,32.9 74.43,33.3 70.62,33.3 65.53,38.39 65.04,38.39 63.54,39.89 63.54,40.57 60.15,43.96 59.21,43.96 58.33,44.84 57.73,44.84 55.21,47.37 47.93,47.37 47.76,47.54 45.88,47.54 44.32,49.1 42,49.1 41.59,49.51 40.05,49.51 39.57,49.99 26.14,49.99 25.02,51.11 21.16,51.11 19.35,52.92 19.05,52.92 v5(18.88,52.75)
  BOTTOM w0.076: 148.74,35.04 148.74,35.05 148.74,35.46 148.74,35.46 148.73,35.5 148.73,35.84 148.9,36.27 UC1.BL2
  BOTTOM w0.091: v5(149.55,34.22) 149,34.22 148.81,34.42 148.81,34.78 148.74,34.84 148.74,35.04
PCIE_CTX_DRX_N15: length 178
  IN3 w0.079: v5(150.58,33.95) 150.69,33.85 150.84,33.85 151.26,33.42 151.26,32.69 152.01,31.94 152.01,21.79 150.15,19.93 149.42,19.93 147.41,17.92 145.71,17.92 145.27,17.48 143.47,17.48 143.4,17.54 141.02,17.54 140.34,16.87 138.71,16.87 133,16.87 132.96,16.9 126.07,16.9 125.54,17.44 125.12,17.44 124.64,16.96 122.46,16.96 122.36,16.85 116.64,16.85 116.56,16.93 116.08,16.93 115.73,16.58 114.45,16.58 111.11,19.92 103.81,19.92 103.59,20.14 95.91,20.14 95.41,20.64 92.27,20.64 91.43,19.8 88.28,19.8 88.03,20.05 81.86,20.05 77.51,24.4 77.51,30.04 75.84,31.71 73.23,31.71 73.18,31.77 71.66,31.77 71.55,31.88 71.35,31.88 71.1,32.13 70.14,32.13 65.04,37.23 64.55,37.23 62.37,39.41 62.37,40.09 59.86,42.6 58.01,42.6 54.41,46.2 47.24,46.2 47.06,46.37 45.4,46.37 43.84,47.93 39.91,47.93 39.02,48.82 25.53,48.82 24.42,49.94 18.64,49.94 18.37,50.21 18.37,53.86 19.23,54.72 19.23,54.98 19.14,55.07 18.96,55.07 v5(18.88,54.99)
  BOTTOM w0.076: v5(150.58,33.95) 150.49,33.86 150.43,33.86 150.33,33.95 150.33,34.07 150,34.4 150,34.9 149.58,35.32 149.58,35.67 149.42,35.82 149.38,35.93 149.38,36.14 149.41,36.18 149.41,36.5 149.36,36.56 149.36,36.77 149.5,36.92 149.5,37.31 149.32,37.48 149.12,37.48 UC1.BL4
PCIE_CTX_DRX_N16: length 182.8
  IN3 w0.079: v5(18.88,57.78) 18.83,57.74 18.83,57.62 18.95,57.51 19.36,57.51 19.57,57.29 19.57,56.8 17.98,55.22 17.98,49.93 18.43,49.48 21.01,49.48 22.05,48.44 38.66,48.44 39.55,47.55 43.68,47.55 45.3,45.93 46.74,45.93 47.2,45.46 54.61,45.46 57.85,42.21 58.73,42.21 65.02,35.93 65.58,35.93 70.62,30.89 76.12,30.89 77.13,29.88 77.13,24.23 81.72,19.64 87.89,19.64 88.11,19.42 93.17,19.42 93.35,19.6 94.92,19.6 94.92,19.6 95.32,19.6 95.43,19.71 101.4,19.71 102.83,18.28 102.84,18.28 103.55,17.56 112.86,17.56 114.33,16.09 121.7,16.09 121.81,16.2 122.22,16.2 122.22,16.2 122.46,16.2 122.71,16.2 122.79,16.2 123.33,15.66 129.27,15.66 130.02,14.91 132.41,14.91 133.23,15.72 134.72,15.72 134.81,15.63 136.94,15.63 137.09,15.78 138.55,15.78 138.65,15.68 143.21,15.68 143.9,16.37 144.87,16.37 145.17,16.68 145.23,16.68 146.09,17.54 147.57,17.54 148.86,18.83 149.54,18.83 149.81,19.1 150.26,19.1 150.64,19.48 151.14,19.48 151.45,19.8 151.45,20.01 152.4,20.95 152.4,32.44 151.65,33.19 151.65,33.59 150.79,34.45 150.72,34.45 v5(150.61,34.34)
  BOTTOM w0.076: UC1.BJ4 149.86,37.21 149.86,36.8 149.91,36.75 149.91,36.59 149.87,36.55 149.87,35.84 149.79,35.76 149.79,35.44 150.18,35.05 150.18,34.63 150.35,34.45 150.5,34.45 v5(150.61,34.34)
PCIE_CTX_DRX_P1: length 109.4
  TOP w0.091: CN73.1 53.47,51.77 53.47,51.56 53.69,51.34 54.73,51.34 55.51,52.11 v7(56.71,52.11) 60.51,52.11 v6(60.71,51.91)
  IN3 w0.079: v6(60.71,51.91) 60.96,52.16 60.97,52.15 61.47,52.15 64.07,49.55 64.07,44.41 69.65,38.83 75.75,38.83 83.36,31.22 100,31.22 101.42,29.8 106.17,29.8 106.43,29.54 112.34,29.54 112.54,29.74 113.83,29.74 120.69,36.59 122.84,36.59 122.99,36.44 123.47,36.44 124.4,37.37 128.13,37.37 128.41,37.66 130.77,37.66 131.06,37.37 132.5,37.37 132.67,37.53 133.36,37.53 135.73,39.9 136.94,39.9 137.17,39.67 137.94,39.67 138.35,39.26 139.65,39.26 139.94,39.55 140.52,39.55 140.84,39.22 140.84,38.66 142.29,37.21 142.74,37.21 v5(142.96,36.98)
PCIE_CTX_DRX_P9: length 40.5
  TOP w0.091: v6(121.75,20.6) 121.75,20.47 121.97,20.25 122.19,20.25 122.28,20.16 122.28,19.81 121.76,19.3 120.51,19.3 CS8.1
  IN3 w0.079: v6(121.75,20.6) 121.94,20.79 121.94,21.07 121.69,21.31 121.69,21.87 122.03,22.21 123.25,22.21 123.82,21.64 126.09,21.64 126.48,22.03 127.84,22.03 128.92,23.11 128.98,23.11 129.69,23.82 129.69,24.47 130.11,24.89 130.17,24.92 130.71,24.92 132.19,26.4 139.35,26.4 141.29,28.34 143.37,28.34 143.44,28.41 143.45,28.41 146.08,31.05 146.08,34.18 146.31,34.4 146.52,34.4 v5(146.61,34.49)
  BOTTOM w0.091: UC1.BR1 146.53,35.81 146.41,35.92 146.25,35.92 146.17,35.85 146.17,35.57 146.4,35.34 146.71,35.34 146.79,35.26 146.79,34.97 146.97,34.78 146.97,34.53 146.84,34.4 146.7,34.4 v5(146.61,34.49)
PCIE_CTX_DRX_P10: length 37.9
  TOP w0.091: v6(120.79,22.62) 120.58,22.41 120.42,22.41 CS10.1
  IN3 w0.079: v6(120.79,22.62) 120.79,22.42 120.7,22.33 120.51,22.33 120.34,22.5 120.34,22.95 120.7,23.31 122.06,23.31 122.76,24.01 123.76,24.01 124.48,24.73 126.23,24.73 126.96,25.46 128.93,25.46 128.99,25.48 129.03,25.5 129.27,25.6 130.44,26.08 130.8,26.44 131.73,27.37 138.94,27.37 141.43,29.86 143.36,29.86 144.61,31.11 144.61,34.99 145.2,35.57 146.21,35.57 146.56,35.92 146.56,36.07 146.56,36.08 146.56,36.46 146.26,36.77 146.26,37.17 146.43,37.34 146.61,37.34 146.72,37.23 146.72,37.1 146.61,36.98 v5(146.53,36.98)
PCIE_CTX_DRX_P11: length 39.2
  TOP w0.091: CS12.1 120.36,25.32 120.6,25.32 v6(120.93,25.65)
  IN3 w0.079: v5(143.03,32.51) 143.13,32.61 143.41,32.61 143.41,32.62 143.69,32.62 143.78,32.52 143.78,31.51 142.91,30.65 140.25,30.65 140.22,30.62 137.62,30.62 136.62,29.62 136.62,28.73 136.04,28.15 131.4,28.15 130.93,27.68 130.93,27.68 130.34,27.09 130.34,27.09 130.05,26.8 128.73,26.25 126.63,26.25 126.07,25.69 124.15,25.69 124,25.84 122.33,25.84 121.71,25.23 121.04,25.23 121.04,25.23 120.73,25.23 120.68,25.28 120.68,25.4 v6(120.93,25.65)
  BOTTOM w0.076: 147.61,34.48 147.61,34.5 147.59,34.52 147.59,35.2 147.48,35.31 147.48,35.61 147.6,35.72 147.6,36.48 147.64,36.51 147.64,36.7 147.53,36.97 147.53,37.08 147.61,37.16 147.77,37.16 147.84,37.08 UC1.BN3
  BOTTOM w0.091: 147.61,34.48 147.61,33.85 145.95,32.19 v7(145.15,32.19) 145.15,32.19 144.9,32.19 144.14,32.95 143.62,32.95 143.27,32.6 143.11,32.6 v5(143.03,32.51)
PCIE_CTX_DRX_P12: length 34.7
  TOP w0.091: v6(120.76,28.56) 120.57,28.37 120.33,28.37 CS14.1
  IN3 w0.079: v5(143.47,32.19) 143.36,32.08 142.06,32.08 141.21,31.23 140,31.23 139.98,31.2 137.37,31.2 136.42,30.25 132.9,30.25 131.38,28.74 131.16,28.74 130.35,27.93 130.35,27.92 129.97,27.54 129.95,27.53 129.74,27.32 129.47,27.2 129.45,27.2 128.87,26.96 128.85,26.95 128.58,26.84 125.47,26.84 124.88,27.42 122.64,27.42 121.76,28.3 121.76,28.3 121.7,28.36 120.97,28.36 v6(120.76,28.56)
  BOTTOM w0.076: UC1.BN1 147.95,35.68 147.99,35.64 147.99,34.01 147.98,33.99
  BOTTOM w0.091: 147.98,33.99 147.98,33.59 v7(147.43,33.05) 146.64,32.25 146.62,32.25 146.16,31.79 143.99,31.79 143.78,32 143.78,32.09 143.96,32.27 143.96,32.39 143.88,32.47 143.75,32.47 v5(143.47,32.19)
PCIE_CTX_DRX_P13: length 171.6
  IN3 w0.079: v5(18.88,51.07) 19.05,50.9 20.31,50.9 20.48,50.73 24.77,50.73 25.89,49.61 39.41,49.61 40.3,48.72 44.16,48.72 45.72,47.16 47.47,47.16 47.65,46.98 54.74,46.98 58.34,43.38 60.19,43.38 63.16,40.41 63.16,39.73 64.88,38.01 65.37,38.01 70.46,32.92 71.42,32.92 71.67,32.67 73.67,32.67 73.83,32.51 76.21,32.51 78.3,30.42 78.3,24.75 82.05,20.99 87.03,20.99 87.19,21.14 89.65,21.14 89.84,20.96 91.47,20.96 91.94,21.42 95.85,21.42 96.32,20.96 104.3,20.96 104.53,20.73 111.46,20.73 114.33,17.87 120.1,17.87 120.23,17.74 124.31,17.74 124.79,18.23 125.86,18.23 126.4,17.69 133.28,17.69 133.32,17.65 138.38,17.65 139.92,17.65 140.63,18.37 140.63,19.72 141.05,20.13 148.5,20.13 149.12,20.75 149.8,20.75 150.26,21.21 150.26,22.33 151.23,23.3 151.23,28.23 150.09,29.37 150.09,30.09 149.16,31.01 149.16,32.56 149.39,32.79 149.39,33.3 149.62,33.53 149.79,33.53 v5(149.88,33.62)
  BOTTOM w0.076: 148.55,36.34 148.55,34.06 ; UC1.BM3 148.3,36.76 148.3,36.94 148.4,37.03 148.6,37.03
  BOTTOM w0.091: v5(149.88,33.62) 149.7,33.44 149.17,33.44 148.55,34.06 ; 148.55,36.34 148.69,36.47 148.69,36.94 148.6,37.03
PCIE_CTX_DRX_P14: length 168.2
  IN3 w0.079: v5(149.55,34.6) 149.45,34.51 149.31,34.51 148.8,34 148.8,33.06 148.57,32.83 148.57,30.76 149.37,29.97 149.37,29.96 149.39,29.94 149.39,21.95 148.16,20.72 140,20.72 139.18,19.9 139.18,19.21 138.25,18.29 126.83,18.29 126.29,18.83 124.57,18.83 124.07,18.33 120.86,18.33 120.69,18.49 114.61,18.49 111.23,21.88 97.44,21.88 96.88,22.44 91.91,22.44 91.13,21.67 90.16,21.67 89.63,22.2 85.67,22.2 85.51,22.04 81.84,22.04 78.88,25 78.88,30.7 76.48,33.1 74.92,33.1 74.52,33.5 70.71,33.5 65.61,38.59 65.12,38.59 63.74,39.97 63.74,40.65 60.24,44.16 59.3,44.16 58.41,45.04 57.82,45.04 55.29,47.57 48.02,47.57 47.84,47.74 45.96,47.74 44.4,49.3 42.08,49.3 41.68,49.71 40.14,49.71 39.65,50.19 26.23,50.19 25.11,51.31 21.24,51.31 19.43,53.12 19.06,53.12 v5(18.88,53.31)
  BOTTOM w0.076: UC1.BL1 149.1,35.68 149.23,35.56 149.23,35.45 149.18,35.4 148.98,35.4 148.93,35.34 148.93,35.13 148.94,35.12 148.94,35.06 148.95,35.05 148.95,35.04
  BOTTOM w0.091: 148.95,35.04 148.95,34.93 149.01,34.86 149.01,34.5 149.09,34.42 149.18,34.42 149.25,34.49 149.25,34.81 149.34,34.9 149.45,34.9 149.55,34.8 v5(149.55,34.6)
PCIE_CTX_DRX_P15: length 177.9
  IN3 w0.079: v5(18.88,55.54) 18.88,55.37 18.98,55.27 19.22,55.27 19.43,55.06 19.43,54.64 18.57,53.77 18.57,50.29 18.72,50.14 24.5,50.14 25.62,49.02 39.1,49.02 39.99,48.13 43.92,48.13 45.48,46.57 47.14,46.57 47.32,46.4 54.5,46.4 58.1,42.8 59.94,42.8 62.57,40.17 62.57,39.49 64.64,37.43 65.13,37.43 70.22,32.33 71.18,32.33 71.43,32.08 71.63,32.08 71.75,31.97 73.26,31.97 73.31,31.91 75.92,31.91 77.71,30.12 77.71,24.48 81.94,20.25 88.11,20.25 88.36,20 91.35,20 92.18,20.84 95.49,20.84 95.99,20.34 103.67,20.34 103.9,20.12 111.19,20.12 114.53,16.78 115.65,16.78 116,17.13 116.64,17.13 116.72,17.06 122.27,17.06 122.37,17.16 124.55,17.16 125.04,17.64 125.62,17.64 126.16,17.1 133.04,17.1 133.08,17.07 138.62,17.07 140.26,17.07 140.93,17.74 143.48,17.74 143.55,17.68 145.19,17.68 145.63,18.12 147.33,18.12 149.33,20.13 150.07,20.13 151.81,21.87 151.81,31.86 151.06,32.61 151.06,33.34 150.75,33.65 150.66,33.65 v5(150.58,33.57)
  BOTTOM w0.076: v5(150.58,33.57) 150.5,33.65 150.34,33.65 150.13,33.87 150.13,33.99 149.84,34.28 149.84,34.34 149.84,34.83 149.41,35.26 149.41,35.6 149.28,35.73 149.22,35.9 149.22,36.21 149.25,36.24 149.25,36.44 149.19,36.49 149.19,36.84 149.33,36.98 149.33,37.24 149.25,37.32 149.1,37.32 149.1,37.32 148.93,37.32 148.86,37.24 148.86,37.1 UC1.BL3
PCIE_CTX_DRX_P16: length 182.9
  IN3 w0.079: v5(18.88,57.22) 18.92,57.27 19.29,57.27 19.37,57.19 19.37,56.89 17.78,55.3 17.78,49.84 18.35,49.28 20.93,49.28 21.97,48.24 38.58,48.24 39.47,47.35 43.59,47.35 45.22,45.72 46.65,45.72 47.12,45.26 54.53,45.26 57.77,42.01 58.65,42.01 64.93,35.73 65.5,35.73 70.54,30.69 76.04,30.69 76.93,29.8 76.93,24.14 81.63,19.44 87.8,19.44 88.02,19.22 93.26,19.22 93.44,19.4 94.84,19.4 94.84,19.39 95.4,19.39 95.52,19.51 101.32,19.51 102.75,18.08 102.75,18.08 103.47,17.36 112.77,17.36 114.24,15.89 121.79,15.89 121.89,16 122.31,16 122.46,16 122.71,16 123.25,15.46 129.19,15.46 129.94,14.71 132.5,14.71 133.31,15.52 134.64,15.52 134.73,15.43 137.02,15.43 137.17,15.58 138.47,15.58 138.56,15.48 143.29,15.48 143.98,16.17 144.95,16.17 145.26,16.48 145.31,16.48 146.18,17.34 147.65,17.34 148.94,18.63 149.62,18.63 149.89,18.9 150.34,18.9 150.73,19.28 151.22,19.28 151.65,19.72 151.65,19.93 152.6,20.87 152.6,32.52 151.85,33.27 151.85,33.68 150.87,34.65 150.69,34.65 v5(150.61,34.72)
  BOTTOM w0.076: UC1.BJ3 150.37,37.07 150.37,37.17 150.27,37.28 150.16,37.28 150.03,37.14 150.03,36.87 150.07,36.82 150.07,36.52 150.04,36.48 150.04,35.77 149.96,35.69 149.96,35.51 150.35,35.12 150.35,34.69 150.42,34.62 150.51,34.62 v5(150.61,34.72)
PCIE_CTX_L_DRX_N1: length 2.7
  TOP w0.091: v6(53.82,55.81) 53.63,55.62 53.63,55.08 LN19.3 53.92,54.79 RN118.2
  BOTTOM w0.091: v6(53.82,55.81) 53.61,56.02 53.61,56.29 53.76,56.45 JNGFF1.47
PCIE_CTX_L_DRX_P1: length 2.7
  TOP w0.091: RN117.2 53.16,54.78 LN19.2 53.43,55.05 53.43,55.62 v6(53.24,55.81)
  BOTTOM w0.091: v6(53.24,55.81) 53.4,55.97 53.4,56.3 53.26,56.44 JNGFF1.49
PCIE_RCOMPN: length 1.7
  TOP w0.203: v2(140.35,38.8) 140.35,38.95 140.55,39.15 RC126.2
  IN1 w0.203: v4(139.91,38.8) v2(140.35,38.8)
  IN3 w0.203: v5(140.32,39.03) 140.14,39.03 v4(139.91,38.8)
PCIE_RCOMPP: length 1.5
  TOP w0.203: v2(140.36,38.24) 140.69,38.57 RC126.1
  IN1 w0.203: v2(140.36,38.24) 140.34,38.26 v4(139.91,38.26)
  IN3 w0.203: v5(140.32,38.38) 140.03,38.38 v4(139.91,38.26)
PCIE_WAKE#: length 197.8
  TOP w0.081: v2(126.82,66.51) v1(128.04,66.51) 129.08,66.51 129.81,67.25 RW10.1 ; v2(60.24,42.88) 60.24,42.9 60.15,42.99 59.65,42.99 RN112.1 59.54,43.3 58.97,43.86 v2(58.97,43.88) ; UE1.A54 40.19,26.18 v2(39.9,25.89)
  IN1 w0.064: v2(58.97,43.88) 58.89,43.96 58.89,44.17 58.82,44.23 58.82,44.23 58.42,44.63 57.53,44.63 56.87,45.3 v4(56.87,47.79) ; v4(38.34,25.34) 38.53,25.53 38.96,25.53 39.32,25.88 39.9,25.88 v2(39.9,25.89) ; v2(126.82,66.51) 126.74,66.44 126.74,65.34 124.5,63.1 124.5,62.64 122.68,60.82 122.68,58.22 124.5,56.4 126.89,56.4 v4(127.3,55.98) ; v2(60.24,42.88) 60.24,42.65 60.1,42.51 60.1,42.08 v2(59.69,41.68) 59.48,41.46 59.48,41.16 59.78,40.86 60.48,40.86 60.9,41.28 65.66,41.28 v4(66.06,40.87)
  IN2 w0.066: v4(66.06,40.87) 66.6,40.87 67.79,39.68 68.95,39.68 70.89,37.75 73.31,37.75 73.86,37.19 76.36,37.19 77.98,35.57 77.98,33.15 78.28,32.85 78.96,32.85 79.05,32.95 92.26,32.95 93.29,33.98 99.31,33.98 100.42,32.88 100.77,32.88 101.36,32.3 107.99,32.3 v4(108.07,32.38) 108.4,32.38 108.73,32.71 109,32.71 110.17,33.88 112.14,33.88 112.64,34.38 115.23,34.38 117.88,37.03 117.88,40.62 120.08,42.81 120.73,42.81 122.09,44.18 122.09,44.83 124.56,47.29 124.56,50.26 125.92,51.63 126.5,51.63 v4(126.9,51.22) ; v4(29.46,51.2) 29.47,51.19 29.47,50.65 30.67,49.45 30.67,47.63 32.36,45.94 32.36,40.32 33.55,39.13 33.55,36.59 32.36,35.39 32.36,34.37 31.46,33.47 31.46,32.35 32.08,31.73 32.57,31.73 33.03,32.19 33.03,32.76 33.31,33.03 34.13,33.03 34.47,32.7 34.47,32.41 34.41,32.35 34.41,32.16 34.42,32.15 34.42,32.05 34.66,31.8 35.15,31.8 36.32,30.63 36.65,30.63 37.46,29.82 37.46,27.56 38.43,26.6 38.43,26.21 38.34,26.13 v4(38.34,25.34)
  IN3 w0.064: v5(127.38,55.51) 127.38,55.58 127.3,55.66 v4(127.3,55.98) ; v5(108.45,32.08) 108.37,32.08 v4(108.07,32.38) ; v5(126.79,50.81) 126.79,51.07 126.9,51.18 v4(126.9,51.22) ; v4(56.87,47.79) 55.92,48.73 55.07,48.73 53.48,50.32 52.55,50.32 51.46,51.41 51.46,51.65 51.09,52.03 49.88,52.03 48.38,53.52 45.68,53.52 45.28,53.36 45.1,53.29 43.84,53.29 43.61,53.06 41.61,53.06 41.12,52.57 40.87,52.57 40.55,52.88 40.48,52.88 40.48,52.89 37.93,52.89 37.12,53.7 36.11,53.7 35.38,52.98 35.38,52.54 34.99,52.14 v5(34.78,52.14) 34.45,52.14 34.23,51.92 32.15,51.92 31.78,51.55 30.18,51.55 29.86,51.23 29.59,51.23 29.56,51.2 v4(29.46,51.2)
  BOTTOM w0.081: v5(108.45,32.08) 108.49,32.04 108.49,30 108.71,29.77 JSSD1.54 ; v5(126.79,50.81) 127.46,51.48 RC102.1 127.74,52.6 127.81,52.67 127.81,55.08 v5(127.38,55.51) ; v5(34.78,52.14) 34.95,51.98 34.95,50.65 34.78,50.48 RT186.2
PCIE_WAKE#_AR: length 5.1
  BOTTOM w0.081: RT293.1 RT186.1 RT188.1 33.89,50.94 33.78,50.82 32.79,50.82 32.64,50.98 32.64,51.17 31.99,51.82 31.99,52.04 31.64,52.39 31.03,52.39 30.94,52.48 UT1.Y2
PCIE_WAKE#_R: length 5.7
  TOP w0.081: v6(132.75,65.02) 132.75,64.94 132.5,64.68 132.05,64.68 131.72,65.02 131.72,67.06 131.53,67.25 RW10.2 131.3,68.2 v1(131.15,68.35)
  BOTTOM w0.081: WL1.29 132.72,64.42 132.72,64.91 132.75,64.94 v6(132.75,65.02)
PD_EE_CLK_L: length 59.6
  TOP w0.102: v2(18.48,35.42) 18.51,35.46 UPD3.6 18.51,35.87 UPD5.6
  IN1 w0.102: v2(18.48,35.42) v4(18.1,35.42) ; v2(25.9,10.65) 25.9,10.28 25.16,9.54 16.42,9.54 16.28,9.4 7.88,9.4 7.27,10.01 7.27,11.17 6.63,11.81 6.63,25.68 6.98,26.02 10.15,26.02 10.52,26.39 v2(15.86,26.39) 16.4,26.93 16.4,28.47 16.06,28.81 16.06,31.71 15.56,32.22 v4(15.56,32.57)
  IN3 w0.102: v4(18.1,35.42) 17.97,35.42 17.54,35.85 16.5,35.85 15.51,34.86 15.51,32.62 v4(15.56,32.57) 15.62,32.64 v5(15.95,32.64)
  BOTTOM w0.102: RPD205.2 16.26,32.64 v5(15.95,32.64)
PD_EE_CLK_L_R: length 1.3
  BOTTOM w0.081: RPD205.1 17.07,32.57 17.19,32.7 UPD1.38
PD_EE_CS#_L: length 39.4
  TOP w0.102: v2(18.64,27.12) v1(18.17,26.65) 16.32,26.65 15.55,27.42 15.55,27.78 15.78,28.01 RPD11.2 15.97,28.02 UPD5.1 15.97,29.96 UPD3.1
  IN1 w0.102: v4(18.68,33.38) 18.43,33.14 18.43,27.33 v2(18.64,27.12) 19.1,27.58 20.58,27.58 22.09,26.08 24.69,26.08 25.81,24.96 26.75,24.96 27.01,24.7 27.01,17.24 27.45,16.8 27.45,10.7 v2(27.4,10.65)
  IN3 w0.102: v5(17.13,33.36) 17.17,33.4 18.66,33.4 v4(18.68,33.38)
  BOTTOM w0.102: UPD1.39 17.4,33.1 v5(17.13,33.36)
PD_EE_MISO_L: length 34.6
  TOP w0.102: v1(19.93,26.05) 20.22,26.34 v2(20.22,27.28) ; UPD3.2 17.24,29.96 UPD5.2 17.24,28.8 16.82,28.38 RPD181.2 RPD12.2 18.02,27.99 v2(18.11,28.08)
  IN1 w0.102: v2(26.9,10.65) 26.9,11.72 26.25,12.37 26.25,24.2 24.6,25.85 21.96,25.85 20.52,27.28 v2(20.22,27.28) 19.81,27.28 19.35,26.81 18.51,26.81 18.11,27.21 v2(18.11,28.08) 18.11,31.7 18.01,31.8 v4(17.93,31.8)
  IN3 w0.102: v4(17.93,31.8) 17.83,31.9 v5(17.2,31.9)
  BOTTOM w0.102: UPD1.36 v5(17.2,31.9)
PD_EE_MOSI_L: length 35.2
  TOP w0.102: v2(25.93,17.82) 26.3,17.82 v1(26.76,18.28) ; v2(19.78,35.86) 19.78,35.87 UPD5.5
  IN1 w0.102: v2(19.78,35.86) 17.58,33.65 v4(17.58,32.32) 17.5,32.24 17.5,30.96 17.81,30.66 17.81,27.19 18.42,26.59 19.44,26.59 19.83,26.98 20.47,26.98 21.82,25.62 24.5,25.62 25.93,24.19 v2(25.93,17.82) 25.93,12.37 26.4,11.9 v2(26.4,10.65)
  IN3 w0.102: v5(17.92,32.3) 17.6,32.3 v4(17.58,32.32)
PD_EE_WP#_L: length 3.1
  TOP w0.081: UPD3.3 18.51,29.96 UPD5.3 18.51,28.14 18.49,28.12 RPD14.2 19.35,27.96 v1(19.55,27.76)
PD_HOLD#_L: length 3.1
  TOP w0.081: UPD3.7 17.24,36.52 UPD5.7 17.24,37.35 16.94,37.64 RPD13.2 17.81,37.84 v1(17.87,37.9)
PD_L_DDM_MUX1_EN: length 44.8
  TOP w0.081: RM36.1 v2(14.46,73.6)
  IN1 w0.064: v2(14.46,73.6) 15.05,73.02 15.49,73.02 17.44,71.07 17.44,66.72 14.6,63.88 14.6,60.77 15.34,60.03 15.34,57.4 16.47,56.27 16.47,45.11 17.36,44.22 17.36,39.33 17.96,38.73 17.96,36.17 17.23,35.44 v4(17.23,35.09)
  IN3 w0.064: v4(17.23,35.09) 17.03,35.3 v5(16.49,35.3)
  BOTTOM w0.081: v5(16.49,35.3) 16.32,35.12 RPD123.1
PD_L_DDM_MUX1_EN_R: length 1.7
  BOTTOM w0.102: UPD1.42 17.23,34.3 17.19,34.34 16.69,34.34 RPD191.1 RPD123.2
PD_L_DRAIN1:
  vias: v1(23.33,30.22) v6(22.64,31.26) v6(22.64,30.22) v6(22.64,29.18) v6(23.94,31.26) v6(23.94,30.22) v6(23.94,29.18)
PD_L_DRAIN2:
  vias: v1(23.48,32.7) v6(22.64,34.21) v6(22.64,33.14) v6(22.64,32.08) v6(23.94,34.21) v6(23.94,33.14) v6(23.94,32.08)
PD_L_GPIO2: length 12.1
  IN1 w0.102: v4(19.61,31.03) 19.85,31.28 19.85,35.32 20.37,35.84 20.37,36.53 v4(20.26,36.64)
  IN3 w0.102: v5(20.68,36.68) 20.63,36.62 20.28,36.62 v4(20.26,36.64) ; v5(22.82,27.95) 22.38,27.95 20.79,29.54 20.79,30.8 20.55,31.03 v4(19.61,31.03)
  BOTTOM w0.102: RPD139.2 v5(20.68,36.68)
PD_L_GPIO4: length 1.2
  BOTTOM w0.102: UPD1.31 17.29,29.9 17.2,29.8 RPD141.1
PD_L_GPIO16: length 16.5
  IN3 w0.102: v5(20.82,35.97) 19.81,35.97 19.49,36.29 15.76,36.29 15.08,35.6 14.6,35.6 14.16,35.17 14.16,29.56 14.74,28.98 15.27,28.98 16.07,29.77 v5(16.07,29.83)
  BOTTOM w0.102: v5(16.07,29.83) 16.09,29.8 RPD141.2 ; UPD1.48 v5(20.82,35.97)
PD_L_GPIO17: length 1.2
  BOTTOM w0.102: RPD139.1 21.22,36.19 UPD1.49
PD_L_GPIO18: length 1.1
  BOTTOM w0.081: UPD1.50 RPD204.1
PD_L_GPIO19: length 2.3
  BOTTOM w0.081: UPD1.53 22.82,35.99 22.13,36.68 RPD204.2
PD_L_USB_MUX1_EN: length 62
  TOP w0.081: RM32.1 v2(20.31,76.63)
  IN1 w0.064: v4(21.21,30.95) 21.23,30.97 21.23,31.51 20.97,31.77 20.97,33.54 21.56,34.14 21.56,35.96 17.87,39.65 17.87,44.05 19.05,45.23 19.05,48.08 17.03,50.1 17.03,56.41 15.75,57.68 15.75,60.95 15.05,61.65 15.05,63.79 17.82,66.56 17.82,66.56 17.85,66.59 17.85,71.32 17.05,72.11 17.05,76.3 17.28,76.54 18.83,76.54 19.09,76.28 19.97,76.28 v2(20.31,76.63)
  IN3 w0.064: v4(21.21,30.95) 21.11,30.85 21.11,29.6 22.41,28.3 23.01,28.3 24.93,26.38 v5(24.93,26.33)
  BOTTOM w0.081: RPD187.1 24.78,26.48 v5(24.93,26.33)
PD_L_USB_MUX1_EN_R: length 2
  BOTTOM w0.102: RPD187.2 RPD190.1 24.17,27.14 23.62,27.69 UPD1.16
PE_CPU: length 5.5
  BOTTOM w0.203: PRZ19.2 PRZ18.1 161.58,17.64 161.31,17.91 160.32,17.91 159.8,18.43 159.8,20.31 159.64,20.48 PUZ01.36
PECI_EC: length 2.5
  TOP w0.081: CE509.2 46.4,31.76 46.48,31.83 RE27.1 47.04,31.6 47.04,31.5 47.73,30.8 UE1.A37
PECI_EC_R: length 159.8
  TOP w0.081: RE27.2 46.81,34.45 49.15,36.79 v1(49.68,36.79) 50.05,36.79 v6(50.57,36.27)
  IN1 w0.064: v4(158.08,34.88) 156.17,34.88 155.5,35.54 154.04,35.54 153.1,36.48 151.71,36.48 149.31,38.88 149.31,39.21 v4(149.19,39.33)
  IN2 w0.066: v6(50.57,36.27) 51.03,36.27 51.36,35.95 55.41,35.95 62.3,29.06 62.3,22.6 62.3,22.6 62.3,22.4 65.28,19.43 65.28,18.42 69.68,14.01 69.68,13.01 71.84,10.86 80.31,10.86 81.82,9.35 94.82,9.35 96.2,10.73 97.36,10.73 99.97,13.34 110.58,13.34 111.02,12.91 119.37,12.91 119.63,12.9 122.15,15.42 123.31,15.42 123.59,15.15 125.82,15.15 128.03,17.36 132.06,17.36 133.26,18.56 138.87,18.56 139.99,19.68 139.99,27.91 139.99,27.91 139.99,29.24 140.64,29.89 143.99,29.89 146.46,32.35 146.46,38.17 146.05,38.58 146.05,38.58 145.95,38.69 145.92,38.71 145.91,38.72 145.74,38.89 145.74,39.08 145.74,39.09 145.74,39.13 145.74,40.9 146.05,41.21 146.05,41.21 146.16,41.32 147.04,41.32 149.02,39.33 v4(149.19,39.33)
  IN3 w0.064: v4(158.08,34.88) 158.41,35.21 v5(158.41,35.42)
  BOTTOM w0.135: UC1.AR1 158.68,35.68 v5(158.41,35.42)
PECI_VREF: length 3.2
  TOP w0.254: UE1.A38 47.23,30.8 47.02,31.02 46.73,31.02 46.59,31.16 46.38,31.16 46.23,31.31 45.74,31.31 45.45,31.6 CE15.1 45.22,31.64 45.1,31.75 RE538.1
PEG_CRX_C_GTX_N5: length 9
  BOTTOM w0.076: UV1.AB9 110.78,56.21 111.22,55.78 111.22,55.47 110.89,55.14 110.89,54.96 112.34,53.51 112.34,53.2 112.04,52.9
  BOTTOM w0.091: CV12.2 113.97,49.98 113.19,50.75 113.19,50.77 112.76,51.21 112.76,51.82 112.04,52.53 112.04,52.9
PEG_CRX_C_GTX_N6: length 8.7
  BOTTOM w0.076: UV1.AC10 109.87,55.29 109.75,55.29 109.68,55.23 109.68,54.98 111.2,53.46 111.2,53.2 110.88,52.88 110.88,52.63 111.59,51.92
  BOTTOM w0.091: CV14.2 113.09,49.1 v7(112.64,49.54) 111.97,50.21 111.97,51.6 111.64,51.92 111.59,51.92
PEG_CRX_C_GTX_N7: length 8
  BOTTOM w0.076: 111.01,50.68 111.01,50.76 111.03,50.78 111.03,51.09 109.57,52.55 109.57,52.94 109.84,53.21 109.84,53.44 109.52,53.77 UV1.AC11
  BOTTOM w0.091: CV16.2 112.14,48.1 111.47,48.77 111.45,48.77 111.01,49.21 111.01,50.68
PEG_CRX_C_GTX_N8: length 9
  BOTTOM w0.076: UV1.AB12 108.33,53.77 108.7,53.4 108.7,53.18 108.39,52.87 108.39,52.58 108.38,52.56 109.88,51.06 109.88,50.94
  BOTTOM w0.091: 109.88,50.94 109.87,50.93 109.87,48.7 v7(110.71,47.86) 111.29,47.27 CV18.2
PEG_CRX_C_GTX_P5: length 9
  BOTTOM w0.076: 111.85,52.94 112.17,53.27 112.17,53.44 110.73,54.89 110.73,55.21 111.05,55.54 111.05,55.71 110.71,56.05 110.53,56.05 110.45,55.97 110.45,55.85 UV1.AC9
  BOTTOM w0.091: CV11.2 113.8,49.86 v7(112.85,50.81) 112.55,51.1 112.55,51.73 111.85,52.44 111.85,52.94
PEG_CRX_C_GTX_P6: length 8.7
  BOTTOM w0.076: UV1.AB10 109.52,54.91 111.03,53.39 111.03,53.27 110.72,52.95 110.72,52.56 111.56,51.72
  BOTTOM w0.091: CV13.2 112.97,48.92 112.69,49.2 112.67,49.2 112.26,49.61 112.26,49.63 111.76,50.13 111.76,51.51 111.56,51.72
PEG_CRX_C_GTX_P7: length 8
  BOTTOM w0.076: 111.21,50.68 111.21,50.69 111.21,50.7 111.19,50.7 111.19,50.7 111.19,50.71 111.2,50.71 111.2,51.16 109.73,52.62 109.73,52.87 110.01,53.15 110.01,53.51 109.68,53.84 109.68,54.08 109.74,54.14 109.84,54.14 UV1.AD11
  BOTTOM w0.091: CV15.2 112.29,48.24 v7(111.41,49.12) 111.21,49.32 111.21,50.68
PEG_CRX_C_GTX_P8: length 8.9
  BOTTOM w0.076: UV1.AC12 108.68,54.11 108.55,54.11 108.49,54.06 108.49,53.84 108.86,53.47 108.86,53.11 108.56,52.8 108.56,52.65 110.07,51.13 110.07,51.06
  BOTTOM w0.091: 110.07,51.06 110.07,48.78 110.65,48.2 110.67,48.2 111.05,47.82 111.05,47.8 111.43,47.42 CV17.2
PEG_CRX_GTX_N5: length 36
  IN1 w0.079: v6(115.78,48.16) 115.78,47.62 115.99,47.41 116.65,47.41 116.65,47.41 116.71,47.41 116.78,47.34 116.79,47.34 118.67,45.46 119.14,45.46 119.15,45.45 119.74,45.45 121.67,43.53 122.86,43.53 124.29,42.1 124.29,41.74 124.29,41.74 124.29,41.12 124.68,40.73 125.82,40.73 126.61,41.53 130.36,41.53 131.49,40.4 137.14,40.4 137.8,41.06 140.96,41.06 141.07,41.16 141.07,41.17 141.4,41.5 141.41,41.5 141.45,41.54 142.69,41.54 143.12,41.11 143.3,41.11 143.37,41.04 143.53,41.04 143.62,41.13 v6(143.62,41.23)
  BOTTOM w0.091: v6(143.62,41.23) 143.86,40.98 UC1.BW9 ; CV12.1 114.62,49.3 114.98,48.95 114.98,48.73 115.55,48.16 v6(115.78,48.16)
PEG_CRX_GTX_N6: length 41.5
  IN1 w0.079: v6(144.48,39.38) 144.48,39.33 144.69,39.12 144.86,39.12 144.95,39.21 144.95,40.81 143.83,41.93 141.29,41.93 141.19,41.83 141.19,41.83 140.8,41.44 137.64,41.44 137.02,40.81 132.82,40.81 132.62,41.02 132.09,41.02 131.19,41.91 125.23,41.91 123.15,43.99 121.75,43.99 118.63,47.11 117.63,47.11 117.62,47.12 116.95,47.79 116.81,47.79 116.65,47.96 116.64,47.96 116.59,48.02 116.59,48.22 116.5,48.31 116.28,48.31 116.21,48.38 v6(116.21,48.6)
  BOTTOM w0.091: UC1.BU6 144.94,39.13 144.68,39.38 v6(144.48,39.38) ; v6(116.21,48.6) 116.14,48.53 116.14,48.37 116.21,48.3 116.5,48.3 116.57,48.24 116.32,48 116.18,48 115,46.81 114.64,46.81 114.11,47.33 114.11,48.03 113.8,48.35 CV14.1
PEG_CRX_GTX_N7: length 42.4
  IN1 w0.079: v6(113,47.08) 112.6,47.48 112.6,48.06 113.33,48.8 114.85,48.8 115.26,49.21 117.09,49.21 117.39,48.91 117.39,48.47 117.95,47.91 119.07,47.91 121.71,45.27 123,45.27 124.49,43.78 124.49,43.77 125.57,42.69 131.52,42.69 132.41,41.8 133.12,41.8 133.5,42.18 136.35,42.18 136.7,42.53 136.86,42.53 137.91,42.53 138.22,42.22 140.44,42.22 140.97,42.76 143.45,42.76 143.45,42.76 144.11,42.76 145.73,41.14 145.73,40.09 145.95,39.87 146.19,39.87 v6(146.29,39.97)
  BOTTOM w0.091: CV16.1 112.89,47.42 113,47.3 v6(113,47.08) ; v6(146.29,39.97) 146,39.68 UC1.BT7
PEG_CRX_GTX_N8: length 40.3
  IN1 w0.079: v6(112.27,45.53) 112.27,46.07 112.62,46.42 113.67,46.42 114,46.75 116.55,46.75 118.43,44.87 118.49,44.87 120.5,42.87 122.63,42.87 123.61,41.89 123.61,40.97 124.43,40.15 126.06,40.15 126.86,40.94 130.12,40.94 131.24,39.81 137.39,39.81 138.05,40.47 141.64,40.47 141.69,40.52 141.88,40.52 142.08,40.72 142.67,40.72 142.86,40.52 143.07,40.52 143.2,40.39 143.2,40.39 143.43,40.16 143.43,40.16 143.49,40.11 143.7,40.11 143.98,40.39 144.26,40.39 144.51,40.64 v6(144.51,40.65)
  BOTTOM w0.091: v6(112.27,45.53) 112.27,45.65 112.37,45.75 112.49,45.75 112.59,45.84 112.59,45.96 112.25,46.29 112.25,46.31 111.97,46.59 CV18.1 ; UC1.BU9 144.84,40.98 v6(144.51,40.65)
PEG_CRX_GTX_P5: length 36
  IN1 w0.079: v6(143.62,40.64) 143.57,40.64 143.38,40.84 143.29,40.84 143.22,40.91 143.04,40.91 142.61,41.34 141.54,41.34 141.49,41.3 141.49,41.3 141.27,41.08 141.27,41.08 141.05,40.85 137.89,40.85 137.24,40.21 137.24,40.21 137.23,40.2 131.4,40.2 130.28,41.32 126.7,41.32 125.9,40.53 124.59,40.53 124.09,41.03 124.09,41.66 124.09,41.66 124.09,42.02 122.78,43.33 121.58,43.33 119.66,45.25 119.07,45.25 119.06,45.26 118.59,45.26 116.71,47.14 116.7,47.14 116.63,47.21 116.57,47.21 116.57,47.21 115.91,47.21 v6(115.37,47.75)
  BOTTOM w0.091: v6(143.62,40.64) 143.62,40.59 143.89,40.33 UC1.BW8 ; v6(115.37,47.75) 115.37,48.05 114.77,48.65 114.77,48.86 114.48,49.15 114.47,49.15 114.46,49.16 CV11.1
PEG_CRX_GTX_P6: length 41.6
  IN1 w0.079: v6(144.5,38.78) 144.51,38.79 144.81,38.79 145.15,39.13 145.15,40.9 143.92,42.13 141.21,42.13 141.11,42.03 141.1,42.03 140.72,41.64 137.56,41.64 136.93,41.01 132.9,41.01 132.7,41.22 132.17,41.22 131.28,42.11 125.31,42.11 123.23,44.19 121.83,44.19 118.71,47.31 117.71,47.31 117.7,47.32 117.03,47.99 116.9,47.99 116.79,48.1 v6(116.79,48.6)
  BOTTOM w0.091: v6(116.79,48.6) 116.79,48.17 116.41,47.79 116.27,47.79 115.09,46.61 114.53,46.61 v7(114.21,46.93) 113.91,47.23 113.91,47.95 113.59,48.27 CV13.1 ; v6(144.5,38.78) 144.5,38.77 144.59,38.77 144.68,38.68 144.68,38.55 144.85,38.38 UC1.BU5
PEG_CRX_GTX_P7: length 42.3
  IN1 w0.079: v6(146.32,39.32) 146.32,39.39 146.13,39.57 146.13,39.57 146.03,39.67 145.86,39.67 145.53,40 145.53,41.05 144.03,42.55 143.37,42.55 143.37,42.56 141.06,42.56 140.52,42.02 138.13,42.02 137.83,42.33 136.78,42.33 136.44,41.98 133.58,41.98 133.2,41.6 132.33,41.6 131.43,42.49 125.49,42.49 122.91,45.07 121.63,45.07 118.99,47.7 117.86,47.7 117.18,48.38 117.18,48.83 117,49.01 115.34,49.01 115.19,48.86 115.19,48.86 114.93,48.6 113.42,48.6 112.8,47.98 112.8,47.57 112.88,47.49 v6(113.42,47.49)
  BOTTOM w0.091: CV15.1 112.97,47.62 113.1,47.49 v6(113.42,47.49) ; UC1.BT6 145.86,39.18 146.01,39.32 v6(146.32,39.32)
PEG_CRX_GTX_P8: length 40.3
  IN1 w0.079: v6(112.86,45.53) 112.86,45.75 112.79,45.82 112.54,45.82 112.47,45.89 112.47,45.99 112.7,46.22 113.75,46.22 114.08,46.55 116.47,46.55 118.34,44.67 118.41,44.67 120.42,42.67 122.55,42.67 123.41,41.81 123.41,40.89 124.35,39.95 126.14,39.95 126.94,40.74 130.03,40.74 131.16,39.61 137.3,39.61 137.47,39.61 138.13,40.27 141.72,40.27 141.77,40.32 141.97,40.32 142.16,40.52 142.58,40.52 142.78,40.32 142.98,40.32 143.11,40.19 143.11,40.19 143.35,39.96 143.35,39.96 143.4,39.91 143.78,39.91 144.07,40.19 144.26,40.19 144.26,40.19 144.31,40.19 v6(144.5,39.99)
  BOTTOM w0.091: v6(144.5,39.99) 144.6,39.99 UC1.BU8 ; CV17.1 112.12,46.74 v7(112.6,46.25) 112.79,46.06 112.79,45.6 v6(112.86,45.53)
PEG_CTX_C_GRX_N5: length 3.7
  BOTTOM w0.091: CV6.2 117.07,53.28 116.86,53.49 116.18,53.49 116.17,53.51 115.58,53.51 114.54,54.55 UV1.AG7
PEG_CTX_C_GRX_N6: length 5.4
  BOTTOM w0.076: 113.39,54.4 113.39,54.6 113,54.99 UV1.AE7
  BOTTOM w0.091: 116.25,52.19 116.25,52.46 115.94,52.77 v7(115.39,52.77) 114.99,52.77 113.85,53.91 113.85,53.94 113.39,54.4
PEG_CTX_C_GRX_N7: length 5.3
  BOTTOM w0.091: UV1.AF9 112.25,53.92 112.08,54.1 112.08,54.2 112.16,54.29 112.47,54.29 112.92,53.84 113.02,53.84 113.68,53.18 113.68,52.94 114.65,51.97 115.06,51.97 115.43,51.6 CV20.2
PEG_CTX_C_GRX_N8: length 3.6
  BOTTOM w0.091: CV22.2 114.59,50.78 114.23,51.15 114.21,51.15 113.72,51.64 113.72,51.87 112.64,52.95 112.53,52.95 UV1.AG10
PEG_CTX_C_GRX_P5: length 3.7
  BOTTOM w0.091: UV1.AG6 114.69,54.68 115.67,53.71 v7(116.47,53.71) 116.93,53.71 117.2,53.43 CV1.2
PEG_CTX_C_GRX_P6: length 5.4
  BOTTOM w0.076: 113.99,54.06 113.98,54.07 113.95,54.07 113.55,54.47 113.55,54.66 113.16,55.05 113.16,55.28 113.22,55.34 113.33,55.34 UV1.AF7
  BOTTOM w0.091: CV7.2 116.4,52.6 116.03,52.97 115.71,52.97 115.7,52.99 115.06,52.99 113.99,54.06
PEG_CTX_C_GRX_P7: length 5.3
  BOTTOM w0.091: CV19.2 115.53,51.78 115.14,52.17 114.74,52.17 113.88,53.02 113.88,53.26 113.1,54.04 113,54.04 112.55,54.49 UV1.AE9
PEG_CTX_C_GRX_P8: length 3.5
  BOTTOM w0.091: UV1.AG9 112.8,53.22 112.8,53.08 113.92,51.96 113.92,51.74 v7(114.17,51.49) 114.72,50.95 CV21.2
PEG_CTX_GRX_N5: length 45.8
  IN1 w0.079: v6(115.52,45.57) 115.76,45.32 115.76,45.18 117.36,43.58 117.38,43.58 119.41,41.54 120.21,41.54 121.34,40.41 122.24,40.41 123.78,38.87 126.34,38.87 127.38,39.91 129.47,39.91 131.26,38.12 134.36,38.12 134.62,38.37 137.71,38.37 138.47,39.13 138.7,39.13 138.83,39.27 141.38,39.27 141.55,39.27 142.02,39.74 142.74,39.74 142.95,39.52 142.95,39.52 143.1,39.38 143.11,39.38 143.16,39.32 143.47,39.32 143.88,38.92 143.88,38.43 143.99,38.32 143.99,38.01 143.8,37.81 143.8,37.64 143.88,37.55 144.07,37.55 144.39,37.88 v6(144.39,37.99)
  BOTTOM w0.091: CV6.1 117.78,52.6 118.9,51.48 118.9,48.53 118.59,48.22 117.8,48.22 117.29,47.72 117.27,47.72 116.89,47.33 116.89,47.31 115.79,46.21 115.79,45.83 v6(115.52,45.57) ; v6(144.39,37.99) 144.21,37.81 144.21,37.75 UC1.BW4
PEG_CTX_GRX_N6: length 43.8
  IN1 w0.079: v6(145.35,38.7) 145.18,38.53 145.18,38.09 145.24,38.03 145.36,38.03 145.86,38.53 146.46,38.53 146.71,38.78 146.71,39.48 146.71,39.49 146.71,41.05 144.64,43.11 144.64,43.33 144.27,43.71 141.9,43.71 141.9,43.7 140.72,43.7 140.41,43.38 138.38,43.38 138.35,43.41 136.31,43.41 135.84,42.94 132.51,42.94 131.99,43.46 125.86,43.46 123.39,45.94 122.7,45.94 121.6,47.04 121.3,47.04 120.96,47.38 120.96,47.78 120.85,47.89 120.84,47.89 120.57,48.17 120.57,48.17 119.9,48.84 119.89,48.84 119.54,49.19 119.23,49.19 118.97,48.93 118.97,48.55 118.72,48.3 118.49,48.3 118.48,48.3 118.26,48.3 118.07,48.49 118.07,48.62 v6(117.79,48.9)
  BOTTOM w0.091: v6(117.79,48.9) 117.98,49.09 117.98,50.77 116.97,51.78 CV8.1 ; UC1.BU4 145.4,38.14 145.35,38.19 v6(145.35,38.7)
PEG_CTX_GRX_N7: length 51
  IN1 w0.079: v6(145.69,34.03) 146.1,34.03 146.11,34.03 146.34,34.03 148.01,35.7 148.01,38.15 148.08,38.21 148.08,38.38 148.08,39.88 148.08,39.89 148.08,40.05 148.07,40.06 148.07,41.62 146.01,43.68 146.01,43.9 144.79,45.12 142.13,45.12 141.36,45.89 136.94,45.89 136.62,45.57 135.27,45.57 135.06,45.37 128.75,45.37 128.3,45.82 125.59,45.82 125.52,45.89 125.52,45.89 124.05,47.36 123.98,47.36 122.89,48.46 122.64,48.46 122.37,48.72 122.37,48.88 122.08,49.18 122.05,49.18 121.25,49.98 121.25,49.98 120.98,50.25 120.98,50.27 120.63,50.62 120.46,50.62 120.14,50.62 120.12,50.59 120.11,50.59 119.73,50.59 119.64,50.67 119.48,50.67 118.1,50.67 117.09,51.69 116.21,51.69 115.85,51.33 115.85,50.94 v6(116.26,50.53)
  BOTTOM w0.091: CV20.1 116.1,50.96 116.21,50.85 116.21,50.85 116.26,50.8 v6(116.26,50.53) ; v6(145.69,34.03) 145.89,34.23 146.08,34.23 146.29,34.45 146.29,34.88 145.72,35.45 145.72,35.86 145.43,36.15 145.4,36.17 UC1.BU2
PEG_CTX_GRX_N8: length 43.6
  IN1 w0.079: v6(146.01,37.77) 146.01,36.99 146.13,36.87 146.21,36.87 146.42,37.08 146.42,37.66 146.67,37.91 146.67,37.92 147.3,38.54 147.3,39.73 147.29,39.73 147.29,41.3 145.23,43.36 145.23,43.57 144.5,44.3 144.12,44.3 141.39,44.3 141.37,44.28 140.48,44.28 140.16,43.96 138.09,43.96 138.06,43.99 136.06,43.99 136.03,43.96 135.15,43.96 134.71,43.53 132.75,43.53 132.21,44.07 128.07,44.07 127.53,44.61 125.7,44.61 125.2,45.11 125.19,45.11 123.73,46.57 123.38,46.57 121.57,48.39 121.57,48.54 120.9,49.21 120.36,49.21 120.15,49.42 120.14,49.42 119.75,49.81 119.44,49.81 119.4,49.81 119.37,49.84 117.44,49.84 117.21,49.61 115.94,49.61 115.81,49.74 v6(115.4,49.74)
  BOTTOM w0.091: CV22.1 115.28,50.13 115.4,50.01 v6(115.4,49.74) ; UC1.BT4 146.01,37.35 v6(146.01,37.77)
PEG_CTX_GRX_P5: length 45.9
  IN1 w0.079: v6(116.1,45.57) 115.96,45.43 115.96,45.26 117.44,43.78 117.46,43.78 119.5,41.74 120.29,41.74 121.42,40.61 122.32,40.61 123.86,39.07 126.26,39.07 127.29,40.11 129.56,40.11 131.34,38.32 134.28,38.32 134.53,38.57 137.62,38.57 138.38,39.33 138.61,39.33 138.75,39.47 141.47,39.47 141.93,39.94 142.82,39.94 143.03,39.73 143.04,39.73 143.19,39.58 143.19,39.58 143.24,39.52 143.56,39.52 144.08,39 144.08,38.67 144.09,38.67 144.09,38.51 144.13,38.47 144.22,38.38 144.57,38.38 144.79,38.16 144.79,37.66 v6(144.44,37.3)
  BOTTOM w0.091: CV1.1 117.9,52.77 119.1,51.57 119.1,48.45 118.68,48.02 117.88,48.02 v7(117.23,47.37) 115.99,46.13 115.99,45.68 v6(116.1,45.57) ; v6(144.44,37.3) 144.26,37.12 144.23,37.12 UC1.BW3
PEG_CTX_GRX_P6: length 43.9
  IN1 w0.079: v6(118.37,48.9) 118.27,48.8 118.27,48.58 118.34,48.5 118.63,48.5 118.77,48.64 118.77,49.01 119.15,49.39 119.46,49.39 119.62,49.39 119.65,49.37 119.65,49.37 119.98,49.04 119.99,49.04 120.77,48.26 120.77,48.25 120.93,48.09 120.93,48.09 121.16,47.87 121.16,47.46 121.39,47.24 121.68,47.24 122.78,46.14 123.48,46.14 124.71,44.9 125.95,43.66 132.08,43.66 132.6,43.14 135.75,43.14 136.22,43.61 138.43,43.61 138.47,43.58 140.32,43.58 140.64,43.9 141.81,43.9 141.82,43.91 144.35,43.91 144.85,43.41 144.85,43.2 146.91,41.14 146.91,39.57 146.91,39.57 146.91,38.7 146.54,38.33 146.16,38.33 146.16,38.32 145.95,38.32 145.56,37.94 145.56,37.82 v6(145.07,37.32)
  BOTTOM w0.091: CV7.1 117.07,51.96 118.18,50.86 118.18,49.09 v6(118.37,48.9) ; UC1.BU3 145.4,36.91 145.28,36.79 145.07,36.79 144.95,36.91 144.95,37.2 v6(145.07,37.32)
PEG_CTX_GRX_P7: length 50.9
  IN1 w0.079: v6(145.69,34.61) 145.69,34.87 145.76,34.94 145.95,34.94 146.12,34.77 146.12,34.3 146.19,34.23 146.26,34.23 147.81,35.78 147.81,38.23 147.88,38.3 147.88,39.97 147.87,39.97 147.87,41.54 145.81,43.6 145.81,43.81 144.7,44.92 142.05,44.92 141.28,45.69 137.02,45.69 136.7,45.37 135.35,45.37 135.15,45.17 128.67,45.17 128.22,45.62 125.51,45.62 125.44,45.69 125.43,45.69 123.97,47.16 123.9,47.16 122.8,48.25 122.56,48.25 122.17,48.64 122.17,48.8 122,48.97 121.97,48.97 121.17,49.78 120.78,50.17 120.78,50.18 120.55,50.41 120.22,50.41 120.2,50.39 120.19,50.39 119.64,50.39 119.56,50.47 119.4,50.47 119.39,50.47 118.01,50.47 117,51.48 116.29,51.48 116.06,51.25 116.06,51.02 116.15,50.93 116.3,50.93 116.43,51.07 116.55,51.07 v6(116.67,50.94)
  BOTTOM w0.091: v6(116.67,50.94) 116.41,50.94 116.25,51.11 CV19.1 ; v6(145.69,34.61) 145.87,34.43 145.99,34.43 146.09,34.53 146.09,34.79 145.58,35.3 145.57,35.3 145.56,35.31 145.26,35.31 145.09,35.48 145.09,35.87 145.17,35.95 145.34,35.95 145.4,35.88 UC1.BU1
PEG_CTX_GRX_P8: length 43.6
  IN1 w0.079: v6(115.81,50.15) 115.81,50.03 116.03,49.81 117.12,49.81 117.36,50.04 119.45,50.04 119.48,50.01 119.84,50.01 120.22,49.62 120.23,49.62 120.44,49.41 120.98,49.41 121.77,48.62 121.77,48.47 123.47,46.77 123.64,46.77 123.81,46.77 125.27,45.31 125.28,45.31 125.78,44.81 127.62,44.81 128.15,44.27 132.29,44.27 132.84,43.73 134.63,43.73 135.06,44.16 135.95,44.16 135.98,44.19 138.14,44.19 138.18,44.16 140.08,44.16 140.4,44.48 141.29,44.48 141.31,44.5 144.03,44.5 144.04,44.5 144.58,44.5 145.43,43.65 145.43,43.44 147.49,41.38 147.49,39.81 147.5,39.81 147.5,38.46 146.87,37.83 146.87,37.83 146.62,37.57 146.62,37 146.29,36.67 146.08,36.67 145.97,36.56 v6(145.97,36.17)
  BOTTOM w0.091: UC1.BT3 v6(145.97,36.17) ; CV21.1 115.41,50.3 115.56,50.15 v6(115.81,50.15)
PEX_TERMP: length 5.2
  TOP w0.081: v6(105.22,45.12) 105.1,45.24 105.1,46.48 v1(105.54,46.92) RV376.1
  BOTTOM w0.081: v6(105.22,45.12) 104.15,45.12 103.6,44.58 UV1.AF25
PHASE_ID1: length 3
  TOP w0.081: RC70.2 136.7,43.33 RC72.1 136.06,43.33 v2(135.79,43.61) v1(135.79,44.1)
  IN1 w0.064: v2(135.79,43.61) 135.7,43.52 v4(135.34,43.52)
  IN3 w0.064: v4(135.34,43.52) 135.55,43.52 v5(135.93,43.9)
PHASE_ID2: length 5.8
  BOTTOM w0.081: UC1.CM14 136.47,43.91 136.15,43.59 135.59,43.59 135.51,43.52 133.87,43.52 133.74,43.65 RC71.1 132.63,43.86 132.47,44.01 131.76,44.01 RC69.2
PHASE_ID3: length 3.9
  TOP w0.081: v2(139.85,42.57) 139.93,42.5 RC572.2 139.93,41.58 RC573.1
  IN1 w0.064: v4(138.77,42.95) 139.12,42.61 139.82,42.61 v2(139.85,42.57)
  IN3 w0.064: v5(139.03,42.22) 138.77,42.47 v4(138.77,42.95)
  BOTTOM w0.081: UC1.CH12 138.61,42.63 v5(139.03,42.22)
PLT_RST_VGA#: length 44.6
  TOP w0.081: UV26.1 110.6,46.45 110.6,46.6 RV378.1 v2(110.1,46.6)
  IN1 w0.064: v4(112.49,58.28) 112.03,58.28 109.56,55.82 109.56,51.53 110.96,50.13 110.96,48.01 110.1,47.14 v2(110.1,46.6)
  IN3 w0.064: v5(115.2,73.96) 115.2,72.99 116.29,71.9 116.29,69.22 117.23,68.28 117.23,61.54 116.45,60.76 116.45,59.25 115.3,58.1 114.3,58.1 113.26,57.07 112.78,57.07 112.38,57.46 v5(112.38,57.82) 112.38,58.18 v4(112.49,58.28)
  BOTTOM w0.081: RV74.1 111.34,75.83 111.62,76.11 115.03,76.11 115.22,75.92 RV5004.1 115.22,75.32 115.2,75.3 UV12.4 v5(115.2,73.96) ; UV1.AC7 111.98,56.92 111.98,57.51 112.28,57.82 v5(112.38,57.82)
PLT_RST_VGA#_QV2: length 2.7
  BOTTOM w0.081: RV74.2 110.98,75.3 111.08,75.2 QV2.5 QV2.2
PLT_RST_VGA#_UV26: length 4.7
  TOP w0.081: QV150.5 113.57,46.61 113.45,46.61 113.28,46.45 112.51,46.45 112.21,46.14 111.8,46.14 110.93,45.27 110.93,44.29 UV26.4
PLTRST#: length 224.4
  TOP w0.081: v6(117.95,63.1) 118.58,62.48 118.58,61.29 119.32,60.55 119.78,60.55 122.23,63 124.09,63 124.37,63.11 124.79,63.53 126.85,63.53 128.07,62.92 128.7,62.5 129.24,61.96 129.42,61.7 130.09,61.02 130.09,60.04 130.26,59.86 130.26,58.89 130.64,58.52 130.64,58.4 130.04,57.8 130,57.8 128.52,56.32 128.52,56.32 128.49,56.29 128.49,56.29 127.43,55.23 127.43,48.23 126.89,47.69 126.89,45.72 126.93,45.69 126.93,45.61 128.54,44 128.54,42.53 130.22,40.85 v2(130.22,36.21) ; v2(34.81,63.39) 31.84,63.39 31.57,63.12 RT285.1 31.57,62.91 31.33,62.66 31.33,59.72 31.36,59.69 31.36,59.25 31.39,59.21 v1(31.39,58.89) 31.39,56.27 30.73,55.61 30.73,53.84 RT190.2 ; v2(130.38,68.24) 131.44,69.31 131.87,69.31 132.26,69.7 136.5,69.7 137.2,70.4 138.19,70.4 138.33,70.26 RC94.1 138.33,69.71 138.42,69.62 UC4.4
  IN1 w0.064: v2(34.81,63.39) 34.93,63.39 v4(35.09,63.23) ; v2(130.22,36.21) 130.22,36.33 129.5,37.05 125.54,37.05 123.85,35.36 122.74,35.36 122.3,35.79 v4(121.64,35.79) ; v4(55.14,43.81) 55.14,44.06 54.65,44.55 v2(54.65,48.2) 54.71,48.26 54.71,49.18 54.51,49.38 54.51,50.32 54.25,50.57 54.25,52.73 55.07,53.55 v4(55.07,53.72) ; v4(131.63,63.72) 131.53,63.72 130.38,64.87 130.38,68.24 v2(130.38,68.24) 130.38,68.76 128.15,70.99 119.85,70.99 118.5,72.33 v4(116.5,72.33)
  IN2 w0.066: v4(55.14,43.81) 57.28,43.81 58.76,42.33 60.1,42.33 66.21,36.21 66.21,35.53 72.55,29.19 80.94,29.19 81.3,29.55 99.83,29.55 100.01,29.37 108.72,29.37 109.31,28.78 112.94,28.78 v4(113.16,28.56) 113.63,28.56 120.86,35.79 v4(121.64,35.79)
  IN3 w0.064: v4(131.63,63.72) 131.7,63.78 v5(131.7,64.4) ; v4(55.07,53.72) 54.52,53.72 53.77,54.48 50.19,54.48 48.59,56.09 44.79,56.09 44.2,56.68 42.89,56.68 41.28,58.29 41.28,58.45 38.62,61.1 37.3,61.1 35.17,63.23 v4(35.09,63.23) ; v4(113.16,28.56) v5(112.8,28.56) ; v5(116.5,73) v4(116.5,72.33) 116.5,69.56 117.82,68.25 117.82,63.24 v6(117.95,63.1)
  BOTTOM w0.081: JSSD1.50 112.5,28.77 112.66,28.62 112.75,28.62 v5(112.8,28.56)
PM_SYS_RESET#: length 2.3
  TOP w0.081: RC248.2 139.35,12.07 138.94,12.49 138.94,12.56 RC531.1 138.14,12.73 137.99,12.88 RC529.1
POK: length 202.4
  IN2 w0.066: v4(119.39,48.82) 119.32,48.82 119.31,48.81 118.94,48.81 118.57,48.45 117.59,48.45 116.8,49.25 115.16,49.25 114.97,49.44 114.97,49.73 114.76,49.94 114.3,49.94 112.55,48.18 112.55,46.75 113.51,45.78 113.51,44.86 112.67,44.01 112.67,39.1 112.53,38.97 109.57,38.97 109.25,39.28 107.48,39.28 105.75,37.56 105.75,34.83 105.37,34.44 104.84,34.44 104.27,33.87 v4(102.88,33.87) ; v4(13.51,7.16) 13.51,11.42 11.22,13.7 11.22,15.35 11.21,15.36 v4(11.21,16.45)
  IN3 w0.064: v4(119.39,48.82) 119.69,48.82 v5(119.72,48.85) ; v5(11.89,27.1) 11.89,24.19 13.11,22.98 13.9,22.98 v5(14.71,22.17) 14.1,21.55 13.06,21.55 10.34,18.84 10.34,17.32 v4(11.21,16.45) v5(11.21,16.03) ; v5(51.11,5.09) 44.93,5.09 43.59,3.75 34.98,3.75 30.99,7.74 16.75,7.74 16.18,7.16 v4(13.51,7.16) ; v5(104.76,34.13) 104.5,33.87 v4(102.88,33.87)
  BOTTOM w0.081: v5(51.11,5.09) 51.32,5.3 52.78,5.3 v1(54.25,3.83) 54.55,3.52 98.78,3.52 99.59,4.33 101.03,4.33 101.31,4.61 101.31,8.53 100.5,9.34 100.28,9.34 99.22,10.4 99.22,11.18 98.57,11.84 98.57,14.7 98.22,15.05 93.52,15.05 91.66,16.91 91.66,24.36 92.11,24.82 95.33,24.82 104.64,34.13 v5(104.76,34.13) ; v5(119.72,48.85) 119.61,48.95 DZ2.1 119.61,52.12 RC105.1 120.36,52.6 UC5.2
  BOTTOM w0.089: PU501.12 v5(14.71,22.17)
  BOTTOM w0.254: v5(11.21,16.03) 11.48,16.03 11.78,15.73 PU301.7

# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BL_PWR_MONITOR: length 2.2
  TOP w0.081: RV625.2 33.99,74.74 33.87,74.86 33.87,75.91 34.11,76.15 QV19.2
BL_PWR_MONITOR_R: length 1
  TOP w0.081: QV18.6 34.71,73.47 34.29,73.89 RV625.1
BLUETOOTH_EN: length 50.9
  TOP w0.081: v2(117.96,62.57) 118.1,62.42 v1(118.1,61.81) 118.1,60.87 120.07,58.9 120.22,58.9 122.22,56.9 122.22,56.18 123.31,55.09 123.31,53.91 124.39,52.83 124.39,51.73 123.52,50.86 123.52,43.66 125.11,42.07 125.11,41.46 124.94,41.3 124.82,41.3 v6(124.82,41.3)
  IN1 w0.064: v2(117.96,62.57) 117.94,62.57 117.79,62.72 117.79,62.72 117.56,62.94 117.5,63.01 117.5,63.24 117.57,63.3 117.57,63.31 117.94,63.69 117.94,66.82 117.57,67.2 117.57,69.95 117.13,70.39 v4(117.13,71.13)
  IN3 w0.064: v5(134.43,44.19) 133.69,43.44 133.39,43.44 133.07,43.12 130.1,43.12 129.57,42.58 128.09,42.58 127.76,42.25 125.56,42.25 124.82,41.51 v6(124.82,41.3) ; v4(117.13,71.13) 116.8,71.45 116.8,72.12 116.86,72.18 116.86,73.22 v5(117.97,74.32)
  BOTTOM w0.081: v5(117.97,74.32) 117.97,74.76 RC570.2 ; v5(134.43,44.19) 134.45,44.16 134.84,44.16 135.17,43.83 UC1.CP14
BLUETOOTH_EN_R: length 7.2
  IN3 w0.064: v5(121.88,72.25) 119.79,72.25 119,71.46 118.04,71.46 117.62,71.89 117.62,73.39 v5(117.97,73.74)
  BOTTOM w0.081: WL1.63 v5(121.88,72.25)
BOARD_ID: length 3.6
  TOP w0.081: UE1.A13 48.23,18.62 48.1,18.48 RE2.2 48.26,18.08 48.46,17.88 48.46,17.2 48.79,16.87 CE11.1 49.37,16.86 RE1.2
BOOT2_CHG:
  vias: v1(199.53,24.09)
BST_IA2: length 1.1
  BOTTOM w0.081: v1(172.99,15.41) 173.19,15.2 PCI23.1
BST_IA3: length 1.1
  BOTTOM w0.081: v1(180.47,15.25) 180.52,15.2 PCI35.1
CAP_LED: length 20
  TOP w0.254: v3(81.19,7.3) 81.01,7.48 v2(80.58,7.48) 80.58,6.92 79.23,5.56 65.86,5.56 R48.2
  IN1 w0.254: v4(79.82,7.5) 80.57,7.5 v2(80.58,7.48)
  IN3 w0.254: v5(79.25,8.14) 79.25,8.06 v4(79.82,7.5)
CAP_LED#: length 61.1
  TOP w0.081: v2(42.05,26.72) 42.26,26.72 42.65,27.1 42.65,27.57 43.14,28.07 v2(43.14,28.34) 42.98,28.5 41.91,28.5 41.84,28.43 UE1.B53 ; Q9.3 67.04,9.4 66.83,9.62 63.3,9.62 62.51,8.83 v1(62.51,8.49) v2(62.51,6.5)
  IN1 w0.064: v2(42.05,26.72) 42.05,26.75 40.13,28.67 39.49,28.67 v2(39.45,28.63) ; v2(43.14,28.34) 43.14,28.14 44.83,26.46 44.83,24.32 42.09,21.58 42.09,20.79 41.55,20.26 41.07,20.26 40,19.19 39.11,19.19 38.67,18.75 38.67,16.18 38.32,15.83 38.32,15.38 40.51,13.18 40.51,13 41,12.51 41.7,12.51 42.89,11.33 48.24,11.33 48.82,10.75 49.78,10.75 50.05,10.47 50.05,9.82 50.7,9.17 51.98,9.17 54.96,6.19 62.19,6.19 v2(62.51,6.5)
CAP_LED_Q: length 3
  TOP w0.254: R48.1 64.12,7.74 63.53,7.14 Q12.1 63.53,6.39 64.19,5.73 v1(64.22,5.73)
CAP_LED_R#: length 7
  TOP w0.081: Q9.1 65.15,8.75 64.8,9.11 v1(64.36,9.11) 64.35,9.11 62.83,7.58 62.83,6.41 62.63,6.21 62.39,6.21 62.16,6.44 62.16,7.24 62.08,7.32 Q12.2
CATERR#: length 7
  BOTTOM w0.081: UC1.AA4 167.37,37.46 167.85,36.98 168.15,36.98 168.24,36.89 168.24,36.11 168.34,36.01 168.64,36.01 168.83,35.82 168.83,35.61 169.51,34.93 169.51,34.62 170.26,33.87 170.26,32.64 170.23,32.61 TP77.1
CEXT_U34: length 3.5
  TOP w0.081: U34.7 61.96,29.98 RE99.2 61.63,31.01 CE36.1 60.88,31.12 v1(60.67,31.33)
CFG0: length 4.2
  BOTTOM w0.081: RC548.2 171.46,33.99 170.65,34.8 170.65,37.03 UC1.T4
CFG1: length 7.1
  IN3 w0.064: v5(172.91,31.98) 172.82,31.98 172.62,32.18 172.62,32.5 172.34,32.78 171.8,32.78 171.61,32.97 171.61,33.33 171.89,33.6 171.89,34.2 170.94,35.15 v5(170.94,37.63)
CFG2: length 5.2
  BOTTOM w0.081: UC1.T3 170.37,34.79 171.1,34.07 171.1,32.49 171.51,32.08 RC406.2
CFG3: length 4.3
  BOTTOM w0.081: RC407.2 172.81,33.77 171.96,34.62 171.96,36.12 171.72,36.36 171.44,36.36 170.94,36.86 UC1.R3
CFG4: length 8.5
  BOTTOM w0.076: RC408.2 179.02,32.15 179.91,32.15 v1(180.09,32.32)
  BOTTOM w0.081: RC408.2 178.54,32.64 175.92,35.26 175.72,35.26 175.43,35.55 175.43,35.96 174.97,36.41 174.97,37.2 174.69,37.48 UC1.J4
CFG5: length 4.3
  BOTTOM w0.081: UC1.M4 172.82,37.17 173.09,36.9 173.09,35.19 174.33,33.95 RC409.2
CFG6: length 5.6
  BOTTOM w0.081: RC410.2 175.63,33.9 174.36,35.17 174.36,36.65 UC1.J3
CFG7: length 5.3
  BOTTOM w0.081: RC411.2 173.99,32.43 173.99,33.97 172.82,35.14 UC1.M3
CFG8: length 3.3
  BOTTOM w0.081: RC412.2 172.2,34.03 171.34,34.89 171.34,35.73 170.94,36.13 UC1.R2
CFG9: length 5.1
  BOTTOM w0.081: RC413.2 173.8,32.21 173.8,33.82 172.58,35.04 172.58,35.93 172.25,36.26 UC1.N2
CFG10: length 4.3
  BOTTOM w0.081: RC414.2 171.81,32.39 171.81,34.03 170.94,34.91 UC1.R1
CFG11: length 2.6
  BOTTOM w0.081: UC1.N1 172.22,35.66 172.22,34.83 RC415.2
CFG12: length 6.3
  BOTTOM w0.076: 177.34,31.91 RC416.2
  BOTTOM w0.081: RC416.2 177.34,33.25 175.15,35.45 175.15,35.8 174.69,36.26 UC1.J2 ; 177.34,31.91 177.34,31.56 v1(177.63,31.27)
CFG13: length 3.4
  BOTTOM w0.081: RC417.2 174.99,33.95 173.8,35.14 173.8,35.73 173.38,36.15 UC1.L2
CFG14: length 4.4
  BOTTOM w0.076: v1(176.53,32.03) 176.53,33.24 RC418.2
  BOTTOM w0.081: UC1.J1 174.69,35.37 176.16,33.9 RC418.2
CFG15: length 4.3
  BOTTOM w0.081: RC419.2 174.66,32.36 174.66,33.92 173.38,35.21 UC1.L1
CFG16: length 1.3
  IN1 w0.064: v4(173.82,36.98) 174.31,36.5 v2(174.43,36.5)
  IN3 w0.064: v5(173.38,36.98) v4(173.82,36.98)
CFG17: length 2.1
  IN1 w0.064: v4(173.55,38.01) 173.55,37.7 173.15,37.31 v2(173.15,36.58)
  IN3 w0.064: v4(173.55,38.01) 173.55,37.76 173.42,37.63 v5(173.38,37.63)
CFG18: length 0.9
  IN1 w0.064: v4(172.25,36.57) 171.95,36.26 v2(171.85,36.26)
  IN3 w0.064: v5(172.25,36.98) v4(172.25,36.57)
CFG19: length 1.1
  IN1 w0.064: v2(172.36,37.61) 172.61,37.85 172.72,37.85 v4(172.76,37.89)
  IN3 w0.064: v5(172.25,37.63) 172.51,37.63 v4(172.76,37.89)
CFG_RCOMP: length 1.1
  IN1 w0.203: v4(167.51,38.38) 167.05,38.38 v2(166.87,38.2)
  IN3 w0.254: v5(167.11,38.38) v4(167.51,38.38)
CHG_AMBER_LED_R#: length 49
  TOP w0.081: v6(35.45,30.33) 35.39,30.33 34.66,31.06 34.66,32.44 34.85,32.62 34.85,34.78 35.18,35.11 v1(35.18,35.37) 35.18,35.75 39.49,40.06 39.49,40.93 39.34,41.08 Q15.6 38.95,40.88 38.95,39.82 37.27,38.14 36.19,38.14 36.07,38.27 36.07,39.49 36.16,39.58 Q31.2 ; QZ3.3 36.97,10.18 37.17,10.38 37.49,10.38 37.69,10.18 38.56,10.18 38.83,10.45 38.83,14.87 38.48,15.22 37.62,15.22 37.44,15.39 35.61,15.39 v2(35.44,15.22)
  IN1 w0.064: v4(36.63,22.71) 36.63,22.64 35.32,21.33 35.32,15.34 v2(35.44,15.22)
  IN2 w0.066: v4(36.63,22.71) 36.63,23.73 37.22,24.33 37.22,26.02 37.01,26.23 37.01,27.96 36.13,28.84 36.13,29.64 v6(35.45,30.33)
CLK_CNV_CRX_DTX_N: length 33.2
  IN1 w0.079: v2(121.79,66.12) 121.97,65.94 122.22,65.94 122.38,66.1 122.76,66.1 122.95,65.91 122.95,65.32 122.64,65.01 122.64,64.44 122.74,64.35 123.04,64.35 123.26,64.13 123.26,63.13 123.1,62.98 123.1,62.52 122.31,61.73 121.65,61.73 121.36,61.44 121.36,61.12 121.78,60.7 121.78,57.67 122.06,57.39 122.06,57.38 122.42,57.03 122.42,56.39 123.66,55.15 124.41,55.15 124.52,55.26 124.52,55.53 124.91,55.92 125.99,55.92 126.22,55.69 126.22,54.79 126.8,54.2 126.99,54.2 127.23,54.44 127.82,54.44 127.93,54.55 127.93,56.49 128.7,57.26 129.55,57.26 130.26,56.55 130.79,56.55 131.45,55.89 131.45,55.38 131.28,55.21 131.28,54.96 131.5,54.74 132.01,54.74 132.38,54.37 132.57,54.37 133.05,54.85 133.35,54.85 v6(133.58,55.08)
  BOTTOM w0.091: UC1.CN31 135.33,54.71 134.76,55.01 134.75,55.03 134.35,55.03 134.35,55.03 134.2,55.03 134.14,55.09 133.59,55.09 v6(133.58,55.08)
CLK_CNV_CRX_DTX_P: length 33.2
  IN1 w0.079: v2(121.79,65.56) 121.97,65.74 122.3,65.74 122.46,65.9 122.67,65.9 122.75,65.83 122.75,65.4 122.43,65.09 122.43,64.36 122.49,64.3 122.49,64.3 122.65,64.14 122.96,64.14 123.05,64.05 123.05,63.22 122.9,63.06 122.9,62.61 122.23,61.93 121.57,61.93 121.16,61.52 121.16,61.04 121.58,60.62 121.58,57.59 121.86,57.3 121.86,57.3 122.22,56.95 122.22,56.3 123.58,54.94 124.49,54.94 124.72,55.18 124.72,55.44 124.86,55.58 124.86,55.58 125,55.71 125.9,55.71 126.01,55.6 126.01,54.7 126.72,54 127.08,54 127.32,54.24 127.9,54.24 128.13,54.47 128.13,56.41 128.78,57.05 129.47,57.05 130.17,56.35 130.71,56.35 131.25,55.81 131.25,55.47 131.07,55.29 131.07,54.88 131.42,54.54 131.92,54.54 132.29,54.17 132.65,54.17 133.13,54.65 133.39,54.65 v6(133.64,54.4)
  BOTTOM w0.091: UC1.CP31 134.76,54.73 134.67,54.82 134.27,54.82 134.26,54.83 134.12,54.83 134.06,54.89 133.96,54.89 133.9,54.83 133.9,54.73 134.02,54.6 134.02,54.46 133.86,54.3 133.74,54.3 v6(133.64,54.4)
CLK_CNV_CRX_R_DTX_N: length 2.1
  TOP w0.091: v6(123.4,66.3) 123.23,66.12 123.02,66.12 122.84,65.94 122.56,65.94 RW54.1
  BOTTOM w0.091: v6(123.4,66.3) 123.58,66.12 123.85,66.12 123.99,66.25 WL1.A33
CLK_CNV_CRX_R_DTX_P: length 2.1
  TOP w0.091: RW53.1 122.56,65.74 122.93,65.74 123.11,65.92 123.19,65.92 v6(123.4,65.71)
  BOTTOM w0.091: v6(123.4,65.71) 123.61,65.92 123.81,65.92 123.97,65.75 WL1.A32
CLK_CNV_CTX_DRX_N: length 17.2
  TOP w0.091: v6(134.91,68.53) 134.75,68.7 134.57,68.7 RW48.2
  IN3 w0.079: v5(134.07,56.73) 133.96,56.62 133.86,56.62 133.79,56.7 133.79,56.95 134.02,57.19 134.02,57.62 134.09,57.69 134.09,62.88 134.2,62.99 134.2,65.38 133.98,65.6 133.98,68.32 134.42,68.76 134.69,68.76 v6(134.91,68.53)
  BOTTOM w0.076: UC1.CP34 135.59,56.4 135.66,56.47 135.66,56.64 135.59,56.72 135.17,56.72 135.02,56.57 135.02,56.4 134.95,56.32 134.81,56.32 134.7,56.21 134.36,56.21 134.34,56.23 134.32,56.23
  BOTTOM w0.091: 134.32,56.23 134.04,56.23 133.87,56.4 133.87,56.53 v5(134.07,56.73)
CLK_CNV_CTX_DRX_P: length 17.2
  TOP w0.091: RW46.2 134.56,68.9 134.7,68.9 v6(134.91,69.12)
  IN3 w0.079: v6(134.91,69.12) 134.75,68.96 134.34,68.96 133.78,68.4 133.78,65.51 134,65.3 134,63.07 133.89,62.96 133.89,57.78 133.82,57.7 133.82,57.27 133.59,57.04 133.59,56.83 v5(133.49,56.73)
  BOTTOM w0.076: 134.32,56.02 134.34,56.02 134.36,56.04 134.76,56.04 134.88,56.16 135.06,56.16 135.12,56.1 135.56,56.1 135.85,56.4 UC1.CN34
  BOTTOM w0.091: v5(133.49,56.73) 133.67,56.55 133.67,56.31 133.96,56.02 134.32,56.02
CLK_CNV_CTX_R_DRX_N: length 2.4
  TOP w0.091: v6(132.43,68.21) 132.63,68.41 132.97,68.41 133.23,68.67 133.65,68.67 RW48.1
  BOTTOM w0.091: v6(132.43,68.21) 132.24,68.39 132.11,68.39 131.97,68.25 WL1.A20
CLK_CNV_CTX_R_DRX_P: length 2.4
  TOP w0.091: v6(132.43,68.79) 132.6,68.62 132.89,68.62 133.14,68.87 133.6,68.87 RW46.1
  BOTTOM w0.091: v6(132.43,68.79) 132.23,68.59 132.11,68.59 131.95,68.75 WL1.A19
CLK_ITPXDP_N: length 5.3
  BOTTOM w0.076: 157.33,35.07 157.53,35.27 157.53,35.38 157.24,35.66 157.24,35.87 ; UC1.AU1 157.68,35.75 157.68,35.86 157.53,36.01 157.33,36.01 157.25,35.93
  BOTTOM w0.091: 157.25,35.93 157.25,35.87 157.24,35.87 ; RC540.2 155.83,33.23 156.07,32.99 156.3,32.99 156.32,33.01 156.9,33.01 157.28,33.39 v7(157.28,33.86) 157.28,35.02 157.33,35.07
CLK_ITPXDP_N_R: length 41.8
  TOP w0.091: JXDP1.42 136.03,10.01 135.83,10.21 135.83,11.7 135.66,11.88 135.66,14.35 134.53,15.48 134.53,15.81 134.66,15.93 134.8,15.93 134.91,16.04 v6(134.91,16.17)
  BOTTOM w0.091: v6(134.91,16.17) 134.91,15.97 135.01,15.88 145.8,15.88 146.28,16.36 147.68,16.36 148.19,16.88 148.19,21.23 149.23,22.27 149.23,29.3 151.28,31.35 152.33,31.35 153.86,32.88 154.67,32.88 154.76,32.97 154.76,33.16 154.84,33.23 RC540.1
CLK_ITPXDP_P: length 5.3
  BOTTOM w0.091: UC1.AU2 157.91,36.04 157.91,35.36 157.49,34.94 157.49,34.15 157.5,34.13 157.5,33.59 157.49,33.57 157.49,33.31 156.97,32.79 v7(156.59,32.79) 155.98,32.79 155.86,32.68 RC539.2
CLK_ITPXDP_P_R: length 41.9
  TOP w0.091: v6(134.33,16.17) 134.33,15.39 135.45,14.27 135.45,11.79 135.63,11.62 135.63,10.22 135.43,10.02 JXDP1.40
  BOTTOM w0.091: RC539.1 153.95,32.68 152.4,31.13 v7(151.74,31.13) 151.35,31.13 149.43,29.21 149.43,22.19 148.4,21.15 148.4,16.79 147.76,16.16 146.36,16.16 145.88,15.67 134.84,15.67 134.35,16.17 v6(134.33,16.17)
CLK_PCIE_N2: length 138.2
  TOP w0.091: RN18.1 52.26,53.7 LN3.4 52.26,53.45 52.11,53.3 52.11,53.17 v6(52.3,52.97)
  IN3 w0.079: v5(152.58,35.28) 152.48,35.38 152.36,35.38 152.29,35.3 152.29,35.23 152.21,35.15 152.14,35.15 151.3,36 148.97,36 147.56,34.58 147.56,33.63 147.33,33.4 147.33,30.49 147.08,30.24 147.08,29.29 148.07,28.29 148.07,22.8 147.23,21.96 139.41,21.96 136.98,19.53 132.06,19.53 130.78,20.81 128.44,20.81 127.7,20.08 124.06,20.08 123.57,19.59 121.82,19.59 121.25,20.16 121.25,20.6 121.01,20.84 120.1,20.84 120.04,20.9 118.24,20.9 117.1,19.75 115.77,19.75 115.28,20.23 114.69,20.23 111.9,23.03 111.9,24.72 109.84,26.78 106.69,26.78 105.75,27.72 97.91,27.72 97.75,27.56 95.3,27.56 95.15,27.71 91.41,27.71 90.05,29.07 83.48,29.07 82.93,29.07 82.86,29.14 82.23,29.14 76.94,34.43 75.46,34.43 74.55,35.34 70.83,35.34 66.34,39.84 65.64,39.84 64.99,40.49 64.99,41.19 62.03,44.15 62.03,44.81 62.03,44.81 62.03,44.97 61.64,45.36 61.58,45.36 61.43,45.51 61.25,45.51 58.88,47.88 58.03,47.88 56.61,49.3 56.54,49.3 56.44,49.41 55.34,49.41 52.1,52.65 52.1,52.77 v6(52.3,52.97)
  BOTTOM w0.091: v5(152.58,35.28) 152.67,35.19 153.12,35.19 153.33,35.4 153.33,36.06 152.98,36.41 152.98,36.48 152.95,36.51 152.95,36.76 153.06,36.87 153.21,36.87 153.29,36.79 UC1.BD3
CLK_PCIE_N2_R: length 2.7
  TOP w0.091: v6(52.31,55.81) 52.12,55.62 52.12,55.06 LN3.3 52.39,54.78 RN18.2
  BOTTOM w0.091: JNGFF1.53 52.26,56.43 52.11,56.28 52.11,56.24 52.11,56.01 v6(52.31,55.81)
CLK_PCIE_N3: length 174
  IN3 w0.079: v5(152.27,34.15) 152.19,34.24 151.94,34.24 150.98,35.2 149.3,35.2 148.34,34.25 148.34,33.26 148.11,33.03 148.11,30.56 148.93,29.75 148.93,22.14 148.52,21.73 148.39,21.73 147.83,21.18 139.81,21.18 138.72,20.09 138.72,19.53 137.94,18.75 131.71,18.75 130.41,20.03 128.76,20.03 128.02,19.29 124.38,19.29 123.88,18.79 121.19,18.79 119.93,20.05 118.6,20.05 117.51,18.95 115.45,18.95 114.96,19.45 114.31,19.45 111.39,22.36 97.66,22.36 97.02,23 91.57,23 91.41,23.16 89.9,23.16 89.52,22.78 85.54,22.78 85.27,22.51 82.05,22.51 79.34,25.22 79.34,30.89 76.68,33.56 75.13,33.56 74.72,33.96 70.91,33.96 65.82,39.05 65.31,39.05 64.2,40.16 64.2,40.87 61.24,43.82 61.24,44.01 58.82,46.44 57.15,46.44 55.56,48.03 48.35,48.03 48.18,48.2 46.15,48.2 44.59,49.76 42.27,49.76 41.87,50.17 40.33,50.17 39.84,50.65 26.5,50.65 25.38,51.77 21.64,51.77 21.06,52.35 21.06,53.63 21.37,53.94 21.37,53.94 21.67,54.24 22.99,54.24 v5(23.09,54.35)
  BOTTOM w0.091: UC1.BH3 150.9,36.61 150.9,35.5 151.6,34.79 151.6,34.54 151.94,34.21 152.22,34.21 v5(152.27,34.15)
CLK_PCIE_N4: length 44.2
  IN3 w0.079: v5(141.29,31.78) 141.2,31.87 140.62,31.87 140.18,32.31 138.53,32.31 138.18,32.65 138.18,32.91 136.85,34.24 132.29,34.24 131.81,33.77 130.73,33.77 130.62,33.88 125.84,33.88 124.39,32.43 122.96,32.44 120.19,29.67 118.9,29.67 v5(118.81,29.58)
  BOTTOM w0.076: 142.25,31.86 142.27,31.87
  BOTTOM w0.091: UC1.BA1 155.25,35.76 155.33,35.76 155.38,35.71 155.38,35.41 155.29,35.32 155.2,35.32 154.73,34.85 154.73,34.32 v7(153.61,33.2) 152.18,31.77 147.29,31.77 146.51,30.99 143.44,30.99 142.55,31.87 142.27,31.87 ; v5(118.81,29.58) 118.73,29.66 118.43,29.66 118.3,29.52 JSSD1.53 ; 142.25,31.86 141.61,31.86 141.6,31.87 141.38,31.87 v5(141.29,31.78)
CLK_PCIE_P2: length 138.4
  TOP w0.091: v6(51.72,52.97) 51.91,53.16 51.91,53.3 51.76,53.45 LN3.1 51.76,53.7 RN17.1
  IN3 w0.079: v6(51.72,52.97) 51.9,52.8 51.9,52.57 55.26,49.2 56.36,49.2 56.46,49.1 56.52,49.1 57.95,47.68 58.79,47.68 61.16,45.31 61.35,45.31 61.5,45.16 61.56,45.16 61.83,44.89 61.83,44.07 64.79,41.11 64.79,40.41 65.55,39.64 66.25,39.64 70.75,35.14 74.46,35.14 75.37,34.23 76.86,34.23 82.14,28.94 82.77,28.94 82.85,28.87 83.56,28.87 89.97,28.87 91.32,27.51 95.07,27.51 95.21,27.36 97.84,27.36 98,27.52 105.66,27.52 106.6,26.58 109.75,26.58 111.7,24.64 111.7,22.95 114.61,20.03 115.2,20.03 115.68,19.55 117.18,19.55 118.33,20.7 119.96,20.7 120.01,20.64 120.92,20.64 121.05,20.52 121.05,20.07 121.74,19.38 123.65,19.38 124.14,19.88 127.78,19.88 128.52,20.61 130.7,20.61 131.98,19.33 137.06,19.33 139.49,21.76 147.31,21.76 148.27,22.72 148.27,28.38 147.28,29.37 147.28,30.16 147.53,30.41 147.53,33.31 147.76,33.54 147.76,34.5 149.06,35.79 151.21,35.79 152.06,34.95 152.53,34.95 v5(152.58,34.9)
  BOTTOM w0.091: UC1.BC3 153.85,36.86 153.53,36.53 153.53,35.31 153.21,34.99 152.67,34.99 v5(152.58,34.9)
CLK_PCIE_P2_R: length 2.7
  TOP w0.091: v6(51.72,55.81) 51.91,55.62 51.91,55.07 LN3.2 51.63,54.78 RN17.2
  BOTTOM w0.091: v6(51.72,55.81) 51.91,56 51.91,56.24 51.76,56.38 JNGFF1.55
CLK_PCIE_P3: length 174
  IN3 w0.079: v5(23.09,53.7) 23.09,53.96 23.01,54.04 21.76,54.04 21.26,53.55 21.26,52.43 21.72,51.97 25.47,51.97 26.59,50.85 39.92,50.85 40.41,50.37 41.95,50.37 42.36,49.96 44.68,49.96 46.24,48.4 48.26,48.4 48.44,48.23 55.65,48.23 57.23,46.64 58.9,46.64 61.44,44.1 61.44,43.91 64.4,40.95 64.4,40.25 65.39,39.26 65.9,39.26 70.99,34.17 74.8,34.17 75.21,33.76 76.76,33.76 79.54,30.98 79.54,25.31 82.14,22.71 85.19,22.71 85.46,22.98 89.44,22.98 89.82,23.36 91.49,23.36 91.65,23.2 97.1,23.2 97.74,22.57 111.47,22.57 114.39,19.65 115.04,19.65 115.54,19.15 117.42,19.15 118.52,20.25 120.01,20.25 121.27,18.99 123.79,18.99 124.3,19.49 127.94,19.49 128.68,20.23 130.5,20.23 131.79,18.95 137.86,18.95 138.52,19.61 138.52,20.17 139.73,21.38 147.75,21.38 148.3,21.93 148.44,21.93 148.73,22.23 148.73,29.66 147.91,30.48 147.91,33.11 148.14,33.34 148.14,34.33 149.22,35.4 151.06,35.4 152.02,34.44 152.18,34.44 v5(152.27,34.53)
  BOTTOM w0.091: v5(152.27,34.53) 152.15,34.41 152.02,34.41 151.81,34.63 151.81,34.88 151.1,35.58 151.1,37.05 UC1.BH4
CLK_PCIE_P4: length 44.1
  IN3 w0.079: v5(118.81,29.96) 118.89,29.87 120.11,29.87 122.87,32.64 124.31,32.64 125.76,34.08 130.7,34.08 130.81,33.97 131.73,33.97 132.2,34.44 136.93,34.44 138.38,32.99 138.38,32.74 138.61,32.51 140.27,32.51 140.7,32.07 141.2,32.07 v5(141.29,32.16)
  BOTTOM w0.091: v5(118.81,29.96) 118.71,29.86 118.46,29.86 118.3,30.03 JSSD1.55 ; v5(141.29,32.16) 141.38,32.07 v7(141.88,32.07) 142.64,32.07 143.52,31.19 146.43,31.19 147.21,31.97 152.09,31.97 153.27,33.14 153.27,33.16 153.65,33.54 153.66,33.54 154.53,34.4 154.53,34.93 154.85,35.25 154.85,36.01 UC1.BA2
CLK_PEG_N0: length 59
  IN1 w0.079: v6(155.45,34.32) 155.27,34.5 153.96,34.5 153.43,35.02 152.22,35.02 148.54,38.7 148.54,41.88 146.61,43.81 146.61,43.82 146.47,43.95 146.47,44.09 144.98,45.58 142.32,45.58 141.55,46.35 138.29,46.35 138.12,46.52 135.97,46.52 135.48,47 134.54,47 134.21,46.67 130.29,46.67 130.25,46.63 130.24,46.63 128.58,46.63 128.24,46.28 125.79,46.28 123.21,48.87 123.21,48.98 122.56,49.63 122.24,49.63 121.44,50.44 121.44,50.46 120.82,51.08 119.89,51.08 119.83,51.14 119.48,51.13 118.49,51.13 114.8,54.83 112.32,54.83 111.74,55.4 111.74,55.79 111.81,55.85 111.81,55.86 111.84,55.89 v6(111.84,56.19)
  BOTTOM w0.091: UC1.AW2 155.99,36.03 155.99,35.51 156.06,35.43 156.06,34.74 155.85,34.53 155.65,34.53 v6(155.45,34.32) ; UV1.AD8 v6(111.84,56.19)
CLK_PEG_P0: length 58.9
  IN1 w0.079: v6(112.4,55.61) 112.4,55.79 112.28,55.92 112.15,55.92 112.01,55.77 112.01,55.77 111.95,55.71 111.95,55.49 112.41,55.03 114.72,55.03 114.88,55.03 118.57,51.33 119.48,51.33 119.88,51.34 119.89,51.33 119.92,51.33 119.98,51.28 120.9,51.28 121.64,50.54 121.64,50.52 122.33,49.84 122.64,49.84 123.41,49.07 123.41,48.95 125.88,46.48 128.15,46.48 128.5,46.83 130.16,46.83 130.21,46.88 132.21,46.88 132.21,46.88 134.13,46.88 134.46,47.21 135.57,47.21 136.05,46.72 138.2,46.72 138.37,46.55 141.64,46.55 142.4,45.78 145.06,45.78 146.67,44.17 146.67,44.04 147.72,42.99 147.72,42.99 148.74,41.96 148.74,38.79 152.31,35.22 153.51,35.22 154.04,34.7 155.24,34.7 v6(155.45,34.91)
  BOTTOM w0.091: UC1.AY3 155.92,36.47 155.92,36.25 155.79,36.12 155.79,35.42 155.86,35.35 155.86,34.83 155.76,34.73 155.63,34.73 v6(155.45,34.91) ; 112.4,55.08 v6(112.4,55.61)
CLK_SMB: length 3.9
  TOP w0.081: v2(107.14,9.87) 106.53,9.87 v1(105.98,9.32)
  IN1 w0.064: v2(107.14,9.87) 107.14,10.59 107.38,10.82 107.38,10.96 v4(107.75,11.33)
  IN3 w0.064: v5(108.15,11.79) 107.85,11.79 107.75,11.69 v4(107.75,11.33)
CLK_TP_SIO_I2C_DAT: length 109.5
  TOP w0.081: R32.2 117.5,7.74 117.56,7.68 v2(117.6,7.68) ; v2(41.78,30.04) 41.78,30.05 42.11,30.38 UE1.A48
  IN1 w0.064: v4(42.4,28.99) 42.4,29.44 41.92,29.92 41.9,29.92 41.79,30.04 v2(41.78,30.04) ; v4(37.65,12.29) 37.65,10.79 39.37,9.07 39.59,9.07 39.6,9.07 39.9,9.07 39.9,9.07 40.16,9.07 40.48,8.76 40.48,8.76 40.61,8.64 42.55,8.64 42.84,8.35 43.8,8.35 44.02,8.13 44.02,8.13 45.33,6.82 45.5,6.82 45.55,6.77 48.33,6.77 51.08,4.03 99.43,4.03 99.87,4.47 101.18,4.47 101.56,4.85 107.47,4.85 107.98,4.34 113.68,4.34 115.09,5.74 115.21,5.74 117.1,7.63 117.55,7.63 v2(117.6,7.68)
  IN3 w0.064: v4(42.4,28.99) 41.68,28.27 41.68,25.7 41.79,25.59 41.79,25.2 41.82,25.17 41.82,17.78 41.49,17.45 41.49,15.9 39.97,14.38 39.06,14.38 37.65,12.96 v4(37.65,12.29)
CLKREQ_CNV#: length 34.4
  TOP w0.081: v2(138.53,53.96) 138.53,53.55 RC73.2
  IN1 w0.064: v6(118.35,70.55) 118.38,70.58 119.63,70.58 119.66,70.54 119.99,70.54 121.24,69.29 123.76,69.29 124.33,68.72 127.65,68.72 128.08,68.29 128.08,64.7 128.87,63.9 128.87,61.89 130.46,60.3 130.46,58.93 132.8,56.59 134.05,56.59 134.84,55.8 135.21,55.8 135.21,55.8 136.12,55.8 136.49,55.43 136.49,55.43 136.75,55.17 137.6,55.17 138.01,54.76 138.01,54.28 138.15,54.14 138.15,53.76 138.31,53.6 v4(138.63,53.6) 138.63,53.73 138.53,53.83 v2(138.53,53.96)
  IN3 w0.064: v5(138.38,53.36) 138.38,53.36 138.61,53.6 138.62,53.6 v4(138.63,53.6)
  BOTTOM w0.081: UC1.CH29 138.38,53.37 v5(138.38,53.36) ; RW31.1 118.97,70.55 v6(118.35,70.55)
CLKREQ_CNV#_R: length 6.3
  IN3 w0.064: v5(119,71.16) 119.27,70.89 121.91,70.89 122.35,70.45 v5(122.35,70.25)
  BOTTOM w0.081: WL1.A43 123.19,71.25 122.82,70.89 122.82,70.43 122.64,70.25 v5(122.35,70.25)
CLKREQ_PCIE#2: length 111.3
  TOP w0.081: RC206.2 139.4,55.47 139.48,55.39 139.48,54.93 139.71,54.71 v2(139.71,54.47) ; v2(59.33,33.25) 60.79,34.71 v1(60.79,35) 60.79,37.21 60.7,37.3 QN4.3 60.55,36.92 60.33,36.69 59.54,36.69 59.09,37.14 RN96.2
  IN1 w0.064: v4(107.33,36.74) 107.13,36.74 106.97,36.9 104.59,36.9 104.36,36.66 104.36,35.86 102.13,33.64 102.13,31.9 100.4,30.17 100.38,30.14 100.32,30.08 100.29,30.06 99.34,29.11 92.88,29.11 92.6,28.84 92.22,28.84 92.05,28.67 86.76,28.67 85.8,29.62 85.1,29.62 85.1,29.62 83.84,29.62 83.8,29.62 83.48,29.62 83.45,29.62 82.9,29.62 78.78,33.74 78.26,33.74 76.39,31.88 73.87,31.88 73.79,31.88 69.87,31.88 68.5,33.24 59.35,33.24 v2(59.33,33.25) ; v2(139.71,54.47) 139.55,54.47 v4(139.39,54.31)
  IN3 w0.064: v4(107.33,36.74) 108.12,37.52 108.12,38.07 108.67,38.62 108.67,39.08 109.25,39.65 109.25,41.6 110.26,42.62 110.26,43.23 111.07,44.04 111.07,45.92 112.24,47.09 112.24,47.79 114.97,50.52 115.68,50.52 116.51,51.35 118.19,51.35 118.52,51.68 119.72,51.68 120.17,52.13 120.88,52.13 120.97,52.05 122.09,52.05 122.3,51.83 123.56,51.83 125.06,50.33 126.25,50.33 126.47,50.12 126.54,50.12 126.54,50.12 132.07,50.12 132.4,50.45 133.5,50.45 133.64,50.31 134.3,50.31 134.59,50.59 134.59,51.09 134.97,51.47 134.97,51.47 135.15,51.66 135.67,51.66 135.77,51.56 136.76,51.56 136.8,51.6 137.11,51.6 138.34,52.82 138.35,52.82 138.42,52.89 138.43,52.89 138.46,52.93 138.75,52.93 139.63,53.81 v5(139.63,54.02) 139.63,54.06 v4(139.39,54.31)
CLKREQ_PCIE#2_R: length 21.9
  TOP w0.081: v2(53.55,43.34) 53.22,43.67 53.22,45.58 52.68,46.12 52.68,47.12 v2(53.19,47.63) ; v2(53.54,41.3) 53.44,41.3 52.88,40.75 v1(52.88,39.18) 53.05,39.02 v2(53.43,39.02) ; v2(58.13,38.61) 58.13,37.95 58.36,37.72 RN96.1 58.6,38.38 RN95.1 59.04,38.39 QN4.6
  IN1 w0.064: v2(53.54,41.3) 54.23,41.99 54.23,42.67 v2(53.55,43.34) ; v2(53.19,47.63) 53.61,48.04 53.61,48.14 53.92,48.45 53.92,48.72 v4(53.95,48.74) ; v2(58.13,38.61) 58.04,38.7 58.04,38.76 57.62,39.18 53.59,39.18 v2(53.43,39.02)
  IN3 w0.064: v5(52.51,49.53) 52.51,49.39 52.78,49.12 53.2,49.12 53.58,48.74 v4(53.95,48.74)
CLKREQ_PCIE#3: length 152.8
  TOP w0.081: v2(140.7,55.33) 140.47,55.56 RC262.2 ; RT502.1 29.06,51.58 v2(29.06,52.44)
  IN1 w0.064: v4(29.35,52.26) 29.17,52.44 v2(29.06,52.44) ; v2(140.7,55.33) 140.7,55.33 140.5,55.13 v4(140.42,55.13) ; v4(41.2,54.37) 41.32,54.25 41.32,53.8 41.73,53.39 41.73,53.24 42.51,52.46 42.51,52.02 42.9,51.63 42.9,42.32 43.84,41.38 43.84,38.97 45.54,37.26 47.12,37.26 49.65,34.73 53.26,34.73 53.47,34.95 56.16,34.95 56.96,34.15 68.96,34.15 69.35,33.76 69.35,33.02 70.12,32.25 76.19,32.25 76.89,32.95 76.92,32.95 78.18,34.21 78.83,34.21 83.06,29.99 83.43,29.99 83.46,29.99 83.8,29.99 83.84,29.99 85.08,29.99 85.08,29.99 86.32,29.99 87.28,29.03 91.9,29.03 92.07,29.21 92.45,29.21 92.86,29.62 98.48,29.62 99.02,30.16 99.02,31.4 99.87,32.25 100.82,32.25 101.75,33.17 101.75,33.78 103.99,36.01 103.99,37.46 104.5,37.97 106.44,37.97 106.57,38.1 106.59,38.1 106.88,38.39 108.5,38.39 108.89,38.78 v4(109.05,38.78)
  IN3 w0.064: v4(140.42,55.13) 140.42,55.03 140.55,54.91 v5(140.55,54.67) 139.98,54.1 139.98,53.86 138.87,52.75 138.48,52.75 138.4,52.68 138.4,52.68 136.64,50.92 136.07,50.92 135.13,49.98 133.79,49.98 133.57,49.76 132.35,49.76 132.12,49.98 126.41,49.98 126.25,50.14 124.73,50.14 123.66,51.21 121.36,51.21 121.25,51.31 118.68,51.31 117.08,49.72 115.98,49.72 115.59,49.32 115.03,49.32 114.15,48.45 113.83,48.45 112.61,47.23 112.61,46.94 111.44,45.77 111.44,43.89 110.63,43.08 110.63,42.47 109.61,41.45 109.61,39.26 109.14,38.78 v4(109.05,38.78) ; v5(28.94,52.4) 29.08,52.26 29.32,52.26 29.32,52.26 v4(29.35,52.26) 29.37,52.24 29.52,52.24 30.15,52.87 30.55,52.87 32.3,54.62 33.88,54.62 34.09,54.42 34.33,54.42 34.43,54.51 36.34,54.51 36.6,54.77 39.07,54.77 39.44,54.4 41.17,54.4 v4(41.2,54.37)
CLKREQ_PCIE#4: length 56.3
  TOP w0.081: v2(140.58,53.83) 140.26,54.14 v1(140.24,54.14) 140.24,54.67 140.04,54.87 140.04,55.55 RC88.2
  IN1 w0.064: v4(140.26,53.71) 140.46,53.71 v2(140.58,53.83)
  IN3 w0.064: v5(107.76,36.36) 107.76,36.46 109.98,38.68 109.98,41.3 111,42.32 111,42.92 111.81,43.73 111.81,45.62 112.79,46.59 113.14,46.59 115.5,48.95 115.74,48.95 116.14,49.35 117.23,49.35 118.76,50.87 121.07,50.87 121.17,50.77 123.46,50.77 124.37,49.86 125.2,49.86 125.3,49.96 126.21,49.96 126.41,49.76 127.8,49.76 127.85,49.72 127.85,49.72 127.95,49.62 133.62,49.62 133.84,49.83 135.19,49.83 136.1,50.74 136.65,50.74 138.45,52.54 138.93,52.54 140.09,53.71 v4(140.26,53.71) 140.55,53.99 v5(140.55,54.02)
  BOTTOM w0.081: v5(107.76,36.36) 107.53,36.13 107.53,29.67 107.92,29.28 JSSD1.52
CLKREQ_PEG#0: length 49.7
  TOP w0.081: RC78.2 138.86,55.37 v2(139.17,55.07) ; v2(109,42.74) 109.01,42.74 109.06,42.79 v1(111.15,42.79) 111.68,42.79 112.12,42.35 112.94,42.35 113.6,43 114.34,43 114.74,42.61 QV3.1
  IN1 w0.064: v2(109,42.74) v4(108.64,42.74) ; v4(139.5,55.05) 139.22,55.05 139.22,55.06 139.18,55.06 139.17,55.07 v2(139.17,55.07)
  IN3 w0.064: v4(108.64,42.74) 109.28,43.37 109.28,45.16 110.11,45.99 110.11,46.21 111.35,47.46 111.35,48.16 114.61,51.41 115.32,51.41 116.14,52.24 117.82,52.24 118.16,52.57 118.35,52.57 118.8,53.02 122.97,53.02 125.43,50.56 126.3,50.56 126.6,50.26 131.86,50.26 132.78,51.17 134.32,51.17 135.53,52.38 137.34,52.38 138.06,53.1 138.67,53.1 139.05,53.48 139.05,54.48 139.48,54.91 139.48,55.04 v4(139.5,55.05) 139.83,55.05 v5(139.93,54.95)
  BOTTOM w0.081: UC1.CF32 139.88,54.96 v5(139.93,54.95)
CLKREQ_PEG#0_R: length 34.4
  TOP w0.081: v2(115.89,42.64) 116.48,42.05 QV3.3
  IN1 w0.064: v2(115.89,42.64) 115.6,42.92 115.6,43.64 115.37,43.88 115.07,43.88 114.68,43.48 112.27,43.48 111.29,44.46 111.29,45.81 111.93,46.45 111.93,52.55 113.64,54.26 113.94,54.26 v4(114.09,54.41)
  IN3 w0.064: v5(118.35,57.06) 118.31,57.06 116.55,55.3 115.07,55.3 114.19,54.41 v4(114.09,54.41)
  BOTTOM w0.081: UV1.AC6 113.01,57.37 113.37,57.01 113.75,57.01 114.59,57.85 114.92,57.85 115.15,57.62 115.51,57.62 115.74,57.85 116.04,57.85 117.27,56.62 118.15,56.62 118.9,55.87 119.17,55.87 119.39,55.65 119.67,55.65 RV68.2 119.69,55.71 v5(118.35,57.06)
CLM_5V: length 1.4
  BOTTOM w0.254: PU501.11 15.21,21.99 14.89,21.67 PR503.2
CLM_+1.35VGPU: length 5
  TOP w0.254: PUW01.13 66.08,55.08 65.37,55.79 v1(65.37,57.04) 64.74,57.66 PRW17.2 64.31,58.63 PRW23.1
CLR#_U34: length 5.6
  TOP w0.081: U34.3 62.46,27.28 62.19,27.55 61.7,27.55 60.22,29.02 v1(60.22,29.17) 60.22,29.3 59.46,30.06 RE97.2
CMOUT_CHG: length 4.7
  BOTTOM w0.203: PRB27.2 PRB29.2 194.53,29.16 194.53,27.32 195.31,26.54 PUB01.26
CMP_STRAP: length 3.6
  TOP w0.081: v2(48.88,20.09) 48.98,20.19 UE1.B15
  IN1 w0.064: v2(50.31,18.34) 50.12,18.34 49.68,18.79 48.86,18.79 48.46,19.18 48.46,19.67 v2(48.88,20.09)
CNV_BRI_CRX_DTX: length 34.8
  IN1 w0.064: v6(118.39,67.27) 118.52,67.14 118.52,63.72 118.4,63.6 118.4,62.38 118.14,62.12 118.14,62.12 118.14,60.04 118.74,59.44 118.74,55.39 121.49,52.64 122.01,52.12 122.01,52.07 122.9,51.18 123.26,51.18 125.14,49.3 125.14,49.18 125.68,48.64 125.8,48.64 126.53,47.91 136.73,47.91 v4(136.83,47.81)
  IN3 w0.064: v5(137.24,47.82) 137.22,47.81 v4(136.83,47.81)
  BOTTOM w0.081: RW27.2 118.53,67.41 v6(118.39,67.27)
CNV_BRI_CRX_R_DTX: length 6.2
  IN3 w0.064: v5(119.02,66.83) 119.61,67.42 122.01,67.42 v5(122.35,67.75)
  BOTTOM w0.081: WL1.A39 123.78,69.25 122.9,68.37 122.9,68.09 122.56,67.75 v5(122.35,67.75)
CNV_BRI_CTX_DRX: length 2.8
  TOP w0.081: v1(137.8,49.65) 138.1,49.34 RW26.2 138.1,48.57 137.89,48.36 v2(137.65,48.36)
  IN1 w0.064: v2(137.65,48.36) 137.7,48.31 v4(138.13,48.31)
  IN3 w0.064: v5(137.89,47.82) 137.89,48.07 v4(138.13,48.31)
CNV_BRI_CTX_R_DRX: length 42.8
  IN1 w0.064: v2(137.52,48.8) 137.52,48.63 137.42,48.53 137.21,48.53 136.86,48.88 134.17,48.88 134.13,48.93 133.91,49.14 133.61,49.14 133.4,48.93 133.4,48.63 133.32,48.54 126.71,48.54 126.04,49.21 125.92,49.21 125.71,49.42 125.71,49.54 123.5,51.75 123.14,51.75 122.58,52.31 122.58,52.36 121.73,53.21 119.31,55.63 119.31,59.67 118.71,60.27 118.71,61.88 118.97,62.14 118.97,63.33 119.15,63.51 119.15,66.95 119.16,66.95 119.16,67.59 119.15,67.59 119.15,68.75 v4(118.49,69.42)
  IN3 w0.064: v4(118.49,69.42) 119,68.91 119.62,68.91 119.74,69.02 122.09,69.02 122.1,69.01 v5(122.35,69.25) 122.35,69.26 123.33,69.26 123.83,68.75 v5(124.1,68.75)
CNV_COEX1: length 163.7
  TOP w0.081: v2(49.36,49.74) 49.33,49.74 RW11.2
  IN1 w0.064: v2(49.36,49.74) 49.4,49.74 49.68,50.02 49.68,50.31 v4(49.72,50.35)
  IN2 w0.066: v4(36.39,51.95) 36.77,51.57 36.77,48.36 41.08,44.05 41.08,41.45 42.6,39.93 51.55,39.93 53.21,38.27 56.94,38.27 65.81,29.39 65.81,22.97 73,15.79 80.45,15.79 81.32,16.65 88.64,16.65 89.48,15.81 92.25,15.81 92.48,16.04 110.56,16.04 111.71,17.19 113.36,17.19 114.91,15.64 118.14,15.64 122.19,19.7 122.39,19.7 122.72,20.03 123.06,20.37 123.06,20.37 123.16,20.47 123.16,22.2 127.59,26.63 129.33,26.63 131.35,28.65 131.35,33.06 132.33,34.05 132.33,37.04 131.16,38.21 131.16,39.42 132.29,40.55 132.29,41 132.49,41.2 132.49,41.2 135.19,43.91 138.08,43.91 138.52,44.34 138.52,44.67 139.07,45.22 v4(139.07,45.32)
  IN3 w0.064: v5(138.54,45.75) 138.83,45.75 139.03,45.54 139.03,45.36 v4(139.07,45.32) ; v4(36.39,51.95) 36.87,51.95 37.14,51.69 40.66,51.69 41.14,51.2 42.3,51.2 42.7,50.79 45.02,50.79 45.29,50.53 45.56,50.53 45.61,50.48 46.84,50.48 46.94,50.57 49.23,50.57 49.38,50.42 49.65,50.42 v4(49.72,50.35)
CNV_COEX2: length 167.2
  TOP w0.081: v1(50.15,50.61) 50.49,50.27 v2(50.49,49.74)
  IN1 w0.064: v4(51.05,50.31) 50.49,49.76 v2(50.49,49.74)
  IN2 w0.066: v4(137.71,45.24) 137.71,45.21 137.62,45.12 137.62,44.6 137.18,44.16 135.17,44.16 134.03,43.03 133.97,43.03 132.1,41.15 132.1,40.66 130.9,39.46 130.9,38.02 132.14,36.77 132.14,34.13 131.15,33.14 131.15,28.73 129.25,26.82 127.41,26.82 122.97,22.38 122.97,20.55 122.87,20.45 122.87,20.45 122.64,20.22 122.31,19.89 122.11,19.89 118.06,15.84 114.99,15.84 113.44,17.38 111.63,17.38 110.48,16.23 92.4,16.23 92.17,16 89.56,16 88.72,16.84 81.24,16.84 80.37,15.98 73.08,15.98 66.01,23.05 66.01,29.47 65.16,30.32 65.16,30.81 57.51,38.46 53.29,38.46 51.63,40.12 51.31,40.12 50.45,40.98 48.24,40.98 47.76,40.5 44.65,40.5 44.4,40.25 42.55,40.25 41.58,41.22 41.58,44.01 36.96,48.63 36.96,52.24 36.72,52.48 v4(36.33,52.48)
  IN3 w0.064: v4(51.05,50.31) 49.99,51.37 49.48,51.37 47.97,52.89 45.8,52.89 45.4,52.73 44.29,51.61 43.03,51.61 42.77,51.88 37.39,51.88 37.38,51.87 36.77,52.48 v4(36.33,52.48) ; v4(137.71,45.24) 137.71,45.56 137.89,45.73 v5(137.89,45.75)
CNV_COEX3: length 128.8
  TOP w0.081: RW13.2 52.25,49.98 v2(52.43,50.15) 52.43,50.31 v1(52.74,50.62)
  IN1 w0.064: v4(52.03,50.27) 52.31,50.27 v2(52.43,50.15)
  IN2 w0.066: v4(133.93,47.54) 133.93,47.49 128.91,42.47 127.75,42.47 125.12,39.83 125.12,36.69 122.97,34.53 121.27,34.53 113.11,26.37 112.54,26.37 111.89,27.01 111.89,27.91 111.6,28.2 109.07,28.2 108.48,28.79 99.77,28.79 99.59,28.97 81.54,28.97 81.18,28.62 72.31,28.62 65.64,35.29 65.64,35.31 63.56,37.39 62.5,37.39 59.38,40.51 59.38,40.98 56.77,43.59 55.68,43.59 55.49,43.4 52.85,43.4 52.61,43.64 47.73,43.64 47.07,44.3 47.07,45.74 43.04,49.76 43.04,50.98 v4(42.53,51.48)
  IN3 w0.064: v5(135.32,47.61) 135.24,47.61 135.13,47.49 133.98,47.49 v4(133.93,47.54) ; v4(42.53,51.48) 43.03,50.98 45.1,50.98 45.37,50.72 45.64,50.72 45.69,50.67 46.76,50.67 46.86,50.76 48.97,50.76 49.1,50.89 49.81,50.89 50.83,49.87 51.52,49.87 51.92,50.27 v4(52.03,50.27)
CNV_CRX_DTX_N0: length 32.7
  IN1 w0.079: v6(133.38,53.24) 133.19,53.43 132.74,53.43 132.74,53.43 132.21,53.43 132.06,53.58 132.05,53.58 131.7,53.93 131.35,53.93 131.2,53.78 131.2,53.3 131.27,53.23 131.62,53.23 131.88,52.97 131.88,52.59 131.38,52.1 128.43,52.1 128.11,52.42 128.11,53.05 128.11,53.05 128.11,53.52 127.98,53.65 127.56,53.65 127.46,53.55 127.46,53.01 127.32,52.87 127.32,52.87 127.27,52.81 126.91,52.81 125.46,54.26 124.84,54.26 124.74,54.36 123.33,54.36 121.28,56.42 121.28,57.06 120.92,57.41 120.92,60.4 120.58,60.74 120.58,62.22 121.17,62.82 121.17,63.61 121.65,64.08 121.65,64.38 121.24,64.79 121.24,66.88 121.5,67.15 121.7,67.15 v2(121.79,67.24)
  BOTTOM w0.091: UC1.CR30 134.53,54.01 134.43,54.01 134.04,53.62 133.87,53.62 133.8,53.54 133.8,53.4 133.9,53.29 133.9,53.16 133.81,53.07 133.55,53.07 v6(133.38,53.24)
CNV_CRX_DTX_N1: length 33.6
  IN1 w0.079: v2(121.79,68.37) 121.7,68.28 121.25,68.28 120.49,67.52 120.49,64.83 120.41,64.75 120.41,63.59 120.49,63.51 120.49,63.21 119.94,62.66 119.94,60.39 120.34,59.99 120.34,57.66 120.34,57.17 120.34,57.17 120.34,56.95 120.54,56.75 120.54,56.75 120.62,56.67 120.62,56.25 123.09,53.78 124.49,53.78 124.6,53.67 125.21,53.67 126.7,52.18 127.14,52.18 127.93,51.39 131.53,51.39 132.78,52.64 134.83,52.64 135.09,52.89 136.52,52.89 136.76,53.13 136.76,53.58 136.88,53.7 136.99,53.7 v6(136.99,53.7)
  BOTTOM w0.091: UC1.CM30 136.74,53.95 v6(136.99,53.7)
CNV_CRX_DTX_P0: length 32.6
  IN1 w0.079: v2(121.79,66.68) 121.98,66.68 122.05,66.75 122.05,66.85 121.95,66.95 121.59,66.95 121.44,66.8 121.44,64.87 121.85,64.46 121.85,64 121.37,63.53 121.37,62.74 120.78,62.14 120.78,60.83 121.12,60.48 121.12,60.32 121.12,57.5 121.13,57.5 121.48,57.14 121.48,56.5 123.42,54.56 124.82,54.56 124.92,54.46 125.54,54.46 126.99,53.02 127.18,53.02 127.25,53.09 127.25,53.63 127.48,53.85 128.06,53.85 128.31,53.6 128.31,52.5 128.51,52.3 131.3,52.3 131.67,52.67 131.67,52.89 131.53,53.03 131.19,53.03 131,53.22 131,53.86 131.27,54.13 131.79,54.13 132.13,53.78 132.14,53.78 132.29,53.63 133.19,53.63 v6(133.38,53.82)
  BOTTOM w0.091: v6(133.38,53.82) 133.95,53.82 134.35,54.22 134.78,54.22 135.17,54.06 UC1.CP30
CNV_CRX_DTX_P1: length 33.7
  IN1 w0.079: v6(136.16,53.49) 136.16,53.54 136.14,53.55 136.14,53.81 136.22,53.88 136.46,53.88 136.56,53.78 136.56,53.42 136.56,53.41 136.56,53.22 136.44,53.1 135,53.1 134.75,52.84 132.7,52.84 131.44,51.59 128.02,51.59 127.22,52.38 126.78,52.38 125.29,53.87 124.68,53.87 124.58,53.98 123.18,53.98 120.82,56.34 120.82,56.76 120.74,56.83 120.74,56.84 120.54,57.03 120.54,57.25 120.54,57.26 120.54,57.57 120.54,57.57 120.54,60.07 120.14,60.47 120.14,62.57 120.69,63.12 120.69,63.29 120.69,63.6 120.61,63.68 120.61,64.67 120.69,64.75 120.69,67.43 121.33,68.07 121.67,68.07 121.67,68.07 121.8,68.07 121.88,68 121.88,67.89 v2(121.79,67.8)
  BOTTOM w0.091: v6(136.16,53.49) 135.94,53.71 UC1.CN30
CNV_CRX_R_DTX_N0: length 2
  TOP w0.091: v6(122.99,67.3) 122.76,67.06 122.56,67.06 RW56.1
  BOTTOM w0.091: WL1.A35 123.93,67.25 123.78,67.1 123.18,67.1 v6(122.99,67.3)
CNV_CRX_R_DTX_N1: length 2.1
  TOP w0.091: v6(123.42,68.3) 123.23,68.1 122.98,68.1 122.9,68.19 122.56,68.19 RW58.1
  BOTTOM w0.091: WL1.A37 123.93,68.25 123.77,68.1 123.61,68.1 v6(123.42,68.3)
CNV_CRX_R_DTX_P0: length 2
  TOP w0.091: RW55.1 122.56,66.86 122.84,66.86 v6(122.99,66.71)
  BOTTOM w0.091: v6(122.99,66.71) 123.18,66.9 123.79,66.9 123.94,66.75 WL1.A34
CNV_CRX_R_DTX_P1: length 2
  TOP w0.091: v6(123.42,67.71) 123.23,67.9 122.9,67.9 122.82,67.98 122.56,67.98 RW57.1
  BOTTOM w0.091: v6(123.42,67.71) 123.6,67.89 123.7,67.89 123.7,67.9 123.8,67.9 123.94,67.75 WL1.A36
CNV_CTX_DRX_N0: length 16.5
  TOP w0.091: v6(135.01,67.37) 134.81,67.57 134.56,67.57 RW49.2
  IN3 w0.079: v5(135.94,55.22) 135.94,55.49 136.01,55.57 136.17,55.57 136.24,55.49 136.24,55.02 136.17,54.94 135.35,54.94 134.74,55.56 134.74,55.69 134.52,55.91 134.52,56.35 134.67,56.5 134.67,57.44 134.69,57.46 134.69,61.95 134.69,62.62 134.78,62.71 134.78,65.62 134.78,65.62 134.78,65.67 134.57,65.89 134.57,67.41 134.72,67.57 134.83,67.57 134.84,67.56 134.94,67.56 135.01,67.49 v6(135.01,67.37)
CNV_CTX_DRX_N1: length 16.6
  TOP w0.091: RW51.2 134.54,66.44 134.74,66.44 v6(134.98,66.19)
  IN3 w0.079: v5(134.98,55.87) 135.05,55.8 135.27,55.8 135.33,55.87 135.33,56.39 135.09,56.64 135.09,58 135.08,58.01 135.08,58.59 135.11,58.61 135.11,59.91 135.07,59.95 135.07,62.36 135.27,62.57 135.27,62.73 135.27,65.05 136.31,66.09 136.31,67.86 136.21,67.96 135.93,67.96 135.81,67.84 135.81,66.59 135.62,66.4 135.19,66.4 v6(134.98,66.19)
CNV_CTX_DRX_P0: length 16.5
  TOP w0.091: v6(135.01,67.96) 134.83,67.77 134.57,67.77 RW47.2
  IN3 w0.079: v6(135.01,67.96) 134.82,67.77 134.64,67.77 134.37,67.49 134.37,65.81 134.58,65.59 134.58,65.54 134.58,65.54 134.58,62.8 134.49,62.7 134.49,62.52 134.48,62.52 134.48,61.87 134.49,61.87 134.49,57.54 134.47,57.52 134.47,56.58 134.31,56.43 134.31,55.83 134.54,55.6 134.54,55.47 135.21,54.8 135.21,54.8 135.27,54.74 136.25,54.74 136.45,54.94 136.45,55.04 v5(136.59,55.18)
CNV_CTX_DRX_P1: length 16.6
  TOP w0.091: RW50.2 134.59,66.64 134.85,66.64 v6(134.98,66.78)
  IN3 w0.079: v5(135.7,55.83) 135.54,56 135.54,56.19 135.53,56.19 135.53,56.47 135.29,56.72 135.29,58.09 135.28,58.09 135.28,58.5 135.31,58.53 135.31,60 135.27,60.03 135.27,62.28 135.47,62.48 135.47,62.61 135.47,62.81 135.47,62.81 135.47,64.96 136.51,66 136.51,67.94 136.29,68.16 135.84,68.16 135.61,67.93 135.61,66.68 135.54,66.61 135.16,66.61 v6(134.98,66.78)
CNV_CTX_R_DRX_N0: length 2.4
  TOP w0.091: RW49.1 133.6,67.6 133.46,67.6 133.23,67.38 133.05,67.38 v6(132.85,67.17)
  BOTTOM w0.091: WL1.A22 132,67.25 132.14,67.4 132.63,67.4 v6(132.85,67.17)
CNV_CTX_R_DRX_N1: length 2.3
  TOP w0.091: v6(132.4,66.23) 132.59,66.42 133.05,66.42 133.1,66.46 133.63,66.46 RW51.1
  BOTTOM w0.091: WL1.A24 131.96,66.25 132.1,66.39 132.23,66.39 v6(132.4,66.23)
CNV_CTX_R_DRX_P0: length 2.4
  TOP w0.091: v6(132.85,67.76) 133.03,67.58 133.15,67.58 133.37,67.8 133.65,67.8 RW47.1
  BOTTOM w0.091: WL1.A21 131.98,67.75 132.13,67.61 132.17,67.61 132.29,67.61 132.3,67.6 132.63,67.6 132.63,67.61 132.7,67.61 v6(132.85,67.76)
CNV_CTX_R_DRX_P1: length 2.3
  TOP w0.091: RW50.1 133.63,66.66 133.01,66.66 132.97,66.62 132.59,66.62 v6(132.4,66.81)
  BOTTOM w0.091: v6(132.4,66.81) 132.24,66.66 132.06,66.66 131.97,66.75 WL1.A23
CNV_RF_RESET#: length 32.5
  TOP w0.081: v2(136.93,55.62) RC74.2 ; v6(121.73,69.75) 121,69.75 v1(120.74,69.5)
  IN1 w0.064: v4(137.95,55.81) 137.76,55.62 v2(136.93,55.62) 136.31,56.24 135.02,56.24 134.45,56.82 132.85,56.82 130.68,58.99 130.68,60.48 129.45,61.71 129.45,64.03 129.18,64.29 129.18,68.29 127.72,69.75 v6(121.73,69.75)
  IN3 w0.064: v5(119,69.37) 119.1,69.46 121.44,69.46 v6(121.73,69.75)
  IN3 w0.089: v4(137.95,55.81) 137.95,55.66 138.1,55.51 v5(138.11,55.51)
  BOTTOM w0.081: v5(138.11,55.51) 138.09,55.49 138.09,55.44 137.97,55.32 UC1.CJ32 ; WL1.58 v6(121.73,69.75)
CNV_RF_RESET#_R: length 5.9
  IN3 w0.064: v5(118.98,69.95) 119.54,69.95 120.04,70.45 121.63,70.45 122.17,69.91 123.26,69.91 v5(124.1,70.75)
CNV_RGI_CRX_DTX: length 39.9
  TOP w0.081: v2(138.22,47.86) 138.29,47.79 RC122.2
  IN1 w0.064: v4(118.3,68.87) 118.96,68.21 118.96,67.51 118.97,67.51 118.97,67.03 118.96,67.02 118.96,63.59 118.78,63.41 118.78,62.22 118.52,61.96 118.52,60.19 119.12,59.59 119.12,55.55 121.65,53.02 122.39,52.28 122.39,52.23 123.06,51.56 123.42,51.56 125.52,49.46 125.52,49.34 125.84,49.02 125.96,49.02 126.63,48.35 134.34,48.35 134.64,48.65 136.81,48.65 137.39,48.07 137.85,48.07 138.06,47.86 v2(138.22,47.86) 138.52,47.86 138.98,47.39 v4(139.01,47.39)
  IN3 w0.064: v5(119.02,68.62) 118.55,68.62 v4(118.3,68.87) ; v4(139.01,47.39) 139.01,47.25 v5(138.54,46.78)
CNV_RGI_CRX_R_DTX: length 6.3
  IN3 w0.064: v5(119.02,68.04) 119.82,68.83 122.02,68.83 122.09,68.75 v5(122.35,68.75)
  BOTTOM w0.081: v5(122.35,68.75) 122.6,68.75 122.97,69.13 122.97,69.48 123.74,70.25 WL1.A41
CNV_RGI_CTX_DRX: length 7.1
  TOP w0.081: RW24.2 135.89,47.76 v1(136.14,48) 136.44,48.31 v2(136.7,48.31) ; RC108.2 140.61,47.58 RC162.2 140.12,47.58 139.78,47.58 v2(139.73,47.53)
  IN1 w0.064: v2(139.73,47.53) 139.73,47.32 v4(139.5,47.1) 139.43,47.03 139.16,47.03 139.16,47.03 138.85,47.03 138.85,47.03 138.53,47.03 138.23,47.33 138.23,47.44 138.01,47.67 137.98,47.67 137.94,47.71 137.85,47.71 137.76,47.81 137.35,47.81 136.98,48.17 136.8,48.17 136.7,48.27 v2(136.7,48.31)
  IN3 w0.064: v5(139.19,46.78) v4(139.5,47.1)
CNV_RGI_CTX_R_DRX: length 40
  IN1 w0.064: v4(118.37,68.25) 118.37,68.04 118.77,67.64 118.77,67.44 118.78,67.43 118.78,67.11 118.77,67.1 118.77,63.7 118.59,63.53 118.59,62.3 118.33,62.04 118.33,60.11 118.93,59.51 118.93,55.47 121.57,52.83 122.2,52.2 122.2,52.15 122.98,51.37 123.34,51.37 125.33,49.38 125.33,49.26 125.76,48.83 125.88,48.83 126.61,48.1 134.51,48.1 134.75,48.34 v2(135.18,48.34)
  IN3 w0.064: v4(118.37,68.25) 118.37,67.74 118.45,67.66 118.55,67.66 118.56,67.65 121.74,67.65 v5(122.35,68.25)
  BOTTOM w0.081: WL1.A40 123.95,69.75 122.45,68.25 v5(122.35,68.25)
CNV_WT_RCOMP: length 3.1
  BOTTOM w0.203: RC60.2 132.93,55.23 133.36,55.65 134.33,55.65 134.64,55.35 UC1.CR32 135.26,55.32 UC1.CP32
COMP_CHG: length 2.7
  BOTTOM w0.203: PUB01.28 196.11,27.18 195.89,27.4 PCB39.1
  BOTTOM w0.254: PRB30.1 196.72,27.7 PCB39.1
CPU_C10_GATE#: length 59.3
  TOP w0.081: UC18.1 109.99,26.06 109.91,25.97 108.46,25.97 108.17,26.27 v1(108.17,30.19) 108.17,31.99 109.97,33.8 109.97,37.67 108.17,39.47 v6(108.17,40.43)
  IN1 w0.064: v4(137.07,52.06) 137.38,52.06 v2(137.4,52.07)
  IN3 w0.064: v4(137.07,52.06) 136.73,51.72 135.85,51.72 135.61,51.96 v5(135.61,52.04) ; v6(108.17,40.43) 108.04,40.56 108.04,43.33 108.64,43.92 108.64,46.88 109.28,47.52 109.81,47.52 114.34,52.05 115.05,52.05 115.88,52.87 117.56,52.87 117.89,53.21 118.09,53.21 118.53,53.65 123.23,53.65 125.21,51.68 127.02,51.68 127.68,51.02 127.83,51.02 127.84,51.01 127.94,51.01 127.94,51 132.15,51 v5(132.33,51.19)
  BOTTOM w0.081: v5(135.61,52.04) 135.46,52.04 135.14,52.36 133.92,52.36 132.96,51.4 132.61,51.4 132.4,51.19 v5(132.33,51.19) 131.67,51.19 RC230.1
CPU_DP1_AUXN: length 186.5
  IN1 w0.079: v4(35.16,42.47) 35.03,42.33 34.89,42.33 34.79,42.43 34.79,43.54 34.11,44.22 34.11,51.64 34.51,52.04 34.51,53.63 34.21,53.92 34.21,54.37 33.91,54.68 33.91,54.85 34.05,54.99 34.16,54.99 v6(34.29,54.85)
  IN3 w0.079: v4(35.16,42.47) 35.33,42.3 35.55,42.3 36.26,41.59 40.03,41.59 41.17,41.12 42.88,39.41 47.63,39.41 49,38.84 49.7,38.14 53.71,36.48 54.88,35.31 56.08,35.31 61.98,29.41 61.98,29.41 62.21,29.18 62.21,28.55 63.63,27.13 63.63,27.13 64.21,26.55 64.21,25.39 65.3,24.29 65.3,21.79 72.37,14.72 74.11,14.72 77.49,13.32 82.44,13.32 83.63,12.14 88.77,10.01 91.35,8.28 99.05,8.28 99.15,8.19 118.9,8.19 119.23,8.52 130.05,8.52 130.22,8.69 150.54,8.69 150.54,8.69 150.63,8.69 151.68,9.74 152.03,10.09 152.86,10.92 155.69,12.03 156.58,12.03 158.6,13.01 158.69,13.1 158.69,13.11 158.98,13.39 159.53,13.94 159.53,16.73 160.62,17.82 160.62,18.07 160.57,18.12 160.57,18.87 160.87,19.17 160.87,26.56 160.27,27.16 160.27,32.26 160.27,32.34 160.3,32.37 160.3,32.38 163.6,35.68 163.6,36.06 164.14,36.6 165.17,36.6 166.15,37.57 166.15,38.65 165.89,38.91 165.89,39.17 166.05,39.34 166.26,39.34 166.33,39.41 166.33,39.61 166.26,39.68 v5(166.19,39.68)
  BOTTOM w0.091: CT19.2 33.85,55.06 34.09,55.06 v6(34.29,54.85)
CPU_DP1_AUXN_C: length 2.4
  BOTTOM w0.091: CT19.1 32.9,55.07 32.52,55.07 32.44,55.15 31.17,55.15 UT1.P2
CPU_DP1_AUXP: length 186.5
  IN1 w0.079: v6(34.29,55.44) 34.05,55.19 33.97,55.19 33.84,55.07 33.84,55.06 33.71,54.93 33.71,54.6 34.01,54.29 34.01,53.84 34.31,53.54 34.31,52.13 33.91,51.73 33.91,44.14 34.59,43.46 34.59,42.34 34.7,42.24 34.7,42.23 34.8,42.13 34.96,42.13 v4(35.16,41.93)
  IN3 w0.079: v5(166.19,39.03) 166.19,38.9 166.35,38.74 166.35,37.49 165.26,36.4 164.22,36.4 163.8,35.98 163.8,35.6 160.5,32.3 160.5,32.29 160.47,32.26 160.47,27.24 161.07,26.64 161.07,19.09 160.77,18.79 160.77,18.2 160.82,18.15 160.82,17.74 159.73,16.65 159.73,13.86 159.1,13.23 159.1,13.23 158.85,12.99 158.71,12.85 156.63,11.83 155.73,11.83 152.98,10.74 152.12,9.89 152.12,9.89 151.82,9.59 151.8,9.57 151.76,9.53 150.72,8.49 130.3,8.49 130.13,8.32 119.31,8.32 118.98,7.99 99.06,7.99 98.97,8.08 91.29,8.08 88.67,9.83 83.52,11.97 82.36,13.12 77.45,13.12 74.07,14.52 72.29,14.52 65.1,21.71 65.1,24.21 64,25.31 64,26.47 63.55,26.93 63.55,26.93 62.01,28.46 62.01,29.1 61.72,29.39 61.72,29.39 56,35.11 54.8,35.11 53.6,36.31 49.59,37.97 48.88,38.67 47.59,39.21 42.8,39.21 41.06,40.95 39.99,41.39 36.18,41.39 35.47,42.1 35.33,42.1 v4(35.16,41.93)
  BOTTOM w0.091: CT18.2 33.85,55.26 34.12,55.26 v6(34.29,55.44)
CPU_DP1_AUXP_C: length 2.4
  BOTTOM w0.091: CT18.1 32.92,55.27 32.6,55.27 32.52,55.35 31.84,55.35 31.59,55.6 31.31,55.6 31.25,55.54 31.25,55.44 31.31,55.38 UT1.P1
CPU_DP1_CTRL_DATA: length 1.7
  TOP w0.091: v1(142.34,40.59) 142.34,40.65 v2(141.97,41.02) 141.65,41.02 RC8.1
  IN1 w0.079: v2(141.97,41.02) 141.97,41.01 141.89,40.93 v4(141.64,40.93)
  IN3 w0.079: v5(141.25,40.98) 141.3,40.93 v4(141.64,40.93)
CPU_DP1_HPD: length 152.6
  IN2 w0.066: v4(33.53,54.17) 33.55,54.19 34.12,54.19 34.69,53.61 34.69,52.61 35.09,52.21 35.09,51.83 35.46,51.46 35.46,50.95 35.71,50.7 35.71,48.38 40.07,44.02 40.07,41.64 42.48,39.23 50.5,39.23 52.18,37.55 55.44,37.55 65.22,27.77 65.22,22.01 67.16,20.07 67.4,20.07 72.31,15.15 80.64,15.15 81.56,16.07 88.4,16.07 89.24,15.23 92.49,15.23 92.72,15.46 110.8,15.46 111.95,16.61 113.12,16.61 114.56,15.18 114.67,15.06 118.38,15.06 121.75,18.44 122.8,18.44 124.12,19.76 124.12,22.34 127.77,25.99 129.54,25.99 131.93,28.38 131.93,32.82 132.91,33.81 132.91,34.24 133.63,34.95 133.63,35.82 133.31,36.13 133.31,37.68 132.63,38.36 v4(132.63,38.71)
  IN3 w0.064: v5(131.75,38.44) 131.84,38.53 132.02,38.53 132.21,38.71 v4(132.63,38.71) ; v5(30.24,52.4) 30.61,52.4 31.29,53.08 32.15,53.08 33.25,54.17 v4(33.53,54.17)
  BOTTOM w0.081: v5(131.75,38.44) 131.66,38.44 131.51,38.6 RC504.1 131.51,38.86 131.89,39.24 134.63,39.24 134.76,39.11 135.72,39.11 135.94,38.9 UC1.CN6
CPU_DP1_N0: length 187.7
  IN1 w0.079: v4(30.34,44.86) 30.57,45.09 30.67,45.09 30.68,45.1 30.7,45.1 30.94,45.34 30.94,46.12 30.6,46.46 30.6,50.55 30.61,50.57 30.61,55.25 30.92,55.56 30.92,58.59 30.9,58.61 30.84,58.87 30.1,60.32 29.51,60.91 29.51,61 v2(29.67,61.16)
  IN3 w0.079: v5(161.23,38.39) 161.12,38.5 160.88,38.5 160.88,38.5 160.64,38.5 157.43,35.29 157.43,33.3 157.43,33.29 157.43,25.39 157.33,25.28 157.33,25.28 157.26,25.21 157.26,20.68 156.87,20.29 156.87,18.07 156.54,17.47 156.38,17.39 155.72,17.39 155.11,16.79 155.11,15.84 154.76,15.49 154.76,14.7 154.64,14.65 146.76,11.41 127.91,11.41 127.23,12.09 126.24,12.09 126.2,12.05 119.29,12.05 118.52,12.82 108.17,12.82 106.97,14.02 99.66,14.02 98.97,14.71 98.97,14.71 98.27,15.4 87.24,15.4 86.77,15.86 86.57,15.86 86.07,16.36 80.42,16.36 78.4,18.38 75.77,18.38 74.93,19.21 74.93,19.3 74.94,19.3 74.94,20.3 74.14,21.09 70.38,21.09 68.22,23.26 68.22,27.92 65.95,30.18 65.95,30.25 65.2,31 65.2,31.19 57.94,38.45 55.8,38.45 53.03,41.21 52.53,41.21 52.46,41.24 50.96,41.87 50.58,42.24 44.56,42.24 42.38,44.43 37.63,44.43 36.73,45.32 30.99,45.32 30.7,45.03 30.56,45.03 30.56,45.03 30.5,45.03 v4(30.34,44.86)
  BOTTOM w0.091: UC1.AL5 161.56,38.39 v5(161.23,38.39)
CPU_DP1_N0_C: length 2.5
  TOP w0.091: v6(29.71,62.34) 29.71,62.34 29.51,62.14 29.51,61.91 CT11.1
  BOTTOM w0.091: UT1.B5 29.6,60.93 29.63,60.93 29.8,61.1 29.8,61.41 29.8,61.41 29.8,61.55 29.63,61.72 29.63,61.84 29.53,61.94 29.53,62.16 v6(29.71,62.34)
CPU_DP1_N1: length 187.8
  IN1 w0.079: v4(30.9,44.68) 31.07,44.51 31.19,44.51 31.33,44.65 31.33,46.27 30.98,46.62 30.98,50.39 30.99,50.41 30.99,55.09 31.31,55.4 31.31,59.03 31.26,59.23 30.53,60.75 30.53,60.98 v2(30.36,61.16)
  IN3 w0.079: v5(162.1,38.39) 162.02,38.32 161.83,38.32 161.68,38.47 161.68,38.62 161.75,38.69 162.23,38.69 162.37,38.55 162.37,38.24 161.94,37.81 161.39,37.6 161.34,37.57 161.32,37.56 161.27,37.52 161.26,37.5 159.03,35.27 158.28,34.19 157.81,33.21 157.81,25.23 157.71,25.13 157.71,20.57 157.54,20.4 157.54,20.4 157.26,20.11 157.26,17.97 156.82,17.18 156.47,17.01 155.88,17.01 155.5,16.63 155.5,15.69 155.15,15.33 155.15,14.4 154.03,13.97 154.02,13.97 153.69,13.83 153.67,13.82 153.43,13.72 151.73,12.98 151.73,12.98 149.48,12.11 147.13,11.14 146.89,11.02 146.84,11.02 125.67,11.02 122.56,11.58 119.31,11.58 117.19,12.43 117.15,12.44 117.15,12.43 117.11,12.44 107.86,12.44 106.72,13.58 99.47,13.58 98.04,15.01 95.59,15.01 95.59,15.01 93.17,15.01 92.27,14.58 90.84,13.88 89.31,13.88 87.55,14.61 87.14,15.02 87.08,15.02 86.62,15.48 86.41,15.48 85.93,15.96 80.44,15.96 80.27,16 75.44,18 72.72,18 67.7,23.02 67.7,25.51 66.58,28.79 57.38,37.99 55.68,37.99 53.11,40.56 50.06,41.82 44.44,41.82 43.33,42.94 42.19,43.58 40.53,44.04 37.38,44.04 36.49,44.93 32.28,44.93 32.23,44.93 31.63,44.77 31.57,44.76 31.32,44.51 31.07,44.51 v4(30.9,44.68)
  BOTTOM w0.091: UC1.AJ5 v5(162.1,38.39)
CPU_DP1_N1_C: length 2.4
  TOP w0.091: v6(30.33,62.34) 30.52,62.15 30.52,61.91 CT13.1
  BOTTOM w0.091: UT1.A3 30.48,61.24 30.44,61.19 30.3,61.19 30.24,61.26 30.24,61.51 30.45,61.72 30.45,62.22 v6(30.33,62.34)
CPU_DP1_N2: length 188.1
  IN1 w0.079: v6(34.3,60.77) 34.01,60.48 33.87,60.48 33.44,60.04 33.36,59.68 33.18,59.55 31.86,55.15 31.76,54.75 31.76,53.09 31.83,53.03 31.83,53.02 32.14,52.71 32.14,44.39 32.03,44.14 32.03,44.14 31.92,43.88 31.91,43.84 31.82,43.75 31.73,43.75 v4(31.55,43.93)
  IN3 w0.079: v5(164.34,39.03) 164.34,38.97 164.21,38.84 163.89,38.84 163.83,38.79 163.83,38.78 162.21,37.16 161.54,36.87 159.7,35.03 158.4,32.84 158.4,25.84 158.77,24.95 158.77,22.68 158.57,22.06 158.57,20.96 158.78,20.75 158.78,18.55 158.51,18.28 158.51,18.28 157.79,17.56 157.79,17.55 157.76,17.53 157.76,16.77 157.76,16.77 157.76,14.97 157.22,14.44 155.88,13.99 155.42,13.81 155.4,13.8 155.39,13.8 155.36,13.79 155.32,13.77 152,12.46 151.94,12.44 151.55,12.28 151.5,12.27 149.7,11.57 147.37,10.61 147.24,10.54 147.13,10.44 128.5,10.44 127.51,10.27 118.9,10.27 116.13,9.96 115.36,9.96 115.36,9.95 110.61,9.95 101.76,10.48 97.84,11.96 93.56,11.96 88.22,12.66 83.89,14.47 83.25,15.11 82.54,15.33 80.55,15.33 77.85,15.96 77.84,15.97 74.3,16.8 73.69,16.8 72.55,17.28 67.08,22.75 67.08,25.2 65.32,29.22 57.61,36.93 56.29,37.3 55.84,37.3 55.46,37.38 54.46,38.38 50.45,41.02 50,41.21 44.23,41.21 42.97,42.47 40.86,43.34 37.19,43.34 36.18,44.35 33.26,44.35 32.12,43.78 31.69,43.78 v4(31.55,43.93)
  BOTTOM w0.091: CT15.2 33.84,60.56 34.09,60.56 v6(34.3,60.77)

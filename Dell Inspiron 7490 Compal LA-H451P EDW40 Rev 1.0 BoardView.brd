# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_M0_DQS1: length 17.1
  IN3 w0.076: v5(178.29,54.57) 177.95,54.57 177.87,54.65 177.87,54.76 177.94,54.82 179.7,54.82 179.72,54.8 ; v5(188.43,57.67) 188.43,57.85 188.35,57.92 188.17,57.92 187.94,57.69 187.94,57.53 188.05,57.41 188.54,57.41 188.72,57.59 188.72,59.02 188.52,59.22 187.85,59.22 187.66,59.41 186.91,59.41 186.89,59.39
  IN3 w0.109: 179.72,54.8 180.18,54.8 185.05,59.67 186.19,59.67 186.47,59.39 186.89,59.39
DDR_M0_DQS2: length 21.5
  IN1 w0.109: v6(175.69,49.73) 175.5,49.73 175.43,49.65 175.43,49.47 175.54,49.36 175.84,49.36 175.85,49.37 177.76,49.37 177.97,49.57 180.8,49.57 180.92,49.69 181.24,49.69 181.5,49.43 181.64,49.43 181.86,49.65 181.86,49.79 181.61,50.04 181.61,50.35 181.94,50.69 182.25,50.69 182.5,50.44 182.64,50.44 182.86,50.66 182.86,50.8 182.65,51.02 182.65,51.33 185.02,53.7 185.63,53.7 185.79,53.86 185.79,54.44 186.06,54.72 188.52,54.72 188.97,54.27 188.97,53.62 188.57,53.22 188.57,53.08 188.81,52.83 v6(188.83,52.83)
  BOTTOM w0.127: v6(188.83,52.83) 188.81,52.83 188.53,53.12 UD42.L10 ; v6(175.69,49.73) 176.02,50.05 UC1.G24
DDR_M0_DQS3: length 15.8
  IN3 w0.076: v5(177.64,49.53) 177.77,49.53 177.86,49.44 177.86,49.27 178.01,49.12 179.47,49.12 179.49,49.1
  IN3 w0.109: v5(188.43,51.17) 188.43,51.06 188.5,50.98 188.68,50.98 188.91,50.75 188.91,48.15 188.27,47.51 185.6,47.51 184.9,48.22 180.92,48.22 180.04,49.1 179.49,49.1
DDR_M0_DQS4: length 15.4
  IN3 w0.076: 177.27,59.27 177.19,59.27 177.12,59.27 176.66,58.8 175.24,58.8 175.18,58.74 175.01,58.74 174.81,58.54 174.81,57.44 174.81,57.44 174.81,57.24 174.81,57.24 174.81,56.81 174.82,56.8 174.82,56.58 174.64,56.4 174.53,56.4 174.4,56.53 174.4,56.64 174.46,56.69 174.56,56.69 v5(174.57,56.7) ; 179.22,64.07 179.16,64.13 179.16,64.14 179.01,64.28 179.01,64.7 178.76,64.95 178.76,65.98 179.07,66.29 179.07,66.54 179.16,66.64 179.16,67.1 179.08,67.18 179.08,67.43 179.16,67.51 179.34,67.51 v5(179.41,67.44)
  IN3 w0.109: 177.27,59.27 177.34,59.27 177.62,59.55 177.62,59.68 179.31,61.38 179.31,63.97 179.22,64.07
DDR_M0_DQS5: length 15.2
  IN3 w0.076: v5(172.05,57.34) 172.05,57.23 172.13,57.16 172.24,57.16 172.29,57.21 172.29,57.22 172.31,57.23 172.31,57.45 172.29,57.46 172.29,57.5 172.24,57.55 172.24,57.8 172.28,57.83 172.28,59.14 172.51,59.37 172.51,59.38 172.57,59.44 ; v5(177.51,67.44) 177.48,67.41 177.48,67.13 177.44,67.09 177.33,67.09 177.25,67.17 177.25,67.69 177.02,67.92 176.19,67.92 176.18,67.93 176.04,67.93 175.94,67.83 175.94,67.81 175.73,67.6 175.73,67.02 175.62,66.91 175.62,65.92 175.61,65.91 175.61,65.83
  IN3 w0.109: 175.61,65.83 175.61,65.44 175.2,65.03 175.2,62.33 173.06,60.2 173.06,59.93 172.57,59.44
  BOTTOM w0.127: v5(177.51,67.44) 177.5,67.44 UD41.D10
DDR_M0_DQS6: length 25.2
  IN1 w0.109: v4(184.29,67.74) 184.29,67.74 184.57,67.74 184.67,67.64 184.67,67.5 184.56,67.39 184.08,67.39 184.07,67.39 183.87,67.59 183.87,67.81 184.14,68.08 184.65,68.08 185.22,67.51 185.75,67.51 186.02,67.78 186.26,67.78 186.68,67.36 186.68,64.87 177.87,56.06 176.75,56.06 175.96,55.27 175.96,53.81 175.84,53.69 v6(175.58,53.69)
  IN3 w0.109: v5(183.96,67.44) 184.25,67.74 v4(184.29,67.74)
  BOTTOM w0.127: UC1.H30 175.25,54.02 v6(175.58,53.69)
DDR_M0_DQS7: length 25.6
  IN1 w0.109: v6(172.84,53.69) 173.11,53.69 173.22,53.8 173.22,58.6 173.9,59.28 173.9,60.34 176.29,62.73 176.29,62.87 175.86,63.3 175.86,63.61 176.2,63.94 176.51,63.94 176.95,63.51 177.09,63.51 177.3,63.71 177.3,63.86 177.09,64.06 177.09,64.37 177.43,64.71 177.74,64.71 177.96,64.49 178.15,64.49 178.52,64.86 178.52,65.59 178.01,66.11 178.01,66.42 178.34,66.75 178.65,66.75 179.14,66.27 179.28,66.27 179.5,66.48 179.5,66.62 179.11,67.01 179.11,67.32 179.45,67.66 179.76,67.66 180.15,67.27 180.29,67.27 180.7,67.68 182.17,67.68 v6(182.32,67.83)
  BOTTOM w0.127: v6(172.84,53.69) 172.52,54.02 UC1.N30 ; v6(182.32,67.83) 182.01,67.51 UD41.L10
DDR_M0_DQS#0: length 14.4
  IN3 w0.076: v5(187.63,55.69) 187.65,55.72 187.96,55.72 188.03,55.79 188.03,55.89 187.96,55.95 187.36,55.95 187.3,55.89 187.06,55.89 187.05,55.88 187,55.88 186.98,55.87 186.97,55.87 ; 179.4,52.27 179.38,52.27 179.36,52.29 178.44,52.29 178.34,52.39 178.22,52.39 178.11,52.29 177.93,52.29 177.87,52.23 177.87,52.17 177.98,52.05 v5(178.29,52.05)
  IN3 w0.102: 179.4,52.27 179.56,52.27
  IN3 w0.109: 186.97,55.87 186.62,55.87 186.52,55.97 186.24,55.97 182.19,51.92 181.31,51.92 181.09,52.14 181.09,52.56 180.99,52.67 180.68,52.67 180.58,52.56 180.58,52.14 180.36,51.92 179.91,51.92 179.56,52.27
DDR_M0_DQS#1: length 17
  IN3 w0.076: v5(177.64,54.57) 177.72,54.65 177.72,54.82 177.88,54.98 179.7,54.98 179.72,55 ; 186.89,59.59 186.91,59.56 187.72,59.56 187.91,59.38 188.58,59.38 188.87,59.08 188.87,57.52 188.61,57.26 187.99,57.26 187.78,57.46 187.78,57.61 187.72,57.67 v5(187.63,57.67)
  IN3 w0.109: 179.72,55 180.09,55 184.96,59.87 186.27,59.87 186.55,59.59 186.89,59.59
DDR_M0_DQS#2: length 21.5
  IN1 w0.109: v6(188.03,52.83) 188.05,52.83 188.36,53.15 188.36,53.3 188.76,53.7 188.76,54.19 188.44,54.51 186.15,54.51 185.99,54.36 185.99,53.78 185.72,53.5 185.11,53.5 182.85,51.25 182.85,51.1 183.06,50.89 183.06,50.58 182.73,50.24 182.41,50.24 182.17,50.48 182.03,50.48 181.81,50.27 181.81,50.12 182.06,49.88 182.06,49.56 181.72,49.23 181.41,49.23 181.15,49.49 181.01,49.49 180.89,49.37 178.05,49.37 177.85,49.16 175.94,49.16 175.93,49.15 175.45,49.15 175.22,49.38 175.22,49.67 175.16,49.73 v6(175.04,49.73)
  BOTTOM w0.127: UC1.H24 175.37,50.05 v6(175.04,49.73) ; UD42.L11 187.75,53.12 v6(188.03,52.83)
DDR_M0_DQS#3: length 15.8
  IN3 w0.076: 179.49,49.3 179.47,49.28 178.07,49.28 178.02,49.33 178.02,49.48 178.07,49.53 v5(178.29,49.53)
  IN3 w0.109: v5(187.63,51.17) 187.72,51.07 188.13,51.07 188.41,50.78 188.6,50.78 188.71,50.67 188.71,48.24 188.19,47.72 185.69,47.72 184.98,48.42 181,48.42 180.12,49.3 179.49,49.3
DDR_M0_DQS#4: length 15.5
  IN3 w0.076: v5(179.41,66.64) 179.24,66.47 179.24,66.22 178.93,65.91 178.93,65.02 179.18,64.77 179.18,64.36 179.28,64.26 179.29,64.26 179.33,64.22 179.35,64.22 179.36,64.21 ; v5(174.57,57.34) 174.4,56.92 174.33,56.86 174.33,56.84 174.27,56.78 174.27,56.74 174.23,56.71 174.23,56.46 174.46,56.23 174.71,56.23 174.99,56.51 174.99,56.87 174.98,56.88 174.98,57.17 174.98,57.17 174.98,57.51 174.98,57.51 174.98,58.47 175.08,58.57 175.25,58.57 175.31,58.63 176.73,58.63 177.17,59.08 177.24,59.08 177.26,59.06 177.27,59.06
  IN3 w0.109: 177.27,59.06 177.42,59.06 177.82,59.46 177.82,59.6 179.52,61.29 179.52,64.06 179.36,64.21
DDR_M0_DQS#5: length 15.2
  IN3 w0.076: 175.81,65.83 175.81,65.84 175.8,65.86 175.8,65.91 175.79,65.92 175.79,66.84 175.9,66.95 175.9,67.53 176.11,67.74 176.11,67.76 176.12,67.75 176.92,67.75 177.05,67.63 177.07,67.63 177.08,67.62 177.08,67.1 177.25,66.92 177.37,66.92 177.46,66.83 v5(177.46,66.64) ; v5(172.05,56.69) 172.05,56.85 172.19,56.99 172.31,56.99 172.46,57.14 172.46,57.15 172.48,57.16 172.48,57.52 172.46,57.53 172.46,57.57 172.41,57.62 172.41,57.73 172.45,57.76 172.45,59.06 172.64,59.26 172.65,59.26 172.69,59.29 172.71,59.29 172.72,59.3
  IN3 w0.109: 175.81,65.83 175.81,65.36 175.4,64.94 175.4,62.25 173.27,60.12 173.27,59.85 172.72,59.3
DDR_M0_DQS#6: length 25.3
  IN1 w0.109: v6(176.49,53.69) 176.42,53.69 176.16,53.95 176.16,55.18 176.83,55.85 177.95,55.85 186.89,64.79 186.89,67.45 186.35,67.98 185.93,67.98 185.66,67.72 185.3,67.72 184.74,68.29 184.06,68.29 183.67,67.9 183.67,67.51 183.99,67.18 184.09,67.18 184.1,67.19 184.2,67.19 184.35,67.05 v4(184.35,67.03)
  IN3 w0.109: v4(184.35,67.03) v5(183.96,66.64)
  BOTTOM w0.127: v6(176.49,53.69) 176.16,54.02 UC1.G30
DDR_M0_DQS#7: length 25.5
  IN1 w0.109: v6(173.76,53.69) 173.54,53.69 173.42,53.81 173.42,58.51 174.1,59.2 174.1,60.26 176.49,62.64 176.49,62.96 176.07,63.38 176.07,63.52 176.28,63.74 176.43,63.74 176.86,63.3 177.18,63.3 177.5,63.63 177.5,63.94 177.29,64.15 177.29,64.29 177.51,64.51 177.65,64.51 177.88,64.28 178.23,64.28 178.72,64.77 178.72,65.67 178.21,66.19 178.21,66.33 178.43,66.55 178.57,66.55 179.06,66.06 179.37,66.06 179.7,66.4 179.7,66.71 179.32,67.09 179.32,67.24 179.53,67.45 179.68,67.45 180.06,67.07 180.38,67.07 180.78,67.48 182.18,67.48 182.33,67.33 v6(182.33,67.04)
  BOTTOM w0.127: UD41.L11 182.01,66.71 v6(182.33,67.04) ; v6(173.76,53.69) 173.43,54.02 UC1.L30
DDR_M0_ODT0: length 72.5
  IN1 w0.094: v6(181.05,69.45) 180.88,69.45 180.24,70.09 180.24,70.85 180.79,71.4 181.1,71.4 182.04,70.46 187.44,70.46 188.82,69.08 188.82,63.42 188.18,62.78 v6(187.9,62.78)
  IN3 w0.094: v6(190.42,54.05) 190.51,54.05 190.89,53.67 190.89,50.78 191.01,50.66 191.25,50.66 191.38,50.79 191.38,51.71 191.38,51.71 191.38,51.92 191.38,51.92 191.38,52.36 191.38,52.36 191.38,52.57 191.38,52.57 191.38,53.01 191.38,53.01 191.38,53.22 191.38,53.22 191.38,54.16 190.79,54.75 190.79,59.76 190.68,59.87 190.68,60.55 190.4,60.83 190.4,62.34 190.17,62.57 189.73,62.57 189.18,63.12 188.23,63.12 v6(187.9,62.78) 187.6,63.08 184.56,63.08 179.64,58.16 179.64,57.67 178.98,57.01 178.14,57.01 178.13,57.01 178.07,57.01 176.63,55.57 176.11,55.57 176,55.46 175.03,55.46 174.62,55.05 174.62,52.01 174.35,51.74 170.48,51.74 169.47,50.73 166.8,50.73 166.52,51.01 166.52,51.44 165.61,52.35 165.61,53.57 165.46,53.72 165.46,53.91 165.15,54.22 v5(165.15,54.67)
  BOTTOM w0.127: v6(190.42,54.05) 190.06,54.42 UD42.J8 ; v6(181.05,69.45) 180.71,69.1 UD41.J8 ; RD73.1 187.39,62.27 v6(187.9,62.78)
DDR_M1_CAA_0: length 52.1
  IN1 w0.094: v6(163.72,73.47) 163.72,73.73 163.84,73.85 164.52,73.85 164.72,74.05 164.94,74.05 165.4,73.6 165.4,73.39 165.62,73.17 166.03,73.17 166.25,73.39 167.16,73.39 167.71,73.94 167.71,74.34 167.84,74.48 168.23,74.48 168.45,74.26 168.45,74.13 167.59,73.27 167.59,73.14 167.71,73.01 167.84,73.01 168.7,73.88 168.83,73.88 168.95,73.75 168.95,73.63 168.09,72.77 168.09,72.64 168.22,72.51 168.34,72.51 169.21,73.38 169.33,73.38 169.46,73.25 169.46,73.12 168.61,72.28 168.61,72.15 168.74,72.03 168.86,72.03 169.71,72.87 169.83,72.87 169.96,72.75 169.96,72.62 169.19,71.86 169.19,71.73 169.32,71.6 169.45,71.6 170.21,72.37 170.34,72.37 170.46,72.24 170.46,72.12 169.96,71.62 169.96,71.49 170.09,71.36 170.21,71.36 170.71,71.87 170.9,71.87 171.01,71.75 171.01,71.52 170.8,71.32 170.8,70.7 170.72,70.61 170.38,70.61 170.23,70.46 170.23,70.23 170.32,70.14 170.76,70.14 170.89,70.01 170.89,69.8 170.79,69.7 169.96,69.7 169.86,69.6 169.86,69.38 169.99,69.25 170.76,69.25 170.89,69.12 170.89,64.71 165.56,59.38 165.29,59.38 v4(165.26,59.41)
  IN3 w0.094: v4(165.26,59.41) 165.26,59.75 164.92,60.09 164.81,60.09 164.28,59.56 164.28,59.38 164.36,59.31 164.57,59.31 164.65,59.23 164.65,59.05 164.55,58.95 164.35,58.95 164.28,58.88 164.28,58.76 164.24,58.72 164.24,57.87 164.28,57.82 164.28,57.48 164.27,57.46 164.27,57.45 164.24,57.42 164.24,57.22 164.27,57.19 164.27,57.09 164.36,57 164.47,57 164.57,57.1 164.57,57.26 v5(164.5,57.32)
  BOTTOM w0.076: v6(163.72,73.47) 163.6,73.35 163.28,73.35 163.2,73.28 162.93,73.28 162.82,73.38 162.82,73.49 162.9,73.57 162.95,73.57 163.03,73.65 163.03,74.82 163.13,74.92 163.28,74.92 163.36,74.84 163.36,73.87 UD44.R2
  BOTTOM w0.127: UD44.R2 163.52,73.84 163.65,73.97 163.65,74.41 163.65,74.99 163.65,76.03 164.18,76.56 RD83.1
DDR_M1_CAA_1: length 47.2
  IN1 w0.094: v6(167.35,53.06) 167.52,52.9 167.52,52.68 167.39,52.55 167.26,52.55 167.1,52.4 166.84,52.4 166.71,52.53 166.16,52.53 165.99,52.7 165.99,53.44 165.57,53.86 165.57,57.78 173,65.21 173,73.97 171.28,75.69 162.15,75.69 162.06,75.6 162.06,75.43 162.57,74.92 162.81,74.92 162.89,75 v4(163.14,75)
  IN3 w0.094: v4(163.14,75) 163.14,75.18 163.06,75.27 162.48,75.27 162.33,75.11 162.33,74.75 162.42,74.65 162.97,74.65 163.17,74.45 163.17,73.95 162.98,73.76 162.83,73.76 v5(162.74,73.84)
  BOTTOM w0.127: v5(162.74,73.84) 162.74,75.58 163.62,76.46 RD85.1 ; v6(167.35,53.06) 167.05,53.37 UC1.AB29
DDR_M1_CAA_2: length 52.8
  IN1 w0.094: v4(162.42,74.24) 162.21,74.24 162.15,74.3 161.91,74.3 161.83,74.22 161.83,74.04 162.05,73.81 162.5,73.81 162.92,74.24 163.42,74.24 164.3,75.12 165.46,75.12 165.55,75.03 165.55,74.25 165.64,74.16 165.91,74.16 166,74.25 166,75.03 166.09,75.12 166.35,75.12 166.44,75.03 166.44,74.09 166.53,74 166.8,74 166.89,74.09 166.89,75.03 166.97,75.12 169.84,75.12 169.93,75.03 169.93,74.42 170.02,74.33 170.29,74.33 170.37,74.42 170.37,75.03 170.46,75.12 170.99,75.12 172.34,73.77 172.34,73.63 172.27,73.56 171.85,73.56 171.76,73.47 171.76,73.2 171.85,73.12 172.27,73.12 172.36,73.03 172.36,72.76 172.27,72.67 171.85,72.67 171.76,72.58 171.76,72.32 171.85,72.23 172.27,72.23 172.36,72.14 172.36,71.87 172.27,71.78 171.85,71.78 171.76,71.69 171.76,71.43 171.85,71.34 172.27,71.34 172.36,71.25 172.36,70.86 172.27,70.77 171.55,70.77 171.46,70.68 171.46,70.42 171.55,70.33 172.27,70.33 172.36,70.24 172.36,69.97 172.27,69.88 171.55,69.88 171.46,69.79 171.46,69.53 171.55,69.44 172.27,69.44 172.36,69.35 172.36,69.08 172.27,68.99 171.55,68.99 171.46,68.9 171.46,68.64 171.55,68.55 172.27,68.55 172.36,68.46 172.36,68.19 172.27,68.1 171.55,68.1 171.46,68.01 171.46,67.75 171.55,67.66 172.27,67.66 172.36,67.57 172.36,67.3 172.27,67.21 171.55,67.21 171.46,67.13 171.46,66.86 171.55,66.77 172.22,66.77 172.35,66.64 172.35,65.84 171.83,65.32 171.83,64.84 165.7,58.71 165.63,58.71 v4(165.23,58.31)
  IN3 w0.094: v5(164.84,58.43) 164.95,58.31 v4(165.23,58.31) ; v5(162.09,73.84) 161.84,73.84 161.67,74.01 161.67,74.49 161.79,74.61 162.05,74.61 v4(162.42,74.24)
  BOTTOM w0.127: UC1.AE37 165.04,58.43 v5(164.84,58.43) ; v5(162.09,73.84) 162.09,75.86 162.5,76.27 RD71.1
DDR_M1_CAA_3: length 51.6
  IN1 w0.094: v4(162.42,73.44) 162.6,73.44 162.69,73.53 162.69,73.61 162.7,73.61 163.04,73.95 163.54,73.95 164.37,74.79 165.1,74.79 165.26,74.63 165.26,74.14 165.71,73.69 166.97,73.69 167.33,74.04 167.33,74.7 167.42,74.79 169.12,74.79 169.29,74.63 169.29,74.5 169.02,74.23 169.02,74.11 169.21,73.92 169.33,73.92 169.6,74.19 169.73,74.19 169.91,74 169.91,73.87 169.65,73.61 169.65,73.48 169.84,73.29 169.96,73.29 171.12,74.45 171.24,74.45 171.43,74.26 171.43,74.13 170.28,72.98 170.28,72.85 170.47,72.66 170.59,72.66 171.18,73.25 171.32,73.25 171.41,73.16 171.41,71.13 171.18,70.9 171.18,66.3 171.27,66.21 171.84,66.21 171.93,66.12 171.93,65.86 171.84,65.77 171.27,65.77 171.18,65.68 171.18,65.41 171.27,65.32 171.43,65.32 171.52,65.24 171.52,64.93 165.64,59.05 165.4,59.05 v4(165.22,58.87)
  IN3 w0.094: v5(165.1,57.66) 165.09,57.65 165.09,55.62 164.89,55.42 164.89,55.02 164.65,54.78 164.65,54.3 164.53,54.18 164.16,54.18 164.05,54.29 164.05,54.68 164.51,55.14 164.51,55.43 164.04,55.9 164.04,56.17 164.27,56.4 164.64,56.4 164.76,56.52 164.76,58.09 164.52,58.32 164.52,58.52 164.87,58.87 v4(165.22,58.87) ; v5(162.09,73.04) 161.98,72.93 161.89,72.93 161.81,73.01 161.81,73.13 162.12,73.44 v4(162.42,73.44)
  BOTTOM w0.127: v5(162.09,73.04) 162.43,73.38 162.43,75.66 163.06,76.29 RD74.1
DDR_M1_CAA_4: length 52.7
  IN1 w0.094: v6(166.47,53.05) 166.67,52.84 166.86,52.84 166.93,52.92 166.93,53.24 166.84,53.34 166.7,53.34 166.55,53.49 166.24,53.49 165.76,53.97 165.76,57.57 173.29,65.09 173.29,74.16 171.43,76.03 158.84,76.03 158.47,75.65 158.47,75.38 158.61,75.24 161.83,75.24 161.94,75.13 v4(161.94,75)
  IN3 w0.094: v4(161.94,75) 161.94,75.22 161.85,75.31 161.51,75.31 161.25,75.05 161.25,74.68 161.46,74.47 161.46,73.75 v5(161.73,73.47)
  BOTTOM w0.127: RD30.1 161.95,76.22 161.77,76.04 161.77,73.5 v5(161.73,73.47) 161.73,73.33 UD44.M3 ; UC1.AC29 166.15,53.37 v6(166.47,53.05)
DDR_M1_CAA_5: length 50.4
  IN1 w0.094: v4(157.28,72.66) 157.44,72.82 157.48,72.82 157.98,73.32 157.98,73.8 158.27,74.09 158.27,74.55 158.38,74.66 159.4,74.66 159.71,74.34 159.99,74.34 160.3,74.66 161.3,74.66 161.49,74.47 161.49,73.95 161.87,73.56 161.87,73.27 162.13,73.02 165.27,73.02 165.4,72.88 166.18,72.88 166.37,73.08 167.11,73.08 168.89,71.29 169.63,71.29 169.94,70.98 169.94,70.17 169.31,69.54 169.31,69.16 169.51,68.96 170.24,68.96 170.59,68.61 170.59,64.82 170.14,64.37 169.11,64.37 168.87,64.13 168.87,63.09 165.66,59.88 165.27,59.88 164.84,59.46 164.84,57.19 165.16,56.87 165.16,53.71 165.6,53.28 165.6,52.17 166.07,51.69 167.36,51.69 167.54,51.87 169.35,51.87 169.56,52.08 169.56,52.54 169.29,52.81 v4(169.25,52.81)
  IN3 w0.094: v4(157.28,72.66) 157.55,72.93 157.55,72.99 v5(157.59,73.03) ; v4(169.25,52.81) 169.25,52.92 v5(168.8,53.37)
  BOTTOM w0.127: RD32.1 157.58,76.56 157.21,76.18 157.21,73.37 UD44.F3
DDR_M1_CAA_6: length 52.4
  IN1 w0.094: v4(167.4,52.2) 167.74,52.54 167.74,54.22 167.26,54.7 166.84,54.7 165.93,55.61 165.93,57.34 173.57,64.98 173.57,74.37 171.63,76.31 158.73,76.31 156.67,74.25 156.67,73.96 v4(157.16,73.46)
  IN3 w0.094: v5(156.89,73.04) 157.23,73.04 157.57,73.38 157.57,73.65 157.47,73.75 157.26,73.75 157.16,73.66 v4(157.16,73.46) ; v5(166.98,52.72) 167.4,52.3 v4(167.4,52.2)
  BOTTOM w0.127: RD34.1 156.46,76.12 156.57,76.02 156.57,73.36 v5(156.89,73.04)
DDR_M1_CAA_7: length 51.6
  IN1 w0.094: v4(156.57,73.44) 155.7,73.44 155.59,73.33 155.59,73.12 155.68,73.03 156.13,73.03 156.27,72.88 156.64,72.88 156.83,73.07 157.3,73.07 157.55,73.32 157.55,73.65 157.2,74.01 157.2,74.16 157.98,74.95 161.44,74.95 161.77,74.62 163.31,74.62 164.1,75.41 171.11,75.41 172.72,73.8 172.72,65.33 165.81,58.42 165.81,58.27 165.4,57.86 165.4,53.76 165.79,53.37 165.79,52.22 166.14,51.87 166.43,51.87 166.53,51.98 v4(166.53,52.18)
  IN3 w0.094: v4(166.53,52.18) 166.53,52.25 v5(166.06,52.72) ; v4(156.57,73.44) 156.57,73.51 v5(156.89,73.84)
  BOTTOM w0.127: v5(156.89,73.84) 156.89,76.6 RD36.1
DDR_M1_CAA_8: length 51.6
  IN1 w0.094: v4(155.91,74.18) 155.91,74.39 158.39,76.88 171.97,76.88 174.14,74.71 174.14,64.74 166.31,56.91 166.31,55.99 166.97,55.33 167.16,55.33 168.7,53.78 168.7,52.78 v4(169.23,52.25)
  IN3 w0.094: v5(156.24,73.84) v4(155.91,74.18) ; v5(168.8,52.72) 168.8,52.69 v4(169.23,52.25)
  BOTTOM w0.127: RD38.1 155.91,76.18 156.04,76.04 156.04,74.04 v5(156.24,73.84)
DDR_M1_CAA_9: length 51.8
  IN1 w0.094: v6(168.33,52.32) 167.97,52.68 167.97,54.23 167.08,55.12 166.77,55.12 166.13,55.76 166.13,57.13 173.86,64.86 173.86,74.49 171.75,76.59 158.53,76.59 156.37,74.43 156.37,73.89 156.21,73.73 155.78,73.73 v4(155.27,74.24)
  IN3 w0.094: v4(155.27,74.24) 155.59,73.91 v5(155.59,73.84)
  BOTTOM w0.127: RD40.1 155.35,75.97 155.59,75.73 v5(155.59,73.84) ; v6(168.33,52.32) 167.93,52.72 UC1.Y28
DDR_M1_CAB_0: length 52.5
  IN3 w0.094: v5(161.98,57.34) 162.16,57.51 162.16,58.68 162.4,58.92 162.4,61.88 164.34,63.82 164.34,64.07 166.17,65.91 166.17,71.45 165.37,72.25 165.37,73.73 165.26,73.84 164.81,73.84 164.7,73.95 164.7,74.39 164.17,74.92 164.05,74.92 163.83,74.7 163.71,74.7 163.58,74.83 163.58,74.95 163.77,75.14 163.77,75.26 163.37,75.66 153.03,75.66 152.88,75.51 152.88,75.13 152.78,75.03 152.54,75.03 152.43,75.13 152.43,75.51 152.35,75.6 152.08,75.6 151.99,75.51 151.99,75.13 151.9,75.04 151.63,75.04 151.55,75.13 151.55,75.51 151.46,75.6 150.06,75.6 149.62,75.15 149.62,75.03 149.72,74.93 149.72,74.81 149.53,74.62 149.41,74.62 149.19,74.83 149.07,74.83 148.74,74.51 148.74,74.19 148.56,74.01 148.56,73.41 148.45,73.3 148.26,73.3 148.17,73.38 148.17,74.07 148.36,74.26 v5(148.36,74.28)
  BOTTOM w0.076: v5(148.36,74.28) 148.46,74.18 148.63,74.18 148.68,74.23 148.96,74.23 149.16,74.44 149.16,75.05 149.26,75.15 149.72,75.15 149.82,75.05 149.82,73.65 149.67,73.5 149.07,73.5 149.04,73.46 148.83,73.46 148.5,73.13 148.5,72.77 148.39,72.66 148.02,72.66 147.84,72.84 147.84,73.19 148.17,73.52 UD43.R2
  BOTTOM w0.127: v5(148.36,74.28) 148.27,74.37 148.27,74.65 148.73,75.12 148.73,75.38 148.94,75.59 RD42.1
DDR_M1_CAB_1: length 52.1
  IN3 w0.094: v5(147.52,73.84) 147.79,73.84 147.86,73.76 147.86,73.6 147.78,73.52 146.54,73.52 146.4,73.65 146.4,73.88 146.71,74.18 146.71,74.42 146.8,74.51 147.38,74.51 147.67,74.22 147.87,74.22 148.01,74.37 148.01,74.49 147.84,74.66 147.84,74.78 148.03,74.97 148.16,74.97 148.39,74.74 148.52,74.74 148.71,74.92 148.71,75.05 148.16,75.6 148.16,75.73 148.35,75.92 148.47,75.92 149.16,75.23 149.29,75.23 149.49,75.43 149.49,75.65 149.8,75.97 163.47,75.97 165.77,73.66 165.77,73.54 165.67,73.43 165.67,73.31 165.86,73.12 165.98,73.12 166.09,73.22 166.22,73.22 166.46,72.99 166.46,72.76 166.37,72.68 165.75,72.68 165.66,72.59 165.66,72.37 165.81,72.23 166.37,72.23 166.46,72.14 166.46,65.94 166.46,65.94 166.46,65.79 164.62,63.95 164.62,63.7 162.6,61.68 162.6,58.74 162.35,58.49 162.35,56.56 162.08,56.29 161.79,56.29 161.59,56.49 161.59,56.65 161.74,56.8 161.88,56.8 v5(161.98,56.69)
  BOTTOM w0.127: v5(147.52,73.84) 147.52,74.27 147.52,74.53 147.52,74.69 147.97,75.14 147.97,76.19 147.82,76.34 RD44.1
DDR_M1_CAB_2: length 50.3
  IN3 w0.094: v5(147.16,75.41) 147.16,75.41 146.91,75.41 146.82,75.5 146.82,75.65 148,76.82 163.87,76.82 167.35,73.34 167.35,65.47 165.47,63.6 165.47,63.34 163.43,61.3 163.43,60.5 163.3,60.38 163.3,57.94 163.22,57.86 163.22,57.6 162.98,57.36 162.98,57.1 163.52,56.56 163.52,55.87 163.36,55.7 163.36,55.48 163.27,55.39 162.63,55.39 162.53,55.49 162.53,55.93 162.71,56.11 163.06,56.11 163.16,56.21 163.16,56.49 163,56.65 162.71,56.65 162.63,56.72 v5(162.63,57.01)
  BOTTOM w0.127: RD46.1 146.71,76.41 147.16,75.96 v5(147.16,75.41) 147.16,75.41 146.96,75.61 146.6,75.61 146.46,75.47 146.46,75.13 146.87,74.72 UD43.N2
DDR_M1_CAB_3: length 53.1
  IN3 w0.094: v5(146.87,73.04) 146.87,73.04 146.28,73.04 146.22,73.1 146.22,73.26 146.28,73.32 147.73,73.32 147.95,73.11 148.84,73.11 149.67,73.94 149.67,74.29 150.07,74.69 150.07,74.86 150.37,75.17 151,75.17 151.44,74.72 152.94,74.72 153.54,75.32 153.81,75.32 153.89,75.23 153.89,74.91 153.98,74.82 154.25,74.82 154.34,74.91 154.34,75.23 154.45,75.34 157.94,75.34 158.61,74.67 158.88,74.67 158.97,74.76 158.97,75.21 159.06,75.3 159.32,75.3 159.41,75.21 159.41,74.76 159.5,74.67 159.79,74.67 159.9,74.78 159.9,75.17 159.99,75.26 160.56,75.26 160.65,75.17 160.65,74.93 159.99,74.27 159.99,74.17 159.9,74.08 159.9,73.71 160.03,73.58 160.31,73.58 160.59,73.86 161.06,73.86 161.25,73.67 161.25,73.24 161.84,72.65 161.84,72.13 161.99,71.99 161.99,71.98 162.25,71.98 162.45,72.18 163,72.18 163.19,71.98 165.18,71.98 165.89,71.27 165.89,66 164.05,64.17 164.05,63.93 162.16,62.04 162.16,61.06 161.96,60.86 161.96,57.7 161.72,57.45 161.72,57.03 161.36,56.67 161.36,56.45 161.57,56.23 161.57,55.75 161.73,55.59 162.05,55.59 162.31,55.85 162.31,56.27 162.4,56.36 v5(162.63,56.36)
  BOTTOM w0.127: v5(146.87,73.04) 147.01,73.04 147.39,73.42 147.72,73.42 147.85,73.55 147.85,74.72 148.38,75.25 RD48.1
DDR_M1_CAB_4: length 51.2
  IN3 w0.094: v5(147.19,74.81) 147.47,74.81 147.56,74.9 147.56,74.9 147.75,75.09 147.75,75.75 148.19,76.19 148.21,76.19 148.27,76.25 163.63,76.25 166.78,73.11 166.78,65.71 164.9,63.84 164.9,63.58 162.83,61.5 162.83,58.65 162.9,58.58 162.9,58.07 162.76,57.93 162.63,57.93 162.54,58.02 162.54,58.22 v5(162.63,58.31)
  BOTTOM w0.076: UD43.M3 146.09,72.91 146.09,72.62 146.17,72.55 146.43,72.55 146.55,72.43 146.55,72.15 146.36,71.96 146.36,71.72 146.55,71.53 146.55,70.44 146.75,70.25 147.11,70.25 147.19,70.32 147.19,70.43 147.16,70.46 147.16,71.55 147.33,71.72 147.33,71.95 147.16,72.12 147.16,72.36 147.31,72.51 147.31,72.65 147.22,72.74 146.72,72.74 146.53,72.93 146.53,73.17
  BOTTOM w0.127: 147.19,74.81 147.19,73.62 147.06,73.5 146.68,73.5 146.53,73.34 146.53,73.17 ; v5(147.19,74.81) 147.19,74.88 147.48,75.17 147.48,76.2 147.26,76.41 RD50.1
  BOTTOM w0.135: 147.19,74.81 v5(147.19,74.81)
DDR_M1_CAB_5: length 52.3
  IN3 w0.094: v5(164.5,56.69) 164.38,56.69 164.1,56.97 164.1,57.12 164.07,57.15 164.07,57.49 164.1,57.52 164.1,57.61 164.1,57.61 164.1,57.76 164.06,57.81 164.06,59.66 164.61,60.22 164.61,60.87 166.61,62.87 166.61,63.13 168.48,65 168.48,73.87 164.4,77.96 147.52,77.96 145.6,76.04 142.07,76.04 v5(141.95,76.16)
  BOTTOM w0.127: RD52.1 142.24,76.45 v5(141.95,76.16) 141.99,76.12 141.99,73.37 UD43.F3
DDR_M1_CAB_6: length 53
  IN3 w0.094: v5(162.63,57.66) 162.73,57.57 162.86,57.57 163.03,57.74 163.03,57.91 163.13,58.01 163.13,58.58 163.03,58.69 163.03,61.3 165.19,63.46 165.19,63.72 167.06,65.59 167.06,73.23 163.75,76.53 148.16,76.53 148.1,76.47 148.07,76.47 147.47,75.87 147.47,75.87 147.46,75.86 147.46,75.27 147.31,75.11 147.07,75.11 147.07,75.11 147.04,75.11 146.41,75.11 146.11,74.81 142.45,74.81 142,74.37 142,74.01 142.21,73.81 142.82,73.81 142.91,73.72 142.91,73.52 142.75,73.36 142.21,73.36 142.12,73.27 142.12,72.82 142,72.7 141.8,72.7 141.67,72.83 v5(141.67,73.04)
  BOTTOM w0.127: v5(141.67,73.04) 141.35,73.36 141.35,75.24 141.12,75.47 RD54.1
DDR_M1_CAB_7: length 52.2
  IN3 w0.094: v5(141.67,73.84) 141.68,73.83 141.68,73.66 141.6,73.57 141.46,73.57 141.35,73.68 141.35,74.29 142.24,75.18 145.96,75.18 147.88,77.1 163.99,77.1 167.46,73.63 167.63,73.46 167.63,65.35 165.76,63.48 165.76,63.23 163.72,61.19 163.72,60.43 163.47,60.18 163.47,57.87 163.39,57.79 163.39,57.45 163.49,57.35 163.49,57.02 163.6,56.91 163.6,56.91 163.75,56.76 163.75,56.76 163.85,56.66 v5(163.85,56.36)
  BOTTOM w0.127: v5(141.67,73.84) 141.67,75.58 141.52,75.73 141.52,76.51 RD56.1
DDR_M1_CAB_8: length 52.7
  IN3 w0.094: v5(163.85,57.01) 163.85,57.12 163.66,57.31 163.66,57.42 163.56,57.52 163.56,57.72 163.65,57.81 163.65,59.91 164.02,60.27 164.02,61.08 166.04,63.11 166.04,63.36 167.91,65.24 167.91,73.64 164.16,77.39 147.76,77.39 145.84,75.47 142.13,75.47 140.68,74.02 140.68,73.66 140.79,73.55 140.91,73.55 141.02,73.66 v5(141.02,73.84)
  BOTTOM w0.127: RD58.1 140.56,75.37 141.02,74.9 141.02,73.84 v5(141.02,73.84)
DDR_M1_CAB_9: length 52.1
  IN3 w0.094: v5(140.37,73.84) 140.37,74.11 140.39,74.13 140.39,74.14 141.74,75.49 142.01,75.75 145.72,75.75 147.64,77.67 164.28,77.67 168.2,73.75 168.2,65.12 166.33,63.25 166.33,62.99 164.34,61 164.31,61 164.31,60.21 163.85,59.75 v5(163.85,57.62)
  BOTTOM w0.127: v5(140.37,73.84) 140.37,73.84 140.37,74.97 140,75.34 RD60.1
DDR_M1_CKE0: length 59.8
  IN1 w0.094: v6(159.87,72.64) 160.17,72.33 160.8,72.33 160.88,72.25 161.37,72.25 162.11,71.52 165.07,71.52 165.62,70.96 165.62,70.7 167.79,68.53 167.79,63.52 164.22,59.94 164.22,56.11 164.46,55.86 164.46,54.96 163.79,54.29 163.79,53.7 163.99,53.5 165.09,53.5 165.37,53.23 165.37,52.1 164.69,51.43 164.69,49.81 164.79,49.71 165.11,49.71 165.22,49.82 165.22,51.53 165.31,51.62 165.58,51.62 165.67,51.53 165.67,49.05 165.75,48.96 166.01,48.96 166.11,49.05 166.11,51.39 166.2,51.48 166.47,51.48 166.55,51.39 166.55,50.49 166.64,50.41 167.12,50.41 167.2,50.32 167.2,50.05 167.12,49.96 166.64,49.96 166.55,49.87 166.55,49.64 166.68,49.52 166.97,49.52 167.06,49.43 167.06,49.04 167.14,48.95 167.4,48.95 167.53,49.08 167.53,49.62 167.62,49.71 167.92,49.71 168.05,49.83 168.05,50.43 167.79,50.68 167.18,50.68 166.94,50.93 v4(166.94,51.15)
  IN3 w0.094: v4(166.94,51.15) 166.94,51.66 167.12,51.84 169.9,51.84 170.28,52.22 170.87,52.22 171.01,52.36 171.01,52.92 170.83,53.1 170.34,53.1 170.22,52.98 170.22,52.85 170.35,52.72 v5(170.62,52.72)
  BOTTOM w0.127: RD66.1 160.27,76.48 160.11,76.32 160.11,75.05 159.82,74.76 159.82,73.36 UD44.K3 160.14,72.83 159.95,72.64 v6(159.87,72.64)
DDR_M1_CKE1: length 61.3
  IN1 w0.094: v4(167.57,51.07) 167.57,51.56 167.66,51.65 168.24,51.65 168.33,51.56 168.33,50.23 168.42,50.14 168.69,50.14 168.78,50.23 168.78,51.45 168.87,51.54 169.27,51.54 169.39,51.42 169.39,50.05 169.25,49.92 168.98,49.92 168.5,49.44 168.5,48.94 168.22,48.66 167.16,48.66 166.97,48.47 166.24,48.47 166.13,48.58 165.74,48.58 165.65,48.49 165.65,48.26 165.57,48.17 165.39,48.17 165.3,48.26 165.3,48.49 165.21,48.58 164.95,48.58 164.8,48.73 164.67,48.73 164.55,48.6 164.42,48.6 164.29,48.72 164.29,48.85 164.42,48.98 164.42,49.1 164.41,49.12 164.41,50.62 163.91,51.13 163.91,51.67 164.22,51.98 164.94,51.98 165.19,52.23 165.19,53.15 165.01,53.33 163.86,53.33 163.61,53.58 163.61,54.42 164.29,55.09 164.29,55.79 164,56.08 164,60.13 167.51,63.64 167.51,68.41 165.32,70.6 159.1,70.6 158.88,70.81 158.88,71.11 158.97,71.2 159.33,71.2 159.73,71.6 160.25,71.6 v6(160.45,71.8)
  IN3 w0.094: v4(167.57,51.07) 167.57,51.42 167.72,51.58 170.02,51.58 170.46,52.02 171.08,52.02 171.24,52.18 171.24,53.64 171.09,53.79 170.77,53.79 170.62,53.64 v5(170.62,53.37)
  BOTTOM w0.127: RD68.1 160.83,76.43 160.68,76.28 160.68,74.77 160.46,74.54 160.46,72.55 UD44.K4 160.14,72.11 v6(160.45,71.8)
DDR_M1_CKE2: length 57.8
  IN3 w0.076: 165.93,54.45 165.96,54.42 166.53,54.42 166.55,54.41 166.55,54.41 166.56,54.41 168.97,54.41 169.67,53.72 169.7,53.72 169.95,53.47 169.95,52.96 v5(169.71,52.72)
  IN3 w0.094: 165.93,54.45 165.89,54.45 165.7,54.64 165.7,55.6 165.48,55.82 165.48,57.42 165.68,57.62 165.68,58.06 165.73,58.11 165.73,58.72 165.9,58.89 165.9,59.61 165.83,59.68 165.83,59.68 165.7,59.81 165.7,61 167.29,62.59 167.29,62.84 169.17,64.72 169.17,74.16 169,74.32 164.68,78.64 146.7,78.64 v5(144.72,76.67)
  BOTTOM w0.127: v5(144.72,76.67) 144.43,74.9 144.43,74.32 144.59,73.94 144.59,73.69 UD43.K3
DDR_M1_CKE3: length 57.2
  IN3 w0.076: v5(169.71,53.37) 169.67,53.41 169.67,53.51 168.91,54.26 166.62,54.26 166.62,54.26 166.48,54.26 166.47,54.27 165.96,54.27 165.94,54.25
  IN3 w0.094: v5(145.28,76.67) 146.97,78.36 164.56,78.36 168.88,74.04 168.88,64.83 167.01,62.96 167.01,62.71 165,60.7 165,60.28 165.66,59.61 165.66,59.25 165.56,59.15 165.56,58.18 165.51,58.13 165.51,57.69 165.3,57.48 165.3,55.69 165.51,55.48 165.51,54.45 165.7,54.25 165.94,54.25
  BOTTOM w0.076: UD43.K4 145.22,72.53 145.22,74.84
  BOTTOM w0.127: v5(145.28,76.67) 145.28,76.24 145.41,76.11 145.41,75.52 145.22,75.32 145.22,74.84
DDR_M1_CLK0: length 53.2
  IN1 w0.109: v4(164.67,53.83) 164.5,53.99 164.5,54.18 164.93,54.61 164.93,56.56 164.63,56.86 164.63,59.49 168.46,63.32 168.46,64.73 168.56,64.83 169.95,64.83 170.17,65.05 170.17,65.52 169.95,65.74 168.56,65.74 168.46,65.84 168.46,66.15 168.56,66.25 169.95,66.25 170.17,66.47 170.17,66.94 169.95,67.16 168.56,67.16 168.46,67.27 168.46,67.56 168.56,67.66 169.93,67.66 170.17,67.89 170.17,68.29 169.91,68.55 168.6,68.55 168.39,68.76 168.39,69.2 169.08,69.89 169.08,70.2 168.74,70.53 168.43,70.53 167.67,69.77 167.53,69.77 167.31,69.99 167.31,70.13 168.22,71.04 168.22,71.35 167.88,71.69 167.57,71.69 166.61,70.72 166.46,70.72 166.25,70.94 166.25,71.08 167.18,72.02 167.18,72.33 166.84,72.66 166.53,72.66 165.73,71.86 165.58,71.86 165.26,72.18 162.33,72.18 161.83,72.68 161.83,72.72 161.44,73.11 161.44,73.36 160.96,73.84 159.64,73.84 159.4,74.08 158.94,74.08 158.46,73.6 158.46,73.04 158.7,72.8 159.01,72.8 v4(159.17,72.64)
  IN3 w0.109: v4(164.67,53.83) 164.24,53.4 v5(164.24,53.37) ; v4(159.17,72.64) 159.49,72.96 v5(159.49,73.04)
  BOTTOM w0.076: v5(159.49,73.04) 159.49,73.15 159.16,73.48 159.16,73.99 159.16,74.14 159.13,74.18 159.13,74.19
  BOTTOM w0.132: 159.13,74.19 159.13,75.04 159.32,75.23 159.32,76.57 RD76.1
DDR_M1_CLK1: length 58.5
  IN1 w0.109: v4(144.56,72.63) 143.95,73.23 143.95,73.7 144.26,74 144.35,74 144.36,74.01 144.82,74.01 144.83,74 144.88,74 146.27,72.61 147.71,72.61 147.81,72.71 147.81,73.02 147.71,73.12 146.7,73.12 146.48,73.34 146.48,73.81 146.68,74.02 146.82,74.02 147.04,74.23 147.04,74.78 146.54,75.28 146.54,76.79 146.76,77.01 147.7,77.01 148.23,76.48 148.23,74.3 149.79,72.74 151.64,72.74 151.93,72.45 151.93,70.28 152.32,69.89 154.24,69.89 155.29,68.83 155.29,68.52 154.69,67.92 154.69,67.77 154.9,67.56 155.05,67.56 155.65,68.16 155.97,68.16 156.76,67.37 156.76,65.88 156.4,65.53 156.4,64.8 156.67,64.53 156.67,56.81 156.69,56.79 156.69,55.44 156.6,55.36 156.6,53.13 157.11,52.62 162.94,52.62 163.19,52.87 164.65,52.87 v4(164.78,53)
  IN3 w0.109: v5(144.27,73.04) 144.56,72.75 v4(144.56,72.63) ; v4(164.78,53) v5(165.15,53.37)
  BOTTOM w0.076: v5(144.27,73.04) 144.27,73.2 143.94,73.54 143.94,73.92 143.92,73.94 143.92,74.08 143.79,74.21 143.79,74.28
  BOTTOM w0.132: RD86.1 143.77,76.5 143.77,74.29 143.79,74.28
DDR_M1_CLK#0: length 52.3
  IN1 w0.109: v4(164.13,53.84) 164.3,54 164.3,54.27 164.73,54.7 164.73,56.47 164.43,56.78 164.43,59.58 168.26,63.41 168.26,64.81 168.48,65.03 169.86,65.03 169.96,65.13 169.96,65.44 169.86,65.54 168.48,65.54 168.26,65.76 168.26,66.23 168.48,66.45 169.86,66.45 169.96,66.56 169.96,66.86 169.86,66.96 168.48,66.96 168.26,67.18 168.26,67.64 168.47,67.86 169.85,67.86 169.96,67.98 169.96,68.21 169.82,68.34 168.52,68.34 168.18,68.68 168.18,69.28 168.87,69.97 168.87,70.11 168.66,70.33 168.51,70.33 167.75,69.57 167.44,69.57 167.11,69.9 167.11,70.22 168.01,71.12 168.01,71.27 167.8,71.48 167.65,71.48 166.69,70.52 166.38,70.52 166.04,70.86 166.04,71.17 166.98,72.1 166.98,72.24 166.76,72.46 166.62,72.46 165.81,71.65 165.5,71.65 165.18,71.97 162.25,71.97 161.63,72.59 161.63,72.63 161.23,73.03 161.23,73.28 160.87,73.64 159.55,73.64 159.31,73.88 159.02,73.88 158.66,73.51 158.66,73.12 158.78,73 159.01,73 159.17,73.16 v4(159.17,73.44)
  IN3 w0.109: v4(159.17,73.44) 159.47,73.74 v5(159.47,73.84) ; v5(164.24,52.72) 163.86,53.11 163.86,53.56 v4(164.13,53.84)
  BOTTOM w0.076: 159.35,74.19 159.49,74.05 UD44.J2
  BOTTOM w0.132: 159.35,74.19 159.35,74.94 159.55,75.14 159.55,76.57 RD90.1
DDR_M1_CLK#1: length 57.7
  IN1 w0.109: v4(164.8,52.37) 164.8,52.53 164.67,52.67 163.28,52.67 163.03,52.41 157.03,52.41 156.4,53.04 156.4,55.44 156.49,55.53 156.49,56.7 156.47,56.72 156.47,64.44 156.2,64.71 156.2,65.61 156.55,65.97 156.55,67.29 155.88,67.96 155.74,67.96 155.13,67.35 154.82,67.35 154.48,67.69 154.48,68 155.09,68.61 155.09,68.75 154.15,69.69 152.23,69.69 151.73,70.19 151.73,72.37 151.55,72.54 149.71,72.54 148.03,74.22 148.03,76.4 147.62,76.8 146.84,76.8 146.74,76.7 146.74,75.36 147.24,74.86 147.24,74.15 146.91,73.81 146.77,73.81 146.68,73.73 146.68,73.42 146.78,73.32 147.79,73.32 148.01,73.1 148.01,72.63 147.79,72.41 146.19,72.41 144.79,73.8 144.74,73.8 144.74,73.81 144.44,73.81 144.44,73.8 144.34,73.8 144.16,73.61 144.16,73.32 144.46,73.02 144.63,73.02 144.73,73.12 144.73,73.3 v4(144.59,73.45)
  IN3 w0.109: v4(144.59,73.45) 144.27,73.76 v5(144.27,73.84) ; v5(165.15,52.72) v4(164.8,52.37)
  BOTTOM w0.076: 144,74.39 144,74.24 144.09,74.15 144.09,74 144.25,73.84 v5(144.27,73.84)
  BOTTOM w0.132: RD82.1 144,76.5 144,74.39
DDR_M1_CS#0: length 90.2
  IN1 w0.094: v4(160.49,72.73) 160.68,72.93 160.68,73.1 160.55,73.23 159.93,73.23 159.52,72.82 159.52,72.44 159.35,72.26 158.91,72.26 158.73,72.44 158.31,72.44 158.13,72.26 155.57,72.26 155.43,72.12 155.43,71.93 155.33,71.83 155,71.83 154.85,71.98 154.85,72.39 154.76,72.48 154.45,72.48 154.36,72.57 154.36,72.84 154.45,72.92 154.76,72.92 154.85,73.01 154.85,73.32 154.57,73.61 154.57,74.77 154.77,74.98 154.84,74.98 155.18,74.64 155.37,74.64 155.53,74.8 155.53,74.92 155.24,75.22 155.24,75.34 155.43,75.53 155.55,75.53 155.95,75.13 156.08,75.13 156.27,75.32 156.27,75.44 155.87,75.85 155.87,75.97 156.05,76.16 156.18,76.16 156.58,75.76 156.71,75.76 156.9,75.95 156.9,76.07 156.49,76.47 156.49,76.6 156.68,76.79 156.81,76.79 157.21,76.39 157.34,76.39 157.67,76.72 157.67,76.97 157.52,77.12 156.43,77.12 156.11,76.79 155.87,76.79 155.58,77.09 155.45,77.09 155.26,76.9 155.26,76.78 155.68,76.35 155.68,76.23 155.49,76.04 155.37,76.04 154.36,77.05 154.21,77.05 154.03,76.87 154.03,76.75 154.87,75.91 154.87,75.88 154.13,75.14 154.13,74.05 v6(153.68,73.61)
  IN3 w0.094: v4(160.49,72.73) 160.61,72.73 160.79,72.91 v5(160.79,73.04) ; v5(145.57,73.04) 146.12,73.59 146.12,73.81 146.03,73.91 144.63,73.91 144.42,74.11 144.42,74.29 144.29,74.42 143.95,74.42 143.83,74.3 143.83,74.02 143.95,73.9 143.95,73.43 143.33,72.81 143.33,71.67 143.73,71.27 143.73,69.73 143.91,69.55 144.15,69.55 144.24,69.64 144.24,71.22 144.49,71.47 144.74,71.47 144.85,71.58 145.73,71.58 145.91,71.76 145.91,72.33 146.12,72.54 149.81,72.54 150.27,72.07 150.27,71.75 150.36,71.66 151.17,71.66 151.25,71.57 151.25,71.3 151.17,71.21 150.36,71.21 150.27,71.12 150.27,70.86 150.36,70.77 150.7,70.77 150.79,70.68 150.79,69.49 151.03,69.25 151.98,69.25 152.14,69.41 152.14,71.04 152.49,71.38 153.29,71.38 153.49,71.59 153.49,73.42 v6(153.68,73.61) 154.03,73.61 155.06,74.64 156.02,74.64 156.41,74.25 157.35,74.25 157.95,73.65 157.99,73.65 158.52,73.12 158.52,72.75 158.85,72.42 158.85,71.44 159.02,71.28 159.02,70.77 159.18,70.6 159.86,70.6 160.09,70.37 160.09,70.02 160.26,69.85 162.8,69.85 162.87,69.79 163.27,69.79 163.33,69.85 164.68,69.85 165.34,69.19 165.34,68.17 165.25,68.08 164.95,68.08 164.86,68 164.86,67.73 164.95,67.64 165.23,67.64 165.37,67.5 165.37,66.05 163.7,64.38 163.31,64.38 161.54,62.61 161.54,61.2 161.48,61.14 161.48,58.46 v5(161.33,58.31)
  BOTTOM w0.127: v6(153.68,73.61) 153.14,74.15 RD62.1
DDR_M1_CS#1: length 92.3
  IN1 w0.094: v6(153.68,74.28) 153.68,75.12 152.39,76.41 152.39,76.54 152.58,76.72 152.71,76.72 153.79,75.64 153.92,75.64 154.11,75.83 154.11,75.95 152.98,77.08 150.49,77.08 150.4,77 150.4,76.71 150.53,76.59 151.56,76.59 153.06,75.09 153.06,74.97 152.87,74.78 152.74,74.78 151.25,76.27 151.12,76.27 150.93,76.08 150.93,75.96 153.27,73.62 153.27,71.92 153.75,71.45 158.89,71.45 158.94,71.4 159.24,71.4 160,72.16 160.59,72.16 160.94,71.82 v6(161.09,71.82)
  IN3 w0.094: v5(161.33,57.01) 161.33,57.31 161.68,57.66 161.68,60.95 161.82,61.09 161.82,62.27 165.54,65.98 165.54,67.57 165.51,67.6 165.51,69.26 165.49,69.29 165.49,71.1 164.86,71.73 161.99,71.73 161.68,72.03 161.68,72.05 161.67,72.06 161.67,72.5 161.04,73.13 161.04,73.14 160.9,73.29 160.89,73.29 160.8,73.38 159.96,73.38 159.73,73.62 159.73,73.96 159.6,74.09 159.59,74.09 159.48,74.21 158.52,74.21 157.8,74.93 154.92,74.93 154.28,74.28 v6(153.68,74.28) 153.42,74.28 153.14,74 153.14,71.84 153.05,71.75 152.78,71.75 152.69,71.84 152.69,74.13 152.6,74.22 152.34,74.22 152.25,74.13 152.25,71.55 152.16,71.46 151.89,71.46 151.8,71.55 151.8,74.18 151.71,74.27 151.45,74.27 151.36,74.18 151.36,72.04 151.27,71.95 151,71.95 150.91,72.04 150.91,74.67 150.82,74.77 150.6,74.77 150.52,74.69 150.52,74.47 150.44,74.38 150.32,74.38 150.24,74.29 150.24,74.03 150.32,73.94 150.44,73.94 150.52,73.85 150.52,73.58 150.44,73.49 150.28,73.49 150.19,73.4 150.19,73.14 150.28,73.05 150.44,73.05 150.52,72.96 150.52,72.63 150.42,72.53 150.14,72.53 149.88,72.79 145.43,72.79 145.29,72.92 145.29,73.16 145.52,73.38 145.52,73.53 145.43,73.61 145.03,73.61 144.96,73.54 144.96,73.22 144.87,73.14 144.87,72.78 145.18,72.48 145.18,71.88 145.26,71.8 145.5,71.8 145.57,71.87 v5(145.57,72.24)
  BOTTOM w0.127: v6(153.68,74.28) 153.26,74.71 RD87.1 ; UD44.L4 161.09,71.94 v6(161.09,71.82)
DDR_M1_D0: length 15.1
  IN3 w0.094: v5(160.12,57.01) 160.07,57.01 159.86,57.22 159.86,58.51 160.03,58.67 160.03,58.87 160.13,58.97 160.13,60.99 159.67,61.44 159.67,61.86 159.98,62.17 159.98,63.49 158.9,64.57 158.75,64.57 158.4,64.92 158.02,64.92 157.8,65.13 157.8,65.85 158.38,66.43 158.38,67.21 158.5,67.33 158.5,67.49 158.26,67.73 156.96,67.73 156.46,68.24 v5(156.24,68.24)
DDR_M1_D1: length 14.8
  IN3 w0.094: v5(160.12,56.36) 160.35,56.59 160.35,56.89 160.37,56.91 160.37,57.12 160.3,57.19 160.3,57.49 160.62,57.81 160.62,58.54 160.8,58.73 160.8,62.94 161.02,63.15 161.02,63.87 159.48,65.41 159.48,65.5 159.24,65.74 159.24,66.09 159.28,66.13 159.28,66.81 159.12,66.98 159.12,67.8 158.17,68.75 157.83,68.75 v5(157.54,69.04)
DDR_M1_D2: length 10.9
  IN3 w0.094: v5(156.89,66.64) 156.89,66.6 156.65,66.36 156.65,66.19 156.27,65.81 156.27,64.91 157.06,64.13 157.06,63.91 158.01,62.96 158.01,60.54 158.34,60.21 158.34,58.18 158.52,58 158.52,57.57 158.82,57.27 v5(158.82,57.01)
DDR_M1_D3: length 12.8
  IN3 w0.094: v5(158.82,56.36) 158.49,56.69 158.49,57.32 158.3,57.51 158.15,57.51 157.95,57.7 157.95,58.05 158.11,58.21 158.11,60.11 157.69,60.54 157.69,62.88 156.77,63.8 156.77,64.07 156.1,64.74 156.1,65.97 156.48,66.34 156.48,66.51 156.64,66.67 156.64,66.74 156.94,67.04 v5(156.94,67.43)
DDR_M1_D4: length 11.8
  IN3 w0.094: v5(160.12,58.31) 160.24,58.44 160.24,58.71 160.33,58.8 160.33,63.68 159.11,64.91 158.74,64.91 158.52,65.14 158.52,66.06 158.56,66.1 158.56,66.85 158.7,66.99 158.7,67.2 158.7,67.2 158.7,67.59 158.3,67.98 157.8,67.98 v5(157.54,68.24)
DDR_M1_D5: length 13.5
  IN3 w0.094: v5(160.12,57.66) 160.12,57.95 160.44,58.27 160.44,58.66 160.57,58.8 160.57,63.12 160.72,63.26 160.72,63.72 159.03,65.41 159.03,66.81 158.91,66.93 158.91,67.73 158.14,68.51 157.16,68.51 v5(156.89,68.24)
DDR_M1_D6: length 11.2
  IN3 w0.094: v5(158.82,57.66) 158.82,57.96 158.54,58.23 158.54,60.31 158.33,60.53 158.33,63.04 157.39,63.98 157.39,64.05 156.46,64.98 156.46,65.66 156.88,66.08 156.88,66.2 157.05,66.37 157.05,66.37 157.14,66.47 157.14,66.98 157.19,67.03 157.19,67.08 v5(157.54,67.44)
DDR_M1_D7: length 11.3
  IN3 w0.094: v5(158.82,58.31) 158.82,60.47 158.58,60.7 158.58,63.19 157.13,64.64 157.13,64.8 156.82,65.12 156.82,65.35 157.21,65.75 157.22,65.75 157.22,66.3 157.31,66.4 157.31,66.91 157.41,67.01 v5(157.53,67.01)
  BOTTOM w0.127: UD44.F11 157.38,66.64 157.08,66.94 157.08,67.13 157.18,67.23 157.3,67.23 v5(157.53,67.01)
DDR_M1_D8: length 12.1
  IN3 w0.094: v5(157.6,57.01) 157.6,57.3 157.35,57.55 157.35,57.56 157.31,57.6 157.31,57.75 157.42,57.86 157.42,58.14 157.35,58.21 157.35,58.28 157.21,58.42 157.21,59.86 156.33,60.74 156.33,62.29 155.22,63.4 155.22,64.48 154.85,64.85 154.85,66.02 155.31,66.48 155.31,67.34 155.22,67.43 v5(154.94,67.43)
DDR_M1_D9: length 12.2
  IN3 w0.094: v5(154.94,66.64) 154.45,66.14 154.45,64.8 154.9,64.35 154.9,63.31 156.04,62.17 156.04,60.77 157.01,59.81 157.01,58.37 157.18,58.2 157.18,58.14 157.22,58.1 157.22,57.9 157.12,57.8 157.12,57.54 157.19,57.47 157.19,57.47 157.25,57.4 157.25,56.36 157.36,56.25 157.49,56.25 v5(157.6,56.36)
DDR_M1_D10: length 15.2
  IN3 w0.094: v5(154.94,69.04) 154.68,68.77 153.26,68.77 152.74,68.25 152.74,64.36 153.18,63.91 153.18,62.78 154.2,61.77 154.2,61.77 154.29,61.67 154.29,60.72 155.79,59.22 155.79,57.81 156.24,57.37 156.24,57.08 v5(156.3,57.01)
DDR_M1_D11: length 17.4
  IN3 w0.094: v5(155.59,69.04) 155.13,69.5 153.84,69.5 153.84,69.5 153.54,69.5 153.54,69.5 153.51,69.5 152.48,68.47 152.48,64.04 152.9,63.62 152.9,62.67 153.92,61.65 153.92,60.76 155.6,59.08 155.6,57.73 155.98,57.35 155.98,56.68 v5(156.3,56.36)
DDR_M1_D12: length 11.5
  IN3 w0.094: v5(157.6,58.31) 157.5,58.42 157.5,59.91 156.62,60.79 156.62,62.41 155.59,63.44 155.59,64.56 155.11,65.03 155.11,65.95 155.73,66.56 155.73,66.86 v5(155.58,67.01)
  BOTTOM w0.127: UD44.C11 155.38,66.64 155.25,66.77 155.25,66.77 155.07,66.95 155.07,67.13 155.19,67.24 155.34,67.24 v5(155.58,67.01)
DDR_M1_D13: length 11.1
  IN3 w0.094: v5(155.59,67.44) 155.7,67.55 155.84,67.55 155.92,67.46 155.92,63.59 155.93,63.58 155.93,63.57 156.96,62.54 156.96,60.83 157.86,59.93 157.86,58.2 157.6,57.94 v5(157.6,57.66)
DDR_M1_D14: length 14.7
  IN3 w0.094: v5(156.3,57.66) 156.3,57.9 156.04,58.16 156.04,59.3 154.6,60.74 154.6,61.77 153.5,62.87 153.5,64.19 153.03,64.67 153.03,68.12 153.46,68.54 155.29,68.54 v5(155.59,68.24)
DDR_M1_D15: length 12.2
  IN3 w0.094: v5(156.3,58.31) 156.3,59.35 154.95,60.7 154.95,61.83 153.83,62.95 153.83,64.28 153.57,64.54 153.57,65.42 153.3,65.69 153.3,67.19 154.04,67.93 154.31,67.93 154.61,68.24 v5(154.94,68.24)
DDR_M1_D16: length 21.8
  IN1 w0.094: v6(162.86,53.06) 163.31,53.51 163.44,53.81 163.44,54.68 164.12,55.36 164.12,55.72 163.77,56.07 163.77,60.66 164.25,61.14 164.25,61.41 166.78,63.94 166.78,67.87 166.33,68.57 165.18,69.71 164.92,69.77 164.81,69.79 164.2,69.79 v6(163.72,69.44)
  BOTTOM w0.127: v6(162.86,53.06) 162.73,53.06 UC1.AJ29 ; UD44.R8 163.39,69.11 v6(163.72,69.44)
DDR_M1_D17: length 19.7
  IN1 w0.094: v6(162.87,53.73) 163.26,54.11 163.26,55.06 163.33,55.13 163.33,56.28 163.59,56.53 163.59,61.15 166.48,64.05 166.48,67.59 165.78,68.29 165.78,68.82 165.16,69.44 v6(164.37,69.44)
  BOTTOM w0.127: UD44.T8 164.37,69.36 v6(164.37,69.44) ; v6(162.87,53.73) 162.71,53.73 UC1.AJ30
DDR_M1_D18: length 16.8
  IN1 w0.094: v6(164.37,67.04) 164.52,67.04 164.63,66.93 164.63,66.75 164.52,66.64 164.2,66.64 164.05,66.5 164.05,65.53 163.75,65.22 163.75,64 161.72,61.97 161.72,61.71 161.63,61.62 161.57,61.62 161.48,61.53 161.48,61.26 161.57,61.17 161.63,61.17 161.72,61.08 161.72,60.82 161.63,60.73 161.57,60.73 161.48,60.64 161.48,60.37 161.57,60.28 161.63,60.28 161.72,60.19 161.72,59.93 161.63,59.84 161.56,59.84 161.47,59.75 161.47,59.48 161.56,59.39 161.63,59.39 161.72,59.31 161.72,59.04 161.63,58.95 161.57,58.95 161.48,58.86 161.48,58.59 161.57,58.51 161.66,58.51 161.75,58.42 161.75,58.15 161.66,58.06 161.57,58.06 161.48,57.97 161.48,57.7 161.57,57.62 161.63,57.62 161.72,57.53 161.72,57.26 161.63,57.17 161.52,57.17 161.44,57.08 161.44,56.82 161.52,56.73 161.54,56.73 161.63,56.64 161.63,56.37 161.54,56.28 161.52,56.28 161.44,56.19 161.44,55.93 161.58,55.78 161.58,55.54 161.05,55.01 v6(161.05,54.99)
  BOTTOM w0.127: v6(164.37,67.04) 164.04,67.36 UD44.T10 ; v6(161.05,54.99) 160.92,54.99 UC1.AM32
DDR_M1_D19: length 16.5
  IN1 w0.094: v6(164.41,66.22) 165.04,65.58 165.04,65.1 164.74,64.79 164.61,64.79 164.41,64.99 164.29,64.99 164.1,64.8 164.1,64.68 164.3,64.48 164.3,64.15 162,61.86 162,55.6 161.53,55.13 161.53,54.09 161.44,54 161.24,54 161.05,54.19 v6(161.05,54.34)
  BOTTOM w0.127: v6(164.41,66.22) 164.04,66.58 UD44.T11 ; UC1.AM31 160.92,54.34 v6(161.05,54.34)
DDR_M1_D20: length 17.1
  IN1 w0.094: v6(161.05,53.69) 160.93,53.57 160.8,53.57 160.68,53.69 160.68,55.32 160.79,55.44 161,55.44 161.15,55.59 161.15,55.75 160.92,55.98 160.92,56.16 161.18,56.42 161.18,62.05 162.89,63.75 162.89,64.05 162.98,64.14 163.25,64.14 163.33,64.23 163.33,64.5 163.25,64.59 162.9,64.59 162.82,64.67 162.82,64.94 162.93,65.06 163.26,65.06 163.52,65.31 163.52,65.49 163.27,65.73 163.27,65.86 163.42,66.01 163.61,66.01 163.7,66.1 v6(163.7,66.24)
  BOTTOM w0.127: UC1.AM30 160.92,53.69 v6(161.05,53.69) ; UD44.R11 163.61,66.64 163.7,66.55 v6(163.7,66.24)
DDR_M1_D21: length 17.1
  IN1 w0.094: v6(163.72,67.04) 163.72,66.74 163.63,66.65 162.94,66.65 162.74,66.45 162.74,65.99 162.6,65.85 162.6,63.88 160.86,62.13 160.86,56.47 160.49,56.1 160.49,53.61 v6(161.05,53.04)
  BOTTOM w0.127: UC1.AM29 160.92,53.04 v6(161.05,53.04) ; UD44.R10 163.72,67.11 v6(163.72,67.04)
DDR_M1_D22: length 17.8
  IN1 w0.094: v6(164.37,68.64) 164.77,68.24 165.03,68.24 165.93,67.34 165.93,64.29 163.02,61.39 163.02,56.72 162.9,56.6 162.9,55.59 162.52,55.21 162.52,54.7 v6(162.87,54.34)
  BOTTOM w0.127: v6(164.37,68.64) 164.04,68.31 UD44.T9 ; v6(162.87,54.34) 162.74,54.34 UC1.AJ31
DDR_M1_D23: length 18.6
  IN1 w0.094: v6(162.87,54.99) 162.87,55.21 163.14,55.48 163.14,56.45 163.3,56.61 163.3,61.27 166.2,64.17 166.2,67.47 165.54,68.14 165.54,68.65 165.11,69.08 164.16,69.08 v6(163.72,68.64)
  BOTTOM w0.127: UC1.AJ32 162.74,54.99 v6(162.87,54.99) ; UD44.R9 163.39,68.31 v6(163.72,68.64)
DDR_M1_D24: length 15.3
  IN1 w0.094: v6(159.23,54.34) 158.79,54.78 158.79,55.11 159.17,55.49 159.17,56.2 159.28,56.31 159.28,63.73 160.63,65.08 160.63,65.81 161.07,66.25 161.07,66.46 161.65,67.04 v6(161.77,67.04)
  BOTTOM w0.127: v6(161.77,67.04) 161.44,67.36 UD44.M10 ; v6(159.23,54.34) 159.1,54.34 UC1.AR31
DDR_M1_D25: length 14.7
  IN1 w0.094: v6(159.23,54.99) 159.41,55.18 159.41,56.19 159.56,56.34 159.56,63.46 160.94,64.83 160.94,65.78 161.37,66.22 161.37,66.4 161.61,66.64 162.02,66.64 v6(162.42,67.04)
  BOTTOM w0.127: v6(159.23,54.99) 159.1,54.99 UC1.AR32 ; UD44.N10 162.09,67.36 v6(162.42,67.04)
DDR_M1_D26: length 20.2
  IN1 w0.094: v6(161.73,69.43) 161.46,69.16 160.76,69.16 160.35,68.75 160.35,68.32 160.26,68.24 158.84,68.24 158,67.39 158,66.53 157.6,66.13 157.6,64.97 157.69,64.87 157.69,57.13 157.44,56.88 157.44,55.62 157.05,55.22 157.05,54.05 v6(157.41,53.69)
  BOTTOM w0.127: v6(161.73,69.43) 161.44,69.14 UD44.M8 ; v6(157.41,53.69) 157.28,53.69 UC1.AV30
DDR_M1_D27: length 22.9
  IN1 w0.094: v6(162.42,68.64) 162.42,68.64 162.09,68.97 162.09,69.61 161.86,69.84 160.39,69.84 159.61,69.06 158.98,69.06 157.75,67.83 157.75,66.81 157.41,66.47 157.41,57.23 157.16,56.98 157.16,55.62 156.85,55.3 156.85,53.6 v6(157.41,53.04)
  BOTTOM w0.127: UD44.N9 162.09,68.31 v6(162.42,68.64) ; UC1.AV29 157.28,53.04 v6(157.41,53.04)
DDR_M1_D28: length 14.7
  IN1 w0.094: v6(161.77,66.24) 161.23,65.7 161.23,64.63 159.85,63.25 159.85,56.32 159.58,56.06 159.58,54.05 v6(159.23,53.69)
  BOTTOM w0.127: v6(159.23,53.69) 159.1,53.69 UC1.AR30 ; UD44.M11 161.44,66.56 v6(161.77,66.24)
DDR_M1_D29: length 15.6
  IN1 w0.094: v6(162.39,66.23) 162.13,65.97 162.13,65.05 160.13,63.05 160.13,56.32 159.76,55.95 159.76,53.58 v6(159.23,53.04)
  BOTTOM w0.127: v6(162.39,66.23) 162.09,66.54 UD44.N11 ; UC1.AR29 159.1,53.04 v6(159.23,53.04)
DDR_M1_D30: length 18.6
  IN1 w0.094: v6(161.77,68.64) 161.42,68.99 160.83,68.99 160.57,68.73 160.57,68.17 160.44,68.03 158.99,68.03 158.18,67.23 158.18,66.34 157.77,65.93 157.77,65.1 157.98,64.89 157.98,56.78 157.7,56.49 157.7,55.51 157.41,55.22 v6(157.41,54.99)
  BOTTOM w0.127: v6(161.77,68.64) 161.44,68.31 UD44.M9 ; v6(157.41,54.99) 157.28,54.99 UC1.AV32
DDR_M1_D31: length 19.6
  IN1 w0.094: v6(163.04,68.63) 162.58,68.17 160.9,68.17 160.57,67.84 159.16,67.84 158.51,67.19 158.51,65.92 158.57,65.85 158.57,64.8 158.26,64.49 158.26,56.58 157.98,56.29 157.98,55.44 157.77,55.23 157.77,54.71 v6(157.41,54.34)
  BOTTOM w0.127: UC1.AV31 157.28,54.34 v6(157.41,54.34) ; v6(163.04,68.63) 162.74,68.33 UD44.P9
DDR_M1_D32: length 19.8
  IN3 w0.094: v5(142.32,68.24) 142.6,67.96 143.16,67.96 143.47,67.65 143.47,67.14 143.55,67.07 143.55,65.83 143.59,65.79 143.59,65.39 143.87,65.11 143.87,65.07 144.46,64.48 148.81,64.48 150.16,63.13 150.54,63.13 151.31,62.36 151.31,62.08 151.85,61.54 152.13,61.54 154.83,58.84 154.83,58.21 154.9,58.14 154.9,57.87 154.83,57.8 154.83,57.56 155.08,57.3 v5(155.08,57.01)
DDR_M1_D33: length 21.8
  IN3 w0.094: v5(155.08,56.36) 154.83,56.62 154.83,57.31 154.6,57.53 154.6,57.83 154.72,57.95 154.72,58.08 154.6,58.19 154.6,58.75 152.11,61.24 151.62,61.24 151.02,61.83 151.02,62.23 150.43,62.82 150.04,62.82 148.61,64.25 144.33,64.25 143.42,65.15 143.42,65.72 143.34,65.8 143.34,66.89 143.24,66.99 143.24,67.63 143.11,67.76 141.66,67.76 141.18,68.24 v5(141.02,68.24)
DDR_M1_D34: length 18.5
  IN3 w0.094: v5(141.66,66.64) 141.66,66.6 141.5,66.45 141.5,65.65 141.28,65.43 141.28,64.71 142.45,63.54 142.57,63.54 143.1,63.01 147.46,63.01 150.48,59.98 151.97,59.98 153.29,58.66 153.29,58.17 153.53,57.93 153.53,57.27 v5(153.78,57.01)
DDR_M1_D35: length 20.4
  IN3 w0.094: v5(141.69,67.44) 141.67,67.43 141.67,67.01 141.31,66.65 141.31,65.71 141.1,65.51 141.1,64.61 143.01,62.7 147.33,62.7 150.24,59.8 151.84,59.8 153.02,58.61 153.02,58.13 152.89,58 152.89,56.87 153.39,56.36 v5(153.78,56.36)

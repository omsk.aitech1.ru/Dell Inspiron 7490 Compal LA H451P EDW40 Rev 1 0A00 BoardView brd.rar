# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RT121  0_01005_5%  [R01005_0OHM]  28.48 60.35 270 top
RT184  100K_01005_1%  [R_01005]  29.23 54.82 0 top
RT186  0_01005_5%  [R_01005]  34.01 50.48 0 bottom
RT188  0_01005_5%  [R01005_0OHM]  34.01 50.94 0 bottom
RT190  0_01005_5%  [R_01005]  29.92 53.38 0 top
RT284  0_01005_5%  [R01005_0OHM]  31.63 62.37 0 top
RT285  0_01005_5%  [R01005_0OHM]  31.57 62.95 0 top
RT287  0_01005_5%  [R01005_0OHM]  30.28 52.93 180 top
RT288  100K_01005_1%  [R_01005]  33.81 60.85 180 top
RT293  1M_01005_1%  [R_01005]  34.01 50.02 0 bottom
RT372  10K_01005_1%  [R_01005]  26.67 53.33 270 top
RT391  10K_01005_1%  [R_01005]  32.97 50.47 0 bottom
RT392  0_01005_5%  [R01005_0OHM]  27.13 53.33 270 top
RT394  0_0201_5%  [R_0201]  19.27 62.26 270 bottom
RT502  10K_01005_1%  [R_01005]  29.14 51.5 270 top
RT503  10K_01005_1%  [R_01005]  27.84 51.16 0 top
RT505  100K_01005_1%  [R_01005]  32.97 51.77 0 bottom
RT506  100K_01005_1%  [R_01005]  34.01 51.77 0 bottom
RT507  100K_01005_1%  [R_01005]  32.97 51.13 0 bottom
RT508  100K_01005_1%  [R_01005]  34.01 54.33 0 bottom
RT509  100K_01005_1%  [R_01005]  32.97 54.33 0 bottom
RT553  100K_01005_1%  [R_01005]  27.84 51.61 0 top
RT554  10K_0201_5%  [R_0201]  24.31 58.35 270 top
RT578  0_0402_5%  [R0402_0OHM]  38.54 51.13 0 top
RT592  10K_01005_1%  [R_01005]  29.6 51.5 270 top
RT593  10K_01005_1%  [R_01005]  34.35 52.85 180 bottom
RT604  10K_01005_1%  [R_01005]  27.59 53.33 270 top
RT605  100K_01005_1%  [R_01005]  28.02 59.99 90 top
RT606  0_0402_5%  [R0402_0OHM]  22.07 61.31 0 top
RT607  0_0402_5%  [R0402_0OHM]  20.94 61.32 180 top
RT608  2.2K_01005_1%  [R_01005]  32.97 52.4 0 bottom
RT609  2.2K_01005_1%  [R_01005]  34.37 52.39 180 bottom
RT610  15_01005_1%  [R_01005]  37.82 53.01 90 top
RU5  0_0201_5%  [R_0201-NPM]  16.85 66.23 180 top
RU6  0_0201_5%  [R_0201-NPM]  16.85 65.54 180 top
RU7  0_0201_5%  [R_0201-NPM]  16.85 64.14 180 top
RU8  0_0201_5%  [R_0201-NPM]  16.85 63.56 180 top
RV1  40.2_01005_1%  [R_01005]  90.04 69.03 135 bottom
RV2  40.2_01005_1%  [R_01005]  89.46 68.94 315 bottom
RV3  40.2_01005_1%  [R_01005]  84.7 41.09 45 bottom
RV4  40.2_01005_1%  [R_01005]  85.24 41.05 225 bottom
RV20  10K_01005_1%  [R_01005]  97.43 66.94 135 top
RV21  10K_01005_1%  [R_01005]  97.94 71.63 135 bottom
RV22  330_01005_1%  [R_01005]  97.45 73.45 180 bottom
RV41  40.2_01005_1%  [R_01005]  85.88 51.88 225 bottom
RV42  40.2_01005_1%  [R_01005]  84.47 52.82 45 bottom
RV43  60.4_01005_1%  [R_01005]  84.04 53.28 45 bottom
RV44  40.2K_01005_1%  [R_01005]  103.03 66.93 135 top
RV51  100K_01005_1%  [R_01005]  103.53 74.72 90 top
RV61  100K_01005_1%  [R_01005]  100.61 76.18 315 bottom
RV68  10K_01005_1%  [R_01005]  119.95 55.92 225 bottom
RV69  100K_01005_1%  [R_01005]  98.92 73.99 135 bottom
RV71  10K_01005_1%  [R_01005]  110.67 55.6 0 top
RV72  10K_01005_1%  [R_01005]  119.44 42.51 45 top
RV74  10K_01005_1%  [R_01005]  111.34 75.62 180 bottom
RV76  10K_01005_1%  [R_01005]  99.24 74.31 135 bottom
RV77  10K_01005_1%  [R_01005]  113.72 75.61 180 bottom
RV80  100K_01005_1%  [R_01005]  97.85 65.67 225 top
RV81  100K_01005_1%  [R_01005]  97.05 65.72 135 top
RV84  100K_01005_1%  [R_01005]  97.43 66.12 135 top
RV88  10K_01005_1%  [R_01005]  103.67 76.3 135 bottom
RV90  10K_01005_1%  [R_01005]  117.2 46.45 225 top
RV91  10K_01005_1%  [R_01005]  99.89 74.96 135 bottom
RV92  10K_01005_1%  [R_01005]  99.28 68.78 180 top
RV93  10K_01005_1%  [R_01005]  99.31 66.75 180 top
RV94  10K_01005_1%  [R_01005]  118.83 54.76 45 bottom
RV102  100K_01005_1%  [R_01005]  98.95 69.31 0 top
RV103  39K_0201_5%  [R_0201]  115.42 43.89 135 top
RV105  100K_0201_5%  [R_0201]  117.67 45.89 315 top
RV111  10K_01005_1%  [R_01005]  109.57 73.78 180 bottom
RV113  10K_01005_1%  [R_01005]  113.78 48.88 225 top
RV116  1K_01005_1%  [R_01005]  81.54 75.45 135 top
RV118  1K_01005_1%  [R_01005]  88.6 69.21 225 bottom
RV120  121_01005_1%  [R_01005]  93.31 65.43 45 top
RV125  549_0201_1%  [R_0201]  94.07 64.06 90 top
RV127  1.33K_0201_1%  [R_0201]  95.57 66.51 180 top
RV162  0_0402_5%  [R0402_0OHM]  121.46 50.92 270 top
RV200  931_0201_1%  [R_0201]  94.77 64.19 90 top
RV203  2.2K_01005_1%  [R_01005]  99.31 67.23 180 top
RV204  2.2K_01005_1%  [R_01005]  99.31 67.74 180 top
RV205  2.2K_01005_1%  [R_01005]  98.26 71.95 135 bottom
RV206  2.2K_01005_1%  [R_01005]  98.59 72.28 135 bottom
RV207  2.2K_01005_1%  [R_01005]  99.28 68.27 180 top
RV208  2.2K_01005_1%  [R_01005]  98.91 72.6 135 bottom
RV376  2.49K_01005_1%  [R_01005]  106.1 47.48 45 top
RV378  100K_01005_1%  [R_01005]  110.35 46.85 45 top
RV381  100K_01005_1%  [R_01005]  96.57 65.34 180 top
RV382  100K_01005_1%  [R_01005]  98.79 75.74 0 top
RV383  100K_01005_1%  [R_01005]  103.02 73.83 90 top
RV384  100K_01005_1%  [R_01005]  103.53 74.18 270 top
RV385  100K_01005_1%  [R_01005]  101.18 76.25 135 bottom
RV387  100K_01005_1%  [R_01005]  105.9 74.08 45 bottom
RV388  100K_01005_1%  [R_01005]  99.15 76.2 180 top
RV389  100K_01005_1%  [R_01005]  106.47 74 225 bottom
RV390  100K_01005_1%  [R_01005]  103.02 75.07 270 top
RV398  100K_01005_1%  [R_01005]  104.23 76.23 225 bottom
RV399  100K_01005_1%  [R_01005]  104.31 75.65 45 bottom
RV623  100K_0201_5%  [R_0201]  34.87 74.16 90 top
RV624  1M_0201_5%  [R_0201]  34.86 75.32 180 top
RV625  47K_0201_5%  [R_0201]  34.29 74.16 90 top
RV626  200K_0201_5%  [R_0201]  37.37 77.15 180 top
RV627  10K_0201_5%  [R_0201]  37.37 77.71 180 top
RV629  200K_0201_5%  [R_0201]  36.04 77.15 180 top
RV630  47K_0201_5%  [R_0201]  29.8 74.52 180 top
RV631  10K_0201_5%  [R_0201]  36.04 77.71 180 top
RV2006  10_0603_5%  [R_0603]  93.74 32.36 0 top
RV2007  100K_0201_5%  [R_0201]  94.53 36.23 180 top
RV2008  100K_0201_5%  [R_0201]  113.61 76.27 270 top
RV2009  10_0603_5%  [R_0603]  116.38 71.46 90 top
RV2437  10K_01005_1%  [R_01005]  82.88 71.68 135 bottom
RV2438  10K_01005_1%  [R_01005]  90.25 45.72 90 bottom
RV2439  10K_01005_1%  [R_01005]  84.57 72.61 315 bottom
RV2440  10K_01005_1%  [R_01005]  87.89 48.37 135 bottom
RV2448  1K_01005_1%  [R_01005]  85.49 42.14 90 bottom
RV2451  121_01005_1%  [R_01005]  79.42 36.39 135 top
RV2453  1K_01005_1%  [R_01005]  91.03 46.9 135 bottom
RV4970  0_0402_5%  [R0402_0OHM]  112.97 52.78 0 top
RV4976  0_0402_5%  [R0402_0OHM]  113.35 55.53 0 top
RV4989  10K_01005_1%  [R_01005]  97.79 67.31 135 top
RV4991  10K_01005_1%  [R_01005]  99.57 74.64 135 bottom
RV4996  100K_01005_1%  [R_01005]  114.16 49.2 45 top
RV4997  10K_01005_1%  [R_01005]  117.28 42.47 45 top
RV4998  10K_01005_1%  [R_01005]  113.94 45.68 45 top
RV5001  1K_01005_1%  [R_01005]  116.14 40.74 45 top
RV5002  100K_0201_5%  [R_0201]  119.46 54.75 90 top
RV5003  10_0603_5%  [R_0603]  115.6 55.5 270 top
RV5004  100K_01005_1%  [R_01005]  115.22 75.56 180 bottom
RV5005  10_0603_5%  [R_0603]  120.23 54.08 0 top
RV5006  100K_0201_5%  [R_0201]  119.02 46.97 90 top
RV5007  10_0603_5%  [R_0603]  85.06 32.1 180 top
RV5008  100K_0201_5%  [R_0201]  77.58 31.93 0 top
RW10  0_0201_5%  [R_0201]  130.72 67.25 0 top
RW11  0_0201_5%  [R_0201]  49.33 49.15 90 top
RW12  0_0201_5%  [R_0201]  50.49 49.15 90 top
RW13  0_0201_5%  [R_0201]  52.25 49.15 90 top
RW14  0_0201_5%  [R_0201]  49.91 49.15 90 top
RW15  0_0201_5%  [R_0201]  51.08 49.15 90 top
RW16  0_0201_5%  [R_0201]  51.66 49.15 90 top
RW24  33_0201_5%  [R_0201]  135.18 48.34 270 top
RW25  22_0201_5%  [R_0201]  119.02 68.04 90 bottom
RW26  33_0201_5%  [R_0201]  137.52 48.8 0 top
RW27  22_0201_5%  [R_0201]  119.02 66.83 90 bottom
RW28  0_0603_5%  [R0603_0OHM]  121.1 71.04 0 top
RW30  0_0201_5%  [R0201_0OHM]  119 69.37 90 bottom
RW31  0_0201_5%  [R0201_0OHM]  119 70.58 90 bottom
RW32  0_0201_5%  [R_0201]  118.37 71.72 90 bottom
RW46  0_0201_5%  [R0201_0OHM]  133.81 69.08 0 top
RW47  0_0201_5%  [R0201_0OHM]  133.81 67.96 0 top
RW48  0_0201_5%  [R0201_0OHM]  133.81 68.52 0 top
RW49  0_0201_5%  [R0201_0OHM]  133.81 67.4 0 top
RW50  0_0201_5%  [R0201_0OHM]  133.81 66.84 0 top
RW51  0_0201_5%  [R0201_0OHM]  133.81 66.28 0 top
RW53  0_0201_5%  [R0201_0OHM]  122.38 65.56 180 top
RW54  0_0201_5%  [R0201_0OHM]  122.38 66.12 180 top
RW55  0_0201_5%  [R0201_0OHM]  122.38 66.68 180 top
RW56  0_0201_5%  [R0201_0OHM]  122.38 67.24 180 top
RW57  0_0201_5%  [R0201_0OHM]  122.38 67.8 180 top
RW58  0_0201_5%  [R0201_0OHM]  122.38 68.37 180 top
RW59  0_0201_5%  [R0201_0OHM]  117.97 74.32 270 bottom
RW60  0_0201_5%  [R0201_0OHM]  132.95 65.67 180 top
RZ2  0_0201_5%  [R_0201]  140.36 27.8 0 bottom
RZ3  100K_0201_5%  [R_0201]  102.82 20.86 90 top
RZ4  0_0201_5%  [R0201_0OHM]  122.21 49.34 270 bottom
RZ5  0_0603_5%  [R0603_0OHM]  44.9 44.47 90 top
RZ7  0_0603_5%  [R0603_0OHM]  121.71 44.08 270 bottom
RZ9  0_0201_5%  [R0201_0OHM]  185.71 26.92 0 top
RZ10  0_0201_5%  [R_0201]  150.94 61.06 0 top
RZ11  0_0402_5%  [R0402_0OHM]  151.5 59.67 270 top
RZ12  0.01_0402_1%  [R_0402]  151.5 56.68 90 top
RZ22  1M_0201_5%  [R_0201]  35.45 14.56 0 top
RZ25  150_0402_5%  [R_0402]  35.17 10.22 90 top
RZ28  0_0402_5%  [R0402_0OHM]  139.08 72.08 90 top
RZ29  0_0402_5%  [R0402_0OHM]  147.96 30.81 0 bottom
RZ30  0.01_0402_1%  [R_0402]  146.53 28.58 0 bottom
RZ36  100K_0201_5%  [R_0201]  46.83 41.01 270 top
RZ1413  330K_0201_1%  [R_0201]  36.04 14 180 top
RZ1416  0_0201_5%  [R0201_0OHM]  132.79 71.12 0 top
RZ1418  100K_0201_5%  [R_0201]  141.63 30.26 0 bottom
RZ1419  0_0201_5%  [R_0201]  122.77 49.34 270 bottom
RZ1420  0_0201_5%  [R0201_0OHM]  46.35 39.23 90 top
RZ1421  0_0402_5%  [R0402_0OHM]  161.94 51.91 180 top
SW1  TST71-N-220-T170-S017_2P  [SW_TST71-N-220-T170-S017_2P]  88.04 5.27 180 bottom
T18  PAD~D  [TPC12]  131.66 57.83 180 bottom
T20  PAD~D  [TPC12]  90.02 62.21 45 top
T21  PAD~D  [TPC12]  90.84 63.18 45 top
T27  PAD~D  [TPC12]  182.62 56.99 180 bottom
T28  PAD~D  [TPC12]  182.62 58.29 180 bottom
T4984  PAD~D  [TPC12]  119.39 53.41 315 bottom
T4985  PAD~D  [TPC12]  119.21 52.1 225 bottom
T4986  PAD~D  [TPC12]  119.76 54.62 135 bottom
T4987  PAD~D  [TPC12]  118.05 54.09 315 bottom
T4988  PAD~D  [TPC12]  85.05 52.23 135 bottom
T4989  PAD~D  [TPC12]  164.05 52.54 0 top
T4990  PAD~D  [TPC12]  130.96 57.38 180 bottom
TP4  PAD  [TPC12]  170.74 33.68 0 bottom
TP5  PAD  [TPC12]  170.73 32.86 0 bottom
TP77  PAD  [TPC12]  170.23 32.19 90 bottom
TP78  PAD  [TPC12]  72.72 73.15 90 top
TP86  PAD  [TPC12]  34.89 20.31 0 top
TP100  PAD  [TPC12]  174.43 36.5 0 top
TP101  PAD  [TPC12]  171.85 36.26 0 top
TP102  PAD  [TPC12]  173.15 36.58 0 top
TP103  PAD  [TPC12]  172.36 37.61 0 top
TP104  PAD  [TPC12]  169.69 33.33 180 bottom
TP105  PAD  [TPC12]  123.84 11.93 0 top
TP106  PAD  [TPC12]  124.84 10.68 0 top
TP107  PAD  [TPC12]  125.12 11.97 0 top
TP108  PAD  [TPC12]  126.25 10.68 0 top
TP109  PAD  [TPC12]  127.53 10.72 0 top
TP110  PAD  [TPC12]  128.85 10.68 0 top
TP111  PAD  [TPC12]  130.24 11.86 0 top
TP112  PAD  [TPC12]  130.77 10.68 0 top
TP113  PAD  [TPC12]  134.35 12.07 0 top
TP114  PAD  [TPC12]  134.18 13.35 0 top
TP115  PAD  [TPC12]  133.12 14.23 0 top
TP116  PAD  [TPC12]  134.56 14.59 0 top
TP117  PAD  [TPC12]  126.4 11.96 0 top
TP118  PAD  [TPC12]  127.23 13.25 0 top
TP119  PAD  [TPC12]  127.67 12.03 0 top
TP120  PAD  [TPC12]  128.96 11.97 0 top
TP121  PAD  [TPC12]  131.57 11.72 0 top
TP122  PAD  [TPC12]  132.32 10.69 0 top
TP123  PAD  [TPC12]  133.14 11.68 0 top
TP124  PAD  [TPC12]  134.19 10.78 0 top
TP125  PAD  [TPC12]  144.36 7.01 0 top
TP126  PAD  [TPC12]  143.34 6.25 0 top
TP127  PAD  [TPC12]  143.68 8.17 0 top
TP128  PAD  [TPC12]  140.26 12.83 0 top
TP129  PAD  [TPC12]  140.17 11.52 0 top
TP130  PAD  [TPC12]  141.61 12.79 0 top
TP131  PAD  [TPC12]  141.25 10.82 0 top
TP132  PAD  [TPC12]  123.52 10.68 0 top
TP133  PAD  [TPC12]  123.01 14.05 0 top
TP134  PAD  [TPC12]  168.11 36.1 0 top
TP135  PAD  [TPC12]  170.65 36.69 0 top
TP136  PAD  [TPC12]  169.38 36.41 0 top
TP137  PAD  [TPC12]  168.53 37.37 0 top
TP138  PAD  [TPC12]  168.06 38.55 0 top
U1  -  [SY6288C20AAC_SOT23-5]  42.8 55.86 270 top
U3  -  [NCT7718W_MSOP8]  133.78 48.79 180 top
U7  -  [74AUP1G07GW_TSSOP5]  129.03 14.08 0 top
U10  -  [TC7SH08FU_SSOP5]  127.8 16.1 180 top
U16  SX9324ICSTRT_WLCSP8  [SX9324ICSTRT_WLCSP_8P]  71 74.68 0 top
U19  -  [AOZ1336DI_DFN8_2X2]  50.28 44.5 180 top
U27  MX25L25645GM2I-10G_SO8  [MX25L25645GM2I-10G_SO8-NPM]  49.87 10.89 90 top
U34  -  [SN74LVC1G123DCUR_VSSOP8]  61.46 26.18 0 top
U711  -  [AP22850SH8-7_W-DFN2020-8]  40.48 73.8 0 top
U6903  -  [SY6288C20AAC_SOT23-5]  10.18 30.85 0 top
UC1  WHL-U42_BGA1528  [WHL-U42_BGA_1528P-T]  179.27 35.68 90 bottom
UC2  -  [74AUP1G07GW_TSSOP5]  181.71 52.19 0 bottom
UC3  MX25L25673GZ4I-08G_WSON8_8X6  [W25Q256JVEIQ_WSON8_8X6]  50.24 10.89 90 top
UC4  -  [NL17SZ08DFT2G_SC70-5]  137.12 67.3 0 top
UC5  -  [NL17SZ08DFT2G_SC70-5]  120.77 51.54 90 bottom
UC9  MC74VHC1G08DFT2G_SC70-5  [SN74AHC1G08DCKR_SC70-5]  137.55 51.42 90 top
UC10  -  [TC7SH08FU_SSOP5]  122.76 54.28 180 bottom
UC18  MC74VHC1G08DFT2G_SC70-5  [SN74AHC1G08DCKR_SC70-5]  109.99 26.44 0 top
UD41  H9CCNNN8JTMLAR-NTM_FBGA178  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  175.51 74.64 270 bottom
UD42  H9CCNNN8JTMLAR-NTM_FBGA178  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  195.63 59.62 180 bottom
UD43  H9CCNNN8JTMLAR-NTM_FBGA178  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  139.07 74.64 270 bottom
UD44  H9CCNNN8JTMLAR-NTM_FBGA178  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  154.29 74.64 270 bottom
UE1  -  [MEC1515H-D0-I-NB_DQFN132_11X11]  42.23 19.48 90 top
UE2  NL17SZ06EDFT2G_SOT-353  [NL17SZ06DFT2G_SC70-5]  56.05 22.7 180 top
UE3  YB8251PST23_PSOT23_3P  [TCS40DLR_SOT23F3]  3.25 76.05 180 top
UE5  -  [74LVC1G32GW_TSSOP5]  62.97 20.32 0 top
UM1  -  [PS186HDMQFN56GTR2-A1_QFN56_7X7]  26.99 39.4 180 top
UM2  -  [G9661MRE1U_TDFN10_3X3]  29.41 37.75 270 top
UM3  W25X20CLZPIG_WSON8_6X5  [W25X20VZPIG_WSON8_6X5]  16.83 48.94 0 top
UM4  -  [TS3DS10224RUKR_WQFN20_3X3]  17.52 71.13 90 top
UN4  -  [SN74LVC1G3157DCKR_SC70-6]  59.69 40.37 90 top
UN5  -  [74AUP1G97GW_SOT363-6]  54.65 48.2 180 top
UPD1  SN1806026RSHR VQFN 56P_7X7  [TPS65987DDHRSHR_VQFN56_7X7]  24.92 34.3 180 bottom
UPD3  W25Q64JVZPIQ_WSON8_6X5  [W25Q64FVZPIG_WSON8_6X5]  15.97 29.96 0 top
UPD5  W25Q64FVSSIG_SO8  [W25Q64FVSSIG_SO8-NPM]  15.97 29.28 0 top
US2  -  [LNG2DMTR_LGA12_2X2]  26.88 75.77 90 top
UT1  THUNDERBOLT_BGA337  [THUNDERBOLT_BGA_337P]  31.4 61.36 0 bottom
UT2  -  [W25Q80DVZPIG_WSON8]  33.41 58.23 270 top
UT14  -  [TC7SH08FU_SSOP5]  32.77 62.91 270 top
UV1  N17S-G2-A1_FCBGA_595P  [N16S-GT-S-A2_BGA_595P]  102.46 73.14 225 bottom
UV2  -  [EM5209VF_DFN14_3X2]  117.53 50.06 0 top
UV6  H5GC4H24MFR-T2C  [H5GQ1H24AFR-T2L_BGA_170P]  88.92 78.68 315 top
UV8  H5GC4H24MFR-T2C  [H5GQ1H24AFR-T2L_BGA_170P]  94.82 41.31 225 top
UV10  -  [NL17SZ08DFT2G_SC70-5]  113.37 44.76 225 top
UV11  -  [MC74VHC1G09DFT2G_SC70-5]  118.05 42.29 225 top
UV12  -  [NL17SZ08DFT2G_SC70-5]  116.5 73 180 bottom
UV17  -  [AP2330W-7_SC59-3]  33.47 40.16 270 top
UV23  -  [74LVC1G32GW_TSSOP5]  120.86 40.54 225 top
UV25  -  [74LVC1G32GW_TSSOP5]  120.84 44.06 0 top
UV26  -  [NL17SZ08DFT2G_SC70-5]  110.75 46.31 225 top
UZ1  -  [EM5209VF_DFN14_3X2]  143.32 28.28 90 bottom
UZ2  AOZ1334DI-01_DFN8-7_3X3  [TPS22961DNYR_WSON8]  114.6 28.49 180 top
UZ3  -  [EM5209VF_DFN14_3X2]  89.99 24.47 0 top
UZ4  -  [TPS22967DSGR_SON8_2X2]  121.27 47.62 0 bottom
UZ7  AOZ1334DI-01_DFN8-7_3X3  [TPS22961DNYR_WSON8]  154.57 60.48 180 top
UZ8  -  [TPS22967DSGR_SON8_2X2]  135.69 72.43 270 top
UZ9  -  [TPS22967DSGR_SON8_2X2]  45.99 42.3 0 top
WL1  S_W/L_MOD INTEL AX201.D2W W/BT S  [INTEL_9560PD2WGE2_152P]  133.55 78.75 180 bottom
XE1  32.768KHZ_15PF_FRB5014A  [X_FRB5014A_4P]  33.58 19.15 90 top
YC1  24MHZ_18PF_8Y24000033  [Y_8Y24000011_4P]  133.96 30.88 90 bottom
YC2  32.768KHZ_9PF_9H03280012  [Y_9H03280012_2P]  129.63 55.6 270 bottom
YM1  27MHZ_12PF_8Y27000002  [Y_8Y27000002_4P]  17.38 45.93 90 bottom
YT1  25MHZ_20PF_8Y25070020  [Y_8Y25000004_4P]  17.79 61.71 270 bottom
YV1  27MHZ_10PF_XRCGB27M000F2P18R0  [Y_XRCGB24M000F2P51R0_4P]  96.07 75.8 0 bottom
ZTB01  PAD  [TPC12]  193.79 29.66 180 bottom
ZTB02  PAD  [TPC12]  192.85 25.9 270 bottom
ZTV01  PAD  [TPC12]  37.45 62.92 0 top
ZTV02  PAD  [TPC12]  37.5 61.65 0 top

## Library data of the parts
C2 C7-C9 C12-C15 C17 C19 C26 C29 C36 C41 C43-C56 C62 C78 C94 C104-C107 C6677 C6901 C6906-C6908 CB16 CC3 CC6 CC73 CC77-CC80 CC83-CC88 CC101 CC110-CC120 CD119 CD125 CD129 CD135 CD140-CD147 CE14 CE24 CE34 CE508-CE510 CIO4-CIO6 CIO9 CM47 CM50-CM52 CN41 CN59 CN61 CN62 CN65-CN69 CPD1-CPD3 CPD6 CPD50-CPD53 CR5 CS1-CS4 CS6 CS34-CS39 CS41 CS43 CS47-CS49 CT189 CT190 CT343 CT344 CT350 CT351 CT361-CT371 CV75-CV77 CV781 CV931-CV933 CW12-CW14 CW16-CW18 CZ9 CZ10 CZ12 CZ38 CZ39 CZ218 CZ219 CZ225 CZ232 CZ236 PC317-PC319 PC321 PC515 PC517-PC520 PC538 PC1811 PC1817-PC1819 PCB48 PCB49 PCF06 PCF07 PCF08 PCH18 PCH20-PCH22 PCI182 PCW36-PCW38 = C_0201
C3 = C_0201: room: RTC
C4 = C_0201: room: FP
C16 CIO1 CR100 CZ227 = C_0201: room: eDP
C22 = C_0201: room: KB
C23 = C_0201: room: TPAD
C28 C30 = C_0201: room: THM
C60 = C_0201: room: AUDIO
C61 = C_0201: room: Other
C1223 CC7-CC12 CC15-CC17 CC19 CC26-CC33 CC41-CC44 CC48 CC51-CC53 CC55 CC56 CC58-CC65 CC81 CC82 CC102-CC104 CE505 CV31 CV34 CV60 CV211 CV214 CV220 CV394 CV397 CZ1-CZ8 CZ11 CZ40 = C_0201: room: CPU
C1224 C6676 CM48 CM49 CPD4 CPD5 CPD7 CPD42 CPD49 CT346 CT352 CW11 CW15 PC100 PC513 PC514 PC535-PC537 PC1803 PC1804 PC1809 PC1810 PC1813 PC1816 PCB18-PCB20 PCB38 PCB41-PCB43 PCB50 PCF09 PCH14 PCH19 PCM19-PCM21 PCM25-PCM27 PCM32 PCV42 PCV44 PCV46 PCV47 PCW35 = C_0402
C6671 CV196 CV197 CV206 CV324 CV325 CV756 CV757 CV785 = C_0201: room: GPU
C6673 = C_0402: room: CAM
C6904 C6905 CD117 CD118 CD120 CD121 CD123 CD124 CD126-CD128 CD130 CD132-CD134 CD136 CD137 CD139 CV1-CV3 CV6-CV8 CV11-CV22 CV38 CV52 CV53 CV55 CV200-CV202 CV205 CV207 CV209 CV210 CV212 CV213 CV216-CV219 CV221 CV222 CV322 CV323 CV326 CV327 CV390-CV393 CV395 CV398-CV402 CV755 CV767-CV780 CV782-CV784 CV786-CV789 = C_0201: room: DGPU
CC1 CC74-CC76 = C_01005
CC4 = C_0201: room: SPI_ROM
CC18 PCH03 PCH04 = C_0805
CC20-CC25 CC35-CC40 CC45-CC47 CS42 = C_0402: room: CPU
CC34 CC49 CC54 CC57 CC72 = C_0603: room: CPU
CC105 CC106 CC109 = C_0201: room: SOC
CC107 CC108 = C_0201: room: CPU_XDP
CD1 CD3 CD5 CD7 CD8 CD10-CD14 CD16-CD21 CD23-CD27 CD41 CD42 CD45 CD46 CD48-CD50 CD52 CD55-CD57 CD59 CD60 CD62-CD68 CD70 CD71 CD73-CD85 CD87-CD89 CD91 CD100-CD103 CD105-CD108 CD113-CD116 CD122 CD131 CD138 = C_0201: room: DDRIII
CD2 CD4 CD6 CD15 CD22 CD43 CD44 CD47 CD51 CD53 CD54 CD58 CD61 CD69 CD86 CD90 = C_0603: room: DDRIII
CD9 = C_0402: room: DDRIII
CD104 CD109-CD111 CN1 CN5 CPD8 CPD40 CPD47 CPD55 CPD56 CV934 CV935 PC504-PC511 PC516 PC1801 PC1802 PC1805-PC1808 PC1812 PCA100 PCA102-PCA112 PCB03 PCB04 PCB05 PCB06 PCB10-PCB17 PCB47 PCG100-PCG137 PCH05 PCH06 PCH07 PCH08 PCH17 PCI100-PCI122 PCI163-PCI171 PCI191-PCI207 PCM18 PCV48 = C_0603
CE1 CE12 CE16 CE23 CE36 = C_0402: room: EC
CE2 CE5-CE11 CE13 CE15 CE18 CE21 CE22 CE26 CE31 CE32 CE504 CE506 CE507 = C_0201: room: EC
CE33 = C_0201: room: LID
CE100 CT1-CT21 CT67 CT95-CT102 CT178-CT187 CT300-CT303 CT305-CT311 CT314-CT322 CT327 CT328 CT331-CT333 CT338-CT341 CT353-CT360 = C_0201: room: TBT
CE101 CIO2 CIO7 CIO8 CN2-CN4 CN6-CN8 CN18 CN60 CN64 CR12 CS44 CZ226 CZ228-CZ231 CZ233 CZ234 CZ238 CZ239 = C_0201: room: WWAN
CH1 CM14 CM28 CM36-CM38 CM45 CM46 CV599 CV600 CV930 = C_01005: room: HDMI
CIO3 = C_0201: room: USB
CLEC1 = SHORTPADS: User Part Number: PART#; room: EC
CLP1-CLP5 = EMIST_SV-11A1M_1P
CLRP2 = SHORTPADS: User Part Number: PART#; room: CPU
CM1 CM2 CM4-CM6 CM10 CM12 CM13 CM15-CM25 CM27 CM29-CM31 CM33-CM35 CM40 CM41 CM43 CM44 CV598 = C_0201: room: HDMI
CM3 CM11 CM26 CM32 CM42 CV597 = C_0603: room: HDMI
CN9 CN10 = C_NEC: room: WWAN
CN57 CN58 = C_0201: room: UZ3
CN72 CN73 CS7-CS14 = C_0201: room: SSD
CR6 = C_0201: room: CARDREADER
CS5 = C_0603: room: SSD
CS32 = C_0201: room: HDD
CS33 = C_0402: room: HDD
CT68 CT69 CT334-CT336 = C_0603: room: TBT
CT323-CT326 CT329 CT330 CT337 = C_0402: room: TBT
CV4 CV5 = C_01005: room: VRAM
CV9 CV10 CV44 CV45 CV51 CV199 CV204 CV396 CV405 CV406 CV601 CV602 CV701 CV702 = C_0603: room: DGPU
CV158 CV159 CV609-CV618 CV709-CV718 CV741 CV754 CV759-CV766 = C_0201: room: VRAM
CV198 CV203 CV403 CV404 = C_0402: room: DGPU
CV603-CV608 CV703-CV708 = C_0603: room: VRAM
CV633 CV651 = C_0201: room: LCD
CZ13-CZ16 CZ18-CZ23 CZ220 CZ221 CZ223 CZ224 CZ235 CZ237 = C_0201: room: DC/DC
CZ17 = C_0402: room: DC/DC
D2 D4 D463 = BAT54CT-7-F_SOT523-3
D3 D462 D464 D465 = RB751S40T1G_SOD523-2
D5 = RB551V-30_SOD323-2: room: TPAD
D8 = RB520SM-30T2R_EMD2-2: room: RTC
D9 = 1N4148WT-7_SOD523-2
DB3 DV13 = RB520SM-30T2R_EMD2-2
DB4 = BAT54HT1G_SOD323-2: room: MEC1641
DS1 DT39 DT40 ED11 ED12 = AZ1045-04F_DFN2510P10E-10-9
DT4 = L30ESD24VC3-2_SOT23-3
DT5 DT6 DT9 DT10 DT13 DT14 DT17 DT18 = DESD3V3Z1BCSF-7_X2-DSN0603-2-2
DV1 = AZ5125-01HPR7G_SOD523-2: room: PCH
DV3-DV5 DV10-DV12 = RB751S40T1G_SOD523-2: room: GPU
DV14 = RB520SM-30T2R_EMD2-2: room: GPU
DZ1 DZ5 DZ6 = RB751S40T1G_SOD523-2: room: CPU
DZ2 DZ7 = RB520SM-30T2R_EMD2-2: room: DC/DC
DZ12 = RB520SM-30T2R_EMD2-2: room: PD
EC2 = C_0201: room: PWR BTN
ED4 = L03ESDL5V0CG3-2_SOT-523-3
ED10 = AZ5123-02SPR7G_SOT23-3
EU6 = L03ESDL5V0CG3-2_SOT-523-3: room: FP
F1 = F_F0603FA3000V032T
F2 F4 = F_T0603FF1000TM
F3 = F_0402L050SLKR: room: KB
F5-F9 = F_T0603FF0500TM
FD1-FD4 = FIDUCIAL_C40M80
H1 = H_1P8N
H2 = H_3P6
H4 H16 H18 H19 = H_3P3
H5 H7 = H_3P7-G
H6 = H_3P6-G
H8 = H_4P1X3P6-G
H9 = H_2P8-G
H10 H12 = H_2P6-G
H11 = H_3P4
H13 = H_3P6X4P1-G
H17 = H_3P7N
H20 = H_2P0X1P6N
H35-H41 = H_0P5X2P3N
H42 = H_2P6
JANT1 = BELLW_10093-1021_4P: room: WWAN
JANT2 = I-PEX_20854-005E-00_5P-T
JAPS1 = ACES_50506-01841-P01_18P-NPM
JCAM1 = ACES_50100-0127N-001_12P
JDB2 = ACES_50521-01041-P01_10P
JDEG1 JSPI1 = ACES_50521-01041-P01_10P: room: EC5085
JEDP1 = I-PEX_20879-040E-01_40P-T
JESPI1 = ACES_50521-01041-P01_10P-NPM: room: TBT_CCG5
JFP1 = TWVM_FPC0510-08RC-TAGHA_8P: room: FP
JHDMI1 = ACON_HMRF6-AK120D_19P-T
JIO1 = I-PEX_20849-040E-01_40P-T
JIO2 = ACES_50279-0040C-P01_4P
JKB1 = STARC_132C30-100020-A2-R_30P: room: KB
JKBBL1 = ACES_51575-00401-001_4P: room: KB
JNGFF1 = LOTES_APCI0144-P007A_75P: room: WWAN
JP3 = JUMP_43X79
JREAD1 = T-SOL_158-1000902603_9P
JRTC1 = ACES_50278-00201-001_2P: room: RTC
JSIM1 = T-SOL_5-501901001000-6_15P-T
JSSD1 = LOTES_APCI0146-P004A_75P
JTP1 = ACES_51524-0080N-001_8P: room: TPAD
JUSBC1 = FOX_UT12123-1A602-7H_24P-T
JXDP1 = JXT_FP270H-061G1AM_61P-NPM
L3 LIO1 LIO2 LU3 LU4 = MURAT_DLM0NSN900HY2D_4P
L16 = MURAT_BLM15PX471SN1D_2P
LC3 = CHILI_PBY160808T-300Y-N_2P
LC4 = MURAT_BLM18EG221TN1D_2P-S
LC5 = MURAT_BLM15BD121SN1D_2P
LED1 = LED_12-22A-S2ST3D-C30-2C_3P
LFP4 = MURAT_DLM0NSN900HY2D_4P-NPM
LI1-LI4 = INPAQ_HCM1012GH900BP_4P-NPM: room: HDMI
LM1-LM5 = CHILI_PBY160808T-300Y-N_2P: room: HDMI
LN3 LN18 LN19 = INPAQ_HCM1012GH900BP_4P-NPM: room: WWAN
LN9 LN10 = MURAT_BLM15AG121SN1D_L0402_2P
LS4 = MURAT_LQG15HSR15J02D_2P
LT2 = MURAT_LQM18NN1R0K00D_2P: room: TBT
LT10 = MAG_MND-04ABIR60M-XGL_2P: room: TBT
LT11 LT13 = TAI-T_HCB2012KF-121T50_2P
LV7 LV10 = TAI-T_HCB1005KF-300T25_2P: room: DGPU
PBATT1 = ACES_50278-01201-001_12P-T
PC11 PC17 PC23 = C_0402: room: PWR_SUPPORT
PC12 = C_0402: room: PWR_BATTIN
PC301 PC302 PC305-PC309 PC315 PC502 PC503 PC532-PC534 PC1814 PC1815 PCA11 PCA12 PCG10 PCG11 PCH15 PCH16 PCI38 PCM06 PCM07 PCV10 PCV12 PCV13 PCV35 PCV37 PCV39 PCV71 PCV72 = C_0402: room: 3_5V
PC303 PC304 = C_0603: room: VGA_CORE
PC310-PC313 = C_0603: room: 1.8VALW
PC501 PCB07 PCB51 PCG20 PCI01 PCI02 PCI13 PCI14 PCI25 PCV01 PCV02 PCV03 PCV04 PCV8 = C_B3
PCA02 PCA03 PCG02 PCG03 = C_0603: room: PWR_CPU_VCCGT
PCA04 PCA05 PCA06 PCA08 PCA09 PCA10 = C_0402: room: PWR_CPU_VCCSA
PCA113-PCA119 = C_0201: room: SA_CAP
PCB01 PCB02 PCB21-PCB23 PCB25-PCB30 PCB33-PCB37 PCB39 PCB40 = C_0402: room: PWR_CHARGER
PCB24 PCB46 = C_0402: room: P_DCIN
PCB31 PCB32 = C_0603: room: PWR_CHARGER
PCB45 = C_0402: room: CHARGER
PCF01 PCF03 PCF04 = C_0402: room: 2.5V
PCF02 = C_0402: room: VCORECAP
PCF05 = C_0603: room: VCORECAP
PCG04 PCG05 PCG06 PCG07 PCG08 PCG09 = C_0402: room: PWR_CPU_VCCGT
PCG138 PCG139 = C_B2: room: GT_CAP
PCG140-PCG153 = C_0201: room: GT_CAP
PCH01 PCH02 PCH09-PCH13 = C_0402: room: +1VA
PCI04 PCI05 PCI16 PCI17 PCI28 PCI29 = C_0603: room: PWR_CPU_VCCCORE
PCI06 PCI07 PCI08 PCI10-PCI12 PCI18-PCI20 PCI22-PCI24 PCI30-PCI32 PCI34-PCI36 = C_0402: room: PWR_CPU_VCCCORE
PCI37 PCI39 PCI41 PCI42 = C_0201: room: 3_5V
PCI123-PCI125 = C_B2: room: CORE_CAP
PCI126 PCI127 PCV14 PCV50-PCV52 = C_EEFSS0D221R
PCI128-PCI162 = C_0201: room: CORE_CAP
PCI172-PCI181 PCI183-PCI190 = C_0201: room: IAGT_CAP
PCM17 PCM22 PCM28 PCM30 = C_0402: room: PDDR
PCM23 PCM24 PCM29 PCM31 = C_0603: room: CPU VR
PCV9 PCV11 PCV33 PCV34 PCV38 PCV53-PCV55 = C_0603: room: 3_5V
PCV15 PCV41 PCV43 PCV45 = C_0402: room: 1.2V/0.6V
PCV16-PCV27 PCV56-PCV70 = C_0603: room: GPU CORE
PCV28-PCV32 = C_0402: room: GPU CORE
PCW12 PCW17-PCW20 PCW22 PCW24 PCW32-PCW34 = C_0402: room: 1p35V
PCW16 PCW21 PCW23 PCW26-PCW31 = C_0603: room: 1p35V
PCZ01 PCZ02 PCZ03 PCZ04 PCZ05 PCZ06 PCZ08 PCZ09 PCZ10 PCZ13 = C_0402: room: ISL95859
PCZ07 PCZ11 PCZ12 = C_0603: room: ISL95859
PD5 PD6 = CEST523NC5VB_SOT-523-3: room: PWR_BATTIN
PDB01 PDB02 = RB751V-40_SOD323-2
PDB05 = SMF4L22A_SOD123FL2
PJP1 PJP501 = JUMP_43X118
PJP302 = JUMP_43X118: room: 3_5V
PJP1800 = JUMP_43X79: room: PWR_CHARGER
PJPDC1 = ACES_50290-0050N-001_5P-T
PJPF01 = JUMP_43X39: room: CPU_CORE
PJPF02 = JUMP_43X39
PJPH01 = JUMP_43X118: room: +1VA
PJPM3 = JUMP_43X39: room: PWR
PJPM4 = JUMP_43X118: room: P_1.2V
PJPW4 = JUMP_43X118: room: 1p35V
PL4 PL5 PL7 PL8 PL311 = 3A_Z120_0603_2P: room: P_DCIN
PL301 = MAG_MMD-06AEI1R5M-M1L_2P: room: 3_5V
PL312 PL1811 = 3A_Z120_0603_2P
PL501 = MAG_MMD-06AH-1R5M-X2_2P
PL511 PLH11 PLV04 = 5A_Z80_0805_2P
PL1801 = TOKO_FDSD0412-H-1R0M-P3_2P
PLA01 = MAG_MMD-05CZ-R33M-V1L_2P: room: PWR_CPU_VCCSA
PLA11 = 5A_Z80_0805_2P: room: PWR_CPU_VCCSA
PLB01 = CYNTE_PCMB103T-1R0MS_2P: room: PWR_CHARGER
PLB11 = MAG_MLV-FY12N1R0M-C1L_2P: room: P_DCIN
PLG01 = CYNTE_PCME063T-R15MS0R907_2P: room: PWR_CPU_VCCGT
PLG11 PLG12 = 5A_Z80_0805_2P: room: PWR_CPU_VCCGT
PLH01 = MAG_MMD-05CZ-R33M-V1L_2P: room: PRIM
PLI01 PLI02 PLI03 = L_7X7X3_M: room: PWR_CPU_VCCCORE
PLI11-PLI13 = 5A_Z80_0805_2P: room: PWR_CPU_VCCCORE
PLM12 = 5A_Z80_0805_2P: room: PDDR
PLM13 = CYNTE_CMLB051B-1R0MS_2P
PLV01 PLV02 = CYNTE_PCME063T-R15MS0R907_2P
PLV03 = 5A_Z80_0805_2P: room: CPU_CORE
PLW12 = CHILI_MHCI06012-1R0M-R8A_2P: room: 1p35V
PLW13 = 5A_Z80_0805_2P: room: 1p35V
PQ1 = FDV301N-G_SOT23-3
PQ2 = LMBT3904WT1G_SC70-3
PQ100 = 2N7002KDW_SOT363-6
PQ501 PQB04 = DMN65D8LW-7_SOT323-3: room: PWR_CHARGER
PQ1402 = DMN65D8LW-7_SOT323-3
PQB01 PQB02 = AON6994_DFN5X6D-8-7
PQB03 = AON7409_DFN8-5: room: PWR_CHARGER
PQB12 PQB13 = LMUN5113T1G_SOT323-3: room: CHARGER
PR1-PR5 PR39 PR101 PR103-PR105 PR301 PR506-PR508 PR1804-PR1807 PR1809 PR1810 PR1813 PR1815 PRF02 PRF03 PRH05 PRH08 PRH09 PRM15 PRM18 PRM19 PRM21-PRM23 PRM25 PRM27 PRV03 PRV23 PRV25 PRV29 PRV31 PRV33-PRV35 PRV39 PRV40 PRV42 PRV43 PRV45 PRV49 PRV50 PRW23 RE51 RE529 RI3 RI4 RI9 RI10 RZ12 RZ30 = R_0402
PR37 PR41 PR42 = R_0402: room: PWR_BATTIN
PR102 = R0402_0OHM: room: PWR_DCIN
PR302-PR304 PR306-PR308 PR525 = R_0402: room: 3_5V
PR305 = R_1206: room: 3_5V
PR501 PR509 PR1802 PR1814 PRB34 PRB35 PRB41 PRH07 PRV32 R17 R38 R40 R41 R65 R75-R77 R86-R88 R90 R241 R242 R1014 R6908 RB21 RB22 RC21-RC26 RC31 RC35-RC37 RC39-RC43 RC89 RC91 RC92 RC95 RC124-RC126 RC130 RC134-RC136 RC164 RC165 RC167-RC170 RC187 RC203 RC239 RC240 RC242 RC244 RC250 RC253 RC256 RC258 RC381 RC387 RC388 RC390 RC405-RC419 RC433 RC436 RC529 RC531 RC535-RC538 RC546 RC548 RC554 RC574-RC576 RD1-RD8 RD25 RE8 RE9 RE12 RE16-RE19 RE21-RE23 RE25 RE26 RE30 RE45 RE49 RE50 RE57 RE58 RE90-RE93 RE100 RE101 RE155 RE161 RE213 RE473 RE478 RE479 RE510 RE511 RE516 RE524 RE527 RE541 RE544-RE547 RE549 RE552-RE554 RFP7 RFP8 RM39 RM48 RM49 RM51 RN3 RN7 RN67 RN82 RN85 RN88 RN89 RN91 RN92 RN97 RN112 RN113 RR167 RS2 RS3 RS13 RT39 RV623-RV627 RV629-RV631 RZ10 RZ22 RZ1413 = R_0201
PR502 = R_0201: room: CPU_CORE
PR503 PRB31 R25 R53 R91 RC539 RC540 RE477 RE508 RE548 RE550 RE551 RI55 RM31-RM38 RM52-RM59 RM61 RN80 RN81 RN86 RN87 RN90 RW59 RW60 RZ9 = R0201_0OHM
PR504 PR1803 PRB06 PRB15 PRM20 R4931 = R_0603
PR505 = R_0402: room: CPU_CORE
PR510 PR1808 PRM24 = R_0805: room: 3V_5VP
PR521 PR522 PR524 = R0402_0OHM: room: Charger
PR523 = R_0402: room: Charger
PRA01 PRB33 PRB43 PRG01 PRH02 PRI01 PRI03 PRI05 PRZ08 PRZ09 PRZ18 PRZ27-PRZ29 = R_0201: room: PWR_CHARGER
PRA02 = R_1206: room: PWR_CPU_VCCSA
PRB01 PRB12 = R_1206_4P-D
PRB02 PRB03 PRB05 PRB07 PRB09 PRB11 PRB13 PRB14 PRB16 PRB19 PRB20 PRB22-PRB27 PRB30 PRB32 PRB36 PRF01 PRZ06 PRZ17 PRZ26 = R_0402: room: PWR_CHARGER
PRB04 = R0603_0OHM: room: PWR_CHARGER
PRB08 = R_0805: room: PWR_CHARGER
PRB10 PRB21 PRB29 PRZ10 PRZ33 PRZ38-PRZ41 PRZ44 PRZ45 = R0402_0OHM: room: PWR_CHARGER
PRB17 PRB18 = R_1206: room: PWR_CHARGER
PRB39 = R_0402: room: CHARGER
PRB65 = R_0603: room: CHARGER
PRB66 = R0603_0OHM: room: CHARGER
PRF04 = R_0402: room: PWR_BATTPOT
PRF05 PRF06 = R_0402: room: 2.5V
PRG02 = R_1206: room: PWR_CPU_VCCGT
PRH01 PRH06 = R_0402: room: +1VA
PRH03 = R_0603: room: +1VA
PRH04 = R_1206: room: 3V_5VP
PRI02 PRI04 PRI06 = R_1206: room: PWR_CPU_VCCCORE
PRM17 PRM26 = R_0402: room: PDDR
PRV20-PRV22 PRV26-PRV28 PRV44 PRV46-PRV48 PRV51 PRW24 R6906 R6907 RE5-RE7 RPD84 RZ28 RZ29 RZ1421 = R0402_0OHM
PRV24 PRV30 = R_1206: room: 1.2V/0.6V
PRV36-PRV38 PRV41 = R_0402: room: 1.2V/0.6V
PRW12 = R_1206: room: 1p35V
PRW13 PRW16-PRW19 PRW21 PRW22 = R_0402: room: 1p35V
PRW14 = R_0603: room: 1p35V
PRZ02 PRZ03 PRZ04 PRZ05 PRZ11 PRZ13 PRZ20-PRZ24 PRZ30-PRZ32 PRZ34-PRZ36 PRZ43 PRZ47-PRZ56 = R_0402: room: ISL95859
PRZ07 PRZ15 PRZ16 PRZ19 PRZ42 PRZ46 = R_0201: room: ISL95859
PRZ12 PRZ14 = R0201_0OHM: room: PWR_CHARGER
PU301 = SY8386BRHC_QFN16_2P5X2P5
PU501 = NB502GQ-Z_QFN16_3X3
PU1801 = NB691GG-Z_QFN11_2X2
PUA01 PUG01 PUI01 PUI02 PUI03 PUV02 PUV03 = MP86902-BGLT-Z_TQFN21-15_3X4
PUB01 = ISL9538BHRTZ-T_TQFN32_4X4
PUF01 = RTQ2522AGQW_WDFN10_3X3
PUH01 = RT6243BGQVF_VQFN18_3P5X3P5
PUM01 = NB685AGQ-Z_QFN16_3X3
PUV01 = MP2988GQ-0010-Z_QFN20_3X3
PUW01 = SY8286RAC_QFN20_3X3: room: 1p35V
PUZ01 = MP2979AGQKT-0038-Z_TQFN48_6X6
Q3 = DMN5L06TK-7_SOT523-3
Q5 = SI1553CDL-T1-GE3_SC70-6
Q7-Q9 Q26 Q27 QN3 = L2N7002WT1G_SC-70-3
Q10 = DMN66D0LDW-7_SOT363-6: room: TPAD
Q11 = DMN66D0LDW-7_SOT363-6: room: THM
Q12 Q31 Q32 QZ3 = LMUN5111T1G_SC70-3
Q13 = MMBT3904WT1G_SC70-3
Q15 Q16 = DMN66D0LDW-7_SOT363-6: room: LED
Q17 = NTK3139PT1G_SOT723-3
Q18 = L2N7002WT1G_SC-70-3: room: RTC
Q19 QE11 = L2N7002WT1G_SC-70-3: room: EC
Q28 Q29 = DMN2400UV-7_SOT-563-6: room: WWAN
Q30 = PMDXB600UNE_DFN1010B-6
QC1 QN4 QN7 QN8 = DMN2400UV-7_SOT-563-6
QV2 QV147 = DMN66D0LDW-7_SOT363-6: room: DGPU
QV3 QV50 = DMN5L06TK-7_SOT523-3: room: VRAM1
QV8 QV150 = DMN66D0LDW-7_SOT363-6
QV18 = MMDT3906_SOT363-6
QV19 QV21 QZ21 = LMBT3904WT1G_SC70-3: room: KBC
QV144-QV146 QV151 QV152 = 2N7002DW-7-F_SOT363-6: room: DC_DC
R5 R6 R63 RE1-RE4 RE20 RE28 RE31 RE32 RE46 RE47 RE66-RE89 RE97 RE163 RE177 RE526 RE534 RE536 RE542 RN95 RS1 = R_0201: room: EC
R10 R12 RIO3-RIO6 RU5-RU8 = R_0201-NPM
R26 R30 R31 R89 RC158 = R_0201: room: LED
R27 R28 RZ25 = R_0402: room: LED
R32 R33 = R0201_0OHM: room: USH
R36 R37 R42 R43 R45 R46 = R_0201: room: TPAD
R39 = R_0402: room: TPAD
R47 = R_0201: room: KB
R48 = R_0402: room: KB
R49 R50 R55 = R_0201: room: THM
R54 = R_0402: room: THM
R64 = R_0201: room: RTC
R256 = R0402_0OHM: room: PD-1
R270-R273 = R_0201: room: eDP
R6902 RZ5 RZ7 = R0603_0OHM
RC1 RC2 RC5 RC6 RC8-RC13 RC19 RC33 RC34 RC38 RC44 RC46 RC50 RC51 RC57 RC58 RC62 RC65 RC68 RC73-RC75 RC77 RC78 RC82 RC86-RC88 RC93 RC94 RC96 RC98-RC100 RC103-RC108 RC110 RC112-RC115 RC117-RC120 RC122 RC127 RC162 RC188-RC191 RC196-RC201 RC205-RC208 RC211 RC213 RC215-RC224 RC230 RC262 RC395 RC504 RC513 RC514 RC516-RC518 RC550 RC553 RC563-RC573 RM30 RM40-RM47 RM50 RPD11-RPD14 RPD90-RPD92 RPD100 RPD124 RPD128-RPD130 RPD139 RPD141 RPD169 RPD170 RPD181 RPD190 RPD191 RPD204 RT288 RT293 RT610 = R_01005
RC4 RC15-RC18 RC20 RC48 RC54 RC60 RC64 RC83 RC123 RC192-RC195 RC227 RC228 RC241 RC243 RC370 RC420 RC524-RC528 RC533 RC547 RC555 RN192 RR132 RR161-RR165 RW32 RZ2 RZ3 RZ1418 = R_0201: room: CPU
RC47 RC49 RC52 RC53 RC55 RC56 RC61 RC69-RC72 RC90 RC160 RC225 RC226 RPD205 RV5001 = R_01005: room: CPU
RC79 RC102 RC523 RT121 RT392 = R01005_0OHM: room: CPU
RC132 RC562 RT578 RZ11 = R0402_0OHM: room: CPU
RC133 RC561 = R_0402: room: CPU
RC238 RC263 RC264 RC556 RW30 RW31 RW46-RW51 RW53-RW58 = R0201_0OHM: room: CPU
RC245-RC248 RE509 RS10 = R0201_0OHM: room: SOC
RC249 = R0402_0OHM: room: SOC
RC251 = R0402_0OHM: room: CPU_XDP
RD10-RD13 RD21-RD24 RD26-RD90 = R_0201: room: DDRIII
RE27 RE99 = R_0402: room: EC
RE29 RE165 RE182 RE507 RE512 RE513 RE525 RE530-RE533 RE535 RE537 RE538 RE543 = R0201_0OHM: room: EC
RE48 = R_0402: room: DBG
RE98 = R_0201: room: DBG
RI1 RI2 RI5-RI8 RI11 RI12 = R_0402: room: HDMI
RM1 RM2 = R0402_0OHM: room: HDMI
RM3-RM6 RM10-RM17 RM23 RM26-RM28 = R_01005: room: HDMI
RM7 = R_0201: room: HDMI
RM60 RPD17 RPD21 RPD22 RPD88 RPD112 RPD123 RPD126 RPD127 RPD163 RPD164 RPD187 = R01005_0OHM
RN10 RN73 RN96 RN193 RS4 RS9 = R0201_0OHM: room: WWAN
RN17 RN18 RN115-RN118 = R_0402: room: WWAN
RN74 RN196-RN199 RS5-RS7 = R_0201: room: WWAN
RN84 = R0402_0OHM: room: WWAN
RPD121 = R1206_0OHM
RR123-RR127 RW10-RW16 RW24-RW27 = R_0201: room: WLAN
RR144 RR156 = R0201_0OHM: room: eDP
RR166 = R0402_0OHM: room: eDP
RS11 RS12 = R_0201: room: SOC
RT1-RT8 RT16 RT20 RT23 RT26 RT27 RT33 RT34 RT36 RT184 RT372 RT391 RT502 RT505-RT509 RT553 RT592 RT593 RT604 RT605 RT608 RT609 = R_01005: room: TBT
RT9 = R_0402: room: Flash ROM
RT40 RT394 = R_0201: room: Flash ROM
RT41 = R_01005: room: GPU
RT186 RT190 = R_01005: room: AR
RT188 RT284 RT285 RT287 = R01005_0OHM: room: AR
RT503 = R_01005: room: PCH
RT554 = R_0201: room: TBT
RT606 RT607 = R0402_0OHM: room: Flash ROM
RV1-RV4 RV116 RV118 RV120 RV2448 RV2451 RV2453 = R_01005: room: VRAM
RV20-RV22 RV41-RV44 RV51 RV61 RV68 RV69 RV71 RV72 RV74 RV76 RV77 RV80 RV81 RV84 RV88 RV90-RV94 RV102 RV203-RV208 RV376 RV378 RV381-RV385 RV387-RV390 RV398 RV399 RV2437-RV2440 RV4989 RV4991 RV4996-RV4998 RV5004 = R_01005: room: DGPU
RV103 = R_0201: room: GPU
RV105 = R_0201: room: PCH
RV111 RV113 = R_01005: room: VGA
RV125 RV127 RV200 = R_0201: room: VRAM
RV162 RV4970 RV4976 = R0402_0OHM: room: VGA
RV2006 RV2009 RV5003 RV5005 RV5007 = R_0603: room: DGPU
RV2007 RV2008 RV5002 RV5006 RV5008 = R_0201: room: DGPU
RW28 = R0603_0OHM: room: WLAN
RZ4 RZ1416 RZ1420 = R0201_0OHM: room: DC/DC
RZ36 = R_0201: room: AUDIO
RZ1419 = R_0201: room: DC/DC
SW1 = SW_TST71-N-220-T170-S017_2P: room: PWR BTN
T18 T27 T28 TP4 TP5 TP77 TP78 TP86 = TPC12: room: CPU
T20 T21 T4984-T4988 = TPC12: room: DGPU
T4989 T4990 TP100-TP138 = TPC12
U1 U6903 = SY6288C20AAC_SOT23-5: room: eDP
U3 = NCT7718W_MSOP8: room: THM
U7 = 74AUP1G07GW_TSSOP5
U10 UC10 UT14 = TC7SH08FU_SSOP5: room: CPU
U16 = SX9324ICSTRT_WLCSP_8P
U19 = AOZ1336DI_DFN8_2X2
U27 = MX25L25645GM2I-10G_SO8-NPM
U34 = SN74LVC1G123DCUR_VSSOP8
U711 = AP22850SH8-7_W-DFN2020-8
UC1 = WHL-U42_BGA_1528P-T: room: CPU
UC2 = 74AUP1G07GW_TSSOP5: room: CPU
UC3 = W25Q256JVEIQ_WSON8_8X6
UC4 UC5 UV26 = NL17SZ08DFT2G_SC70-5
UC9 = SN74AHC1G08DCKR_SC70-5: room: CPU
UC18 = SN74AHC1G08DCKR_SC70-5
UD41-UD44 = H9CCNNN8JTMLAR-NTM_FBGA_178P: room: DDRIII
UE1 = MEC1515H-D0-I-NB_DQFN132_11X11
UE2 = NL17SZ06DFT2G_SC70-5: room: EC
UE3 = TCS40DLR_SOT23F3
UE5 UV25 = 74LVC1G32GW_TSSOP5
UM1 = PS186HDMQFN56GTR2-A1_QFN56_7X7: room: HDMI
UM2 = G9661MRE1U_TDFN10_3X3: room: HDMI
UM3 = W25X20VZPIG_WSON8_6X5
UM4 = TS3DS10224RUKR_WQFN20_3X3
UN4 = SN74LVC1G3157DCKR_SC70-6
UN5 = 74AUP1G97GW_SOT363-6
UPD1 = TPS65987DDHRSHR_VQFN56_7X7
UPD3 = W25Q64FVZPIG_WSON8_6X5
UPD5 = W25Q64FVSSIG_SO8-NPM
US2 = LNG2DMTR_LGA12_2X2: room: HDD
UT1 = THUNDERBOLT_BGA_337P
UT2 = W25Q80DVZPIG_WSON8: room: TBT
UV1 = N16S-GT-S-A2_BGA_595P: room: DGPU
UV2 = EM5209VF_DFN14_3X2: room: DGPU
UV6 UV8 = H5GQ1H24AFR-T2L_BGA_170P: room: GDDR5
UV10 = NL17SZ08DFT2G_SC70-5: room: GPU
UV11 = MC74VHC1G09DFT2G_SC70-5: room: GPU
UV12 = NL17SZ08DFT2G_SC70-5: room: DGPU
UV17 = AP2330W-7_SC59-3
UV23 = 74LVC1G32GW_TSSOP5: room: DGPU
UZ1 = EM5209VF_DFN14_3X2: room: CPU
UZ2 UZ7 = TPS22961DNYR_WSON8
UZ3 = EM5209VF_DFN14_3X2: room: DC/DC
UZ4 UZ8 = TPS22967DSGR_SON8_2X2: room: DC/DC
UZ9 = TPS22967DSGR_SON8_2X2
WL1 = INTEL_9560PD2WGE2_152P
XE1 = X_FRB5014A_4P
YC1 = Y_8Y24000011_4P
YC2 = Y_9H03280012_2P
YM1 = Y_8Y27000002_4P
YT1 = Y_8Y25000004_4P
YV1 = Y_XRCGB24M000F2P51R0_4P: room: CPU
ZTB01 ZTB02 ZTV01 ZTV02 = TPC12: room: Power BTN

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1N4148WT-7_SOD523-2
  rect 0.61x0.711 smd: 1(0,0) 2(1.4,0)
2N7002DW-7-F_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
2N7002KDW_SOT363-6
  oval 0.356x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.6) 5(0.65,1.6) 6(0,1.6)
3A_Z120_0603_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
5A_Z80_0805_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G97GW_SOT363-6
  rect 0.508x0.508 smd: 1(0,0) 3(1.5,0) 4(1.5,1.8) 6(0,1.8)
  rect 0.406x0.61 smd: 2(0.75,0) 5(0.75,1.8)
74LVC1G32GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50100-0127N-001_12P
  round 0.787 hole 0.787 unplated: (-6,-1.2) (2,-1.2)
  oval 0.508x1.499 smd: 1(0,0) 2(0,-5.8) 3(-0.8,0) 4(-0.8,-5.8) 5(-1.6,0) 6(-1.6,-5.8) 7(-2.4,0) 8(-2.4,-5.8) 9(-3.2,0) 10(-3.2,-5.8) 11(-4,0) 12(-4,-5.8)
  custom 0.375x0.375 smd: 13(2.1,0) 14(-6.1,0)
  rect 1.803x2.007 smd: 15(2.1,-2.9) 16(-6.1,-2.9)
  rect 1.803x1.499 smd: 17(2.1,-5.8) 18(-6.1,-5.8)
ACES_50278-00201-001_2P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0)
  rect 1.295x3.353 smd: 3(-2.85,-4.925) 4(4.1,-4.925)
ACES_50278-01201-001_12P-T
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0) 7(7.5,0) 8(8.75,0) 9(10,0) 10(11.25,0) 11(12.5,0) 12(13.75,0)
  rect 1.295x3.353 smd: 13(-2.85,-4.925) 14(16.6,-4.925)
ACES_50279-0040C-P01_4P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 1.295x3.353 smd: 5(-2.85,-4.925) 6(6.6,-4.925)
ACES_50290-0050N-001_5P-T
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0)
ACES_50506-01841-P01_18P-NPM
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50521-01041-P01_10P
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.5) 12(5.5,-2.5)
ACES_50521-01041-P01_10P-NPM
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.5) 12(5.5,-2.5)
ACES_51524-0080N-001_8P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0)
  rect 2.489x2.21 smd: 9(10,-3.05) 10(-3,-3.05)
ACES_51575-00401-001_4P
  oval 0.406x0.838 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 0.787x2.007 smd: 5(-2.2,-3.175) 6(5.2,-3.175)
ACON_HMRF6-AK120D_19P-T
  round 0.787 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.499x2.21 hole 0.889x1.6: 20(-4.65,-6.5) 21(-2.75,1.7) 22(11.75,1.7) 23(13.65,-7.75)
AON6994_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.665)
  rect 3.988x2.667 smd: 7(1.905,3.63)
AON7409_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AOZ1336DI_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
AP22850SH8-7_W-DFN2020-8
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.21) 6(1,2.21) 7(0.5,2.21) 8(0,2.21)
  rect 1.6x0.889 smd: 9(0.75,1.105)
AZ1045-04F_DFN2510P10E-10-9
  oval 0.254x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.381x1.549 smd: 3(1,0.437)
AZ5123-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AZ5125-01HPR7G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.5,0)
BAT54CT-7-F_SOT523-3
  oval 0.406x0.508 smd: 1(0,0) 2(-0.5,-1.3) 3(0.5,-1.3)
BAT54HT1G_SOD323-2
  rect 0.635x0.838 smd: 1(0,0) 2(2.225,0)
BELLW_10093-1021_4P
  rect 0.61x0.559 smd: 1(0,0)
  custom 0.145x0.145 smd: 2(0.96,0.975) 4(-0.96,0.975)
  rect 0.508x0.508 smd: 3(0,1.975)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.584 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_01005
  rect 0.229x0.254 smd: 1(0,0) 2(0.356,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_B3
  rect 1.346x2.692 smd: 1(0,0) 2(2.75,0)
C_EEFSS0D221R
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_NEC
  rect 0.787x1.092 smd: 1(0,0) 2(2.45,0)
CEST523NC5VB_SOT-523-3
  oval 0.508x0.61 smd: 1(0,0)
  oval 0.406x0.61 smd: 2(-0.5,-1.24) 3(0.5,-1.24)
CHILI_MHCI06012-1R0M-R8A_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CHILI_PBY160808T-300Y-N_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
CYNTE_CMLB051B-1R0MS_2P
  rect 1.905x2.489 smd: 1(0,0) 2(4.095,0)
CYNTE_PCMB103T-1R0MS_2P
  rect 4.089x4.089 smd: 1(0,0) 2(9.5,0)
CYNTE_PCME063T-R15MS0R907_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
DESD3V3Z1BCSF-7_X2-DSN0603-2-2
  rect 0.203x0.279 smd: 1(0,0) 2(0.4,0)
DMN5L06TK-7_SOT523-3
  oval 0.406x0.508 smd: 1(0,0) 2(-0.5,-1.3) 3(0.5,-1.3)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN2400UV-7_SOT-563-6
  oval 0.305x0.61 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,1.6) 5(0.5,1.6) 6(0,1.6)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
EMIST_SV-11A1M_1P
  rect 2.591x2.718 smd: 1(0,0)
F_0402L050SLKR
  rect 0.61x0.711 smd: 1(0,0) 2(1,0)
F_F0603FA3000V032T
  rect 0.711x0.991 smd: 1(0,0) 2(1.5,0)
F_T0603FF0500TM
  rect 0.711x0.991 smd: 1(0,0) 2(1.5,0)
F_T0603FF1000TM
  rect 0.711x0.991 smd: 1(0,0) 2(1.5,0)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
FOX_UT12123-1A602-7H_24P-T
  round 0.61 hole 0.61 unplated: (-1.05,-0.325) (6.3,-0.325)
  oval 1.194x2.489 hole 0.61x1.905: 1(-2.3,-0.775) 2(7.55,-0.775)
  oval 2.261x1.092 hole 0.787x0.711: 3(-1.15,-1.425) 4(6.4,-1.425)
  oval 1.194x2.21 hole 0.61x1.6: 5(-3.225,-6.425) 6(8.475,-6.425)
  oval 0.279x0.94 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  oval 0.279x0.838 smd: B1(5.25,-1.65) B2(4.75,-1.65) B3(4.25,-1.65) B4(3.75,-1.65) B5(3.25,-1.65) B6(2.75,-1.65) B7(2.25,-1.65) B8(1.75,-1.65) B9(1.25,-1.65) B10(0.75,-1.65) B11(0.25,-1.65) B12(-0.25,-1.65)
G9661MRE1U_TDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.591x1.6 smd: 11(1,1.55)
H5GQ1H24AFR-T2L_BGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
H9CCNNN8JTMLAR-NTM_FBGA_178P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A6(4,0) A8(5.601,0) A9(6.401,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) B1(0,-0.65) B2(0.8,-0.65) B3(1.6,-0.65) B4(2.4,-0.65) B5(3.2,-0.65) B6(4,-0.65) B8(5.601,-0.65) B9(6.401,-0.65) B10(7.201,-0.65) B11(8.001,-0.65) B12(8.801,-0.65) B13(9.601,-0.65) C2(0.8,-1.3) C3(1.6,-1.3) C4(2.4,-1.3) C5(3.2,-1.3) C6(4,-1.3) C8(5.601,-1.3) C9(6.401,-1.3) C10(7.201,-1.3) C11(8.001,-1.3) C12(8.801,-1.3) D2(0.8,-1.95) D3(1.6,-1.95) D4(2.4,-1.95) D5(3.2,-1.95) D6(4,-1.95) D8(5.601,-1.95) D9(6.401,-1.95) D10(7.201,-1.95) D11(8.001,-1.95) D12(8.801,-1.95) E2(0.8,-2.6) E3(1.6,-2.6) E4(2.4,-2.6) E5(3.2,-2.6) E6(4,-2.6) E8(5.601,-2.6) E9(6.401,-2.6) E10(7.201,-2.6) E11(8.001,-2.6) E12(8.801,-2.6) F2(0.8,-3.25) F3(1.6,-3.25) F4(2.4,-3.25) F5(3.2,-3.25) F6(4,-3.25) F8(5.601,-3.25) F9(6.401,-3.25) F10(7.201,-3.25) F11(8.001,-3.25) F12(8.801,-3.25) G2(0.8,-3.9) G3(1.6,-3.9) G4(2.4,-3.9) G5(3.2,-3.9) G6(4,-3.9) G8(5.601,-3.9) G9(6.401,-3.9) G10(7.201,-3.9) G11(8.001,-3.9) G12(8.801,-3.9) H2(0.8,-4.55) H3(1.6,-4.55) H4(2.4,-4.55) H5(3.2,-4.55) H6(4,-4.55) H8(5.601,-4.55) H9(6.401,-4.55) H10(7.201,-4.55) H11(8.001,-4.55) H12(8.801,-4.55) J2(0.8,-5.2) J3(1.6,-5.2) J4(2.4,-5.2) J5(3.2,-5.2) J6(4,-5.2) J8(5.601,-5.2) J9(6.401,-5.2) J10(7.201,-5.2) J11(8.001,-5.2) J12(8.801,-5.2) K2(0.8,-5.85) K3(1.6,-5.85) K4(2.4,-5.85) K5(3.2,-5.85) K6(4,-5.85) K8(5.601,-5.85) K9(6.401,-5.85) K10(7.201,-5.85) K11(8.001,-5.85) K12(8.801,-5.85) L2(0.8,-6.5) L3(1.6,-6.5) L4(2.4,-6.5) L5(3.2,-6.5) L6(4,-6.5) L8(5.601,-6.5) L9(6.401,-6.5) L10(7.201,-6.5) L11(8.001,-6.5) L12(8.801,-6.5) M2(0.8,-7.15) M3(1.6,-7.15) M4(2.4,-7.15) M5(3.2,-7.15) M6(4,-7.15) M8(5.601,-7.15) M9(6.401,-7.15) M10(7.201,-7.15) M11(8.001,-7.15) M12(8.801,-7.15) N2(0.8,-7.8) N3(1.6,-7.8) N4(2.4,-7.8) N5(3.2,-7.8) N6(4,-7.8) N8(5.601,-7.8) N9(6.401,-7.8) N10(7.201,-7.8) N11(8.001,-7.8) N12(8.801,-7.8) P2(0.8,-8.45) P3(1.6,-8.45) P4(2.4,-8.45) P5(3.2,-8.45) P6(4,-8.45) P8(5.601,-8.45) P9(6.401,-8.45) P10(7.201,-8.45) P11(8.001,-8.45) P12(8.801,-8.45) R2(0.8,-9.1) R3(1.6,-9.1) R4(2.4,-9.1) R5(3.2,-9.1) R6(4,-9.1) R8(5.601,-9.1) R9(6.401,-9.1) R10(7.201,-9.1) R11(8.001,-9.1) R12(8.801,-9.1) T1(0,-9.75) T2(0.8,-9.75) T3(1.6,-9.75) T4(2.4,-9.75) T5(3.2,-9.75) T6(4,-9.75) T8(5.601,-9.75) T9(6.401,-9.75) T10(7.201,-9.75) T11(8.001,-9.75) T12(8.801,-9.75) T13(9.601,-9.75) U1(0,-10.4) U2(0.8,-10.4) U3(1.6,-10.4) U4(2.4,-10.4) U5(3.2,-10.4) U6(4,-10.4) U8(5.601,-10.4) U9(6.401,-10.4) U10(7.201,-10.4) U11(8.001,-10.4) U12(8.801,-10.4) U13(9.601,-10.4)
H_0P5X2P3N
  oval 0.508x2.311 hole 0.508x2.311 unplated: (0,0)
H_1P8N
  round 1.803 hole 1.803 unplated: (0,0)
H_2P0X1P6N
  oval 2.007x1.6 hole 2.007x1.6 unplated: (0,0)
H_2P6
  round 3.099 hole 2.591: 1(0,0)
H_2P6-G
  round 3.099 hole 2.591: 1(0,0)
H_2P8-G
  round 3.302 hole 2.794: 1(0,0)
H_3P3
  round 3.81 hole 3.302: 1(0,0)
H_3P4
  round 3.912 hole 3.404: 1(0,0)
H_3P6
  round 4.115 hole 3.607: 1(0,0)
H_3P6-G
  round 4.115 hole 3.607: 1(0,0)
H_3P6X4P1-G
  oval 4.115x4.597 hole 3.607x4.089: 1(0,0)
H_3P7-G
  round 4.216 hole 3.708: 1(0,0)
H_3P7N
  round 3.708 hole 3.708 unplated: (0,0)
H_4P1X3P6-G
  oval 4.597x4.115 hole 4.089x3.607: 1(0,0)
I-PEX_20849-040E-01_40P-T
  oval 0.305x0.61 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 0.559x0.711 smd: 41(-0.9,-0.05) 42(20.4,-0.05)
  rect 1.194x1.702 smd: 43(-2.93,-2.8) 44(22.43,-2.8)
  rect 0.406x0.559 smd: 45(-1.25,1.24) 46(0.25,1.325) 47(1.75,1.325) 48(3.25,1.325) 49(4.75,1.325) 50(6.25,1.325) 51(7.75,1.325) 52(9.25,1.325) 53(10.25,1.325) 54(11.75,1.325) 55(13.25,1.325) 56(14.75,1.325) 57(16.25,1.325) 58(17.75,1.325) 59(19.25,1.325) 60(20.75,1.24)
  rect 0.61x1.194 smd: 61(-2.645,-0.7) 62(22.145,-0.7)
  rect 0.559x0.559 smd: 63(2.25,-0.825) 64(5.25,-0.825) 65(8.25,-0.825) 66(11.25,-0.825) 67(14.25,-0.825) 68(17.25,-0.825)

# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LX_1.05V: length 11.3
  TOP w0.081: PRH04.1 v1(133.15,20.97)
  IN1 w0.508: v6(134.58,22.7) 133.97,22.7 133.59,22.32 128.87,22.32 127.43,23.75 v4(127.43,24.08)
  IN3 w0.254: v4(127.43,24.08) 127.67,24.08 v5(128.05,24.46)
  BOTTOM w0.508: PCH10.2 127.98,24.53 v5(128.05,24.46)
  vias: v6(134.58,22.06)
LX_1.8V: length 6.2
  TOP w0.254: 67.99,25.82 67.84,25.97 67.31,25.97 67.02,25.69 67.02,24.34 66.51,23.83 66.51,21.52 66.83,21.2 PR1804.1
  vias: v1(67.77,27.74)
LX_3V: length 0.8
  TOP w0.081: v6(18.12,12.3) v1(18.92,12.3)
  vias: v6(17.49,12.3)
LX_5V: length 3.3
  IN2 w0.254: v6(17.37,19.86) 15.56,19.86 v6(15,20.41)
  BOTTOM w0.254: PR506.1 14.72,20.14 v6(15,20.41)
  vias: v3(18.28,19.13)
LX_+1.35VGPU:
  vias: v2(69.98,52.87) v2(70.19,52.62) v4(70.28,53.09) v4(70.6,52.78) v5(70.27,53.95) v5(70.6,53.95)
LX_GPU1:
  vias: v1(57.47,71.34) v6(56.08,76.76) v6(58.57,76.3)
LX_GPU2:
  vias: v1(58.12,68.99) v6(58.05,64.54) v6(58.05,63.78)
LX_GT: length 1.9
  BOTTOM w0.081: v1(193.83,43.91) 194.04,44.12 PRG02.1
LX_IA1:
  vias: v3(171.22,16.73) v6(171.74,17.7) v6(171.75,17.14)
LX_IA2:
  vias: v3(174.52,15.97) v6(174.84,17.11) v6(174.84,16.47)
LX_IA3:
  vias: v1(185.88,15.41) v6(181.73,19.38) v6(182.56,19.41)
LX_SA: length 0.6
  TOP w0.081: v6(143.34,22.89) 143.34,22.3 v1(143.36,22.29)
  vias: v6(143.98,22.89)
M2_SSD_PEDET: length 31.9
  TOP w0.081: v6(114.24,33) 113.85,33.39 RS1.2
  IN3 w0.064: v6(114.24,33) 114.36,33 120.39,39.03 120.93,39.03 121.04,39.14 123.78,39.14 124.09,38.83 127.21,38.83 127.32,38.94 128.13,38.94 128.24,38.83 129.7,38.83 v5(129.95,39.08)
  BOTTOM w0.081: v6(114.24,33) 114.76,33.52 JSSD1.69 ; UC1.CM10 136.58,41.23 136.32,40.97 134.93,40.97 134.63,40.67 134.32,40.67 133.85,41.14 131.22,41.14 131.09,41.01 130.65,41.01 130.1,40.46 v1(130.1,40.12) 130.1,39.23 v5(129.95,39.08)
MASK_SATA_LED#: length 46.9
  TOP w0.081: Q3.2 37.2,43.58 36.96,43.34 RC158.1 R26.2 37.09,42.33 37.09,39.06 36.76,38.73 v2(36.43,38.73) ; UE1.B21 50.3,22.43 49.91,22.82 49.91,22.99 49.81,23.09 v2(49.66,23.09)
  IN1 w0.064: v4(47.99,24.43) 48.44,23.98 49.02,23.98 49.59,23.41 49.59,23.16 v2(49.66,23.09) ; v4(34.93,32.72) 34.64,33.01 34.64,34.57 34.95,34.89 34.95,35.71 35.35,36.11 35.35,37.65 v2(36.43,38.73)
  IN2 w0.066: v4(47.99,24.43) 43.36,24.43 43.03,24.11 43.03,23.31 41.43,21.71 40.37,21.71 40.05,22.03 38.06,22.03 37.38,21.35 36.51,21.35 36.01,21.85 36.01,21.95 36.31,22.25 36.69,22.25 36.99,22.55 36.99,23.42 37.35,23.78 38.73,23.78 39.11,24.16 39.11,26.54 38.01,27.64 38.01,29.33 38.29,29.61 38.29,31.22 37.58,31.93 36.05,31.93 35.85,32.12 35.53,32.12 v4(34.93,32.72)
MCARD_WWAN_PWREN: length 26.1
  TOP w0.081: v2(46.74,18.85) 46.74,19.04 46.73,19.04 UE1.A10 ; RZ1420.1 46.35,38.95 46.8,38.49 46.8,37.09 v1(46.54,36.83) 45.52,35.81 v2(45.15,35.81)
  IN1 w0.064: v2(46.74,18.85) 46.26,18.85 46.26,18.85 45.94,18.85 v4(45.9,18.89) ; v4(45.34,32.16) 44.72,32.79 44.72,34.75 45.14,35.17 45.14,35.79 v2(45.15,35.81)
  IN3 w0.064: v4(45.34,32.16) 47.52,29.99 47.52,28.22 47.14,27.84 46.85,27.84 44.81,25.8 44.81,19.76 45.68,18.89 v4(45.9,18.89)
MCARD_WWAN_PWREN_R: length 3.5
  TOP w0.254: UZ9.3 46.99,41.67 47.41,41.25 CZ237.1 RZ36.1 46.68,41.01 46.35,40.68 RZ1420.2
ME_FWP: length 147.2
  TOP w0.081: UE1.A4 43.73,19.16 43.4,18.82 42.84,18.82 v2(42.69,18.68)
  IN1 w0.064: v2(42.69,18.68) 42.35,19.02 42.35,19.11 43.2,19.96 43.2,21.43 47.1,25.34 49.81,25.34 50.05,25.1 50.86,25.1 51.45,24.51 52.33,24.51 52.4,24.45 53.32,24.45 53.81,24.95 53.81,24.97 54.34,25.49 54.69,25.49 55.58,26.38 56.21,26.38 58.39,28.56 58.98,28.56 58.99,28.56 59.22,28.56 59.22,28.56 59.28,28.56 60.84,30.13 60.86,30.13 60.92,30.19 75.49,30.19 79.09,26.59 79.09,26.43 79.09,26.43 79.09,25.38 79.81,24.67 80.27,24.67 82.69,22.25 86.27,22.25 91.69,27.67 98.84,27.67 98.99,27.67 102.77,31.44 102.77,32.98 103.64,33.85 103.64,33.99 103.82,34.17 103.82,34.61 v4(103.98,34.76)
  IN2 w0.066: v4(103.98,34.76) 104.1,34.63 104.37,34.63 104.87,35.13 104.87,37.86 104.4,38.32 104.4,40.71 110.43,46.73 110.43,48.31 116.57,54.46 127.54,54.46 127.79,54.7 127.79,56.54 129.6,58.36 131.74,58.36 132.38,59 133.29,59 135.46,61.17 136.85,61.17 137.06,60.97 137.06,60.76 136.99,60.7 136.99,60.39 v4(136.91,60.31)
  IN3 w0.064: v5(137.02,62.16) 137.02,61.94 136.9,61.81 136.9,61.19 137.01,61.08 137.01,60.41 v4(136.91,60.31)
  BOTTOM w0.081: v5(137.02,62.16) 137.08,62.11 137.31,62.11 138.04,62.84 148.06,62.84 v1(148.71,62.19) 148.71,61.12 148.37,60.79 RC50.1
MEM_CONFIG0: length 3.8
  BOTTOM w0.081: RC215.2 131.41,48.12 131.69,48.4 132.51,48.4 132.64,48.27 RC216.1 132.82,48.08 133.25,47.65 UC1.CR20
MEM_CONFIG1: length 6.3
  BOTTOM w0.081: UC1.CM20 136.58,47.67 136.28,47.97 135.9,47.97 135.81,47.87 135.62,47.87 135.5,48 135.24,48 135.2,47.96 134.81,47.96 134.72,48.05 133.62,48.05 132.93,48.74 RC218.1 132.64,48.93 132.51,49.06 131.61,49.06 131.41,48.86 RC217.2
MEM_CONFIG2: length 4.8
  BOTTOM w0.081: UC1.CN19 135.61,47.15 135.45,47.31 133.24,47.31 133.13,47.41 RC220.1 132.65,47.58 132.49,47.74 131.74,47.74 RC219.2
MEM_CONFIG3: length 5.5
  BOTTOM w0.081: RC221.2 131.41,46.95 131.53,47.08 132.55,47.08 132.65,46.99 RC222.1 132.95,46.76 133.03,46.67 135.67,46.67 135.85,46.75 136.1,47 UC1.CM19
MEM_CONFIG4: length 5.3
  BOTTOM w0.081: UC1.CN18 135.91,46.43 135.52,46.04 133.03,46.04 132.97,46.1 RC224.1 132.63,46.34 132.55,46.42 131.51,46.42 131.41,46.32 RC223.2
MEM_SMBCLK: length 26
  TOP w0.081: v2(137.31,43.03) 137.64,42.7 RC198.1 ; v2(127.32,43.07) 126.88,43.07 125.54,44.41 125.54,47.4 125.44,47.5 125.44,50.49 125.52,50.57 125.52,51.55 125.74,51.77 v1(125.74,52) 125.74,52.57 v6(125.65,52.66)
  IN1 w0.064: v2(127.32,43.07) 131.67,43.07 132.57,42.18 132.92,42.18 133.31,42.56 136.2,42.56 136.67,43.03 v4(136.84,43.03) 137.3,43.03 v2(137.31,43.03)
  IN3 w0.064: v4(136.84,43.03) 137.09,43.03 v5(137.27,43.21)
  BOTTOM w0.081: UC1.CK14 137.24,43.25 v5(137.27,43.21) ; v6(125.65,52.66) 125.65,52.92 126.03,53.29 QC1.6 125.38,53.66 124.86,53.14 RC388.1
MEM_SMBDATA: length 26.6
  TOP w0.081: v2(126.03,45.32) 125.93,45.42 125.93,47.56 125.84,47.65 125.84,50.33 125.91,50.41 125.91,51.38 126.14,51.61 v1(126.14,53.86) v6(125.08,54.92) ; RC199.1 138.93,44.2 138.57,44.55 v2(138.57,44.62)
  IN1 w0.064: v4(138.96,44.55) 138.89,44.62 v2(138.57,44.62) 138.38,44.62 138.33,44.57 134.4,44.57 134.18,44.79 128.51,44.79 128.26,45.05 127.91,45.05 127.72,45.24 126.11,45.24 v2(126.03,45.32)
  IN3 w0.064: v4(138.96,44.55) 138.91,44.6 138.68,44.6 138.57,44.71 v5(138.54,44.71)
  BOTTOM w0.081: QC1.3 124.43,54.97 RC387.1 125.08,55.25 v6(125.08,54.92)
MEM_VREF: length 11.4
  TOP w0.081: QV50.2 96.04,64.34 96.04,65.04 96.03,65.04 95.92,65.15 95.92,65.85 96.02,65.95 96.02,66.92 95.65,67.28 95.65,67.72 97.25,69.31 RV102.1 98.95,69.51 99.15,69.71 v6(100.73,69.71)
  BOTTOM w0.081: v6(100.73,69.71) UV1.C5
MODE1_5V: length 2.5
  BOTTOM w0.254: PU501.14 13.71,22.43 13.21,21.93 12.5,21.93 12.08,21.51 PR505.1
MODE2_5V: length 3.2
  BOTTOM w0.203: PR502.2 11.35,21.01 11.44,21.1 11.44,22.23 12.06,22.85 PU501.16
MODEL_ID: length 3.8
  TOP w0.081: CE10.1 47.52,16.9 RE3.2 47.48,17.02 47.75,17.29 47.75,18.04 47.65,18.14 RE4.2 47.4,18.4 47.73,18.73 UE1.A12
MSCLK: length 32.6
  TOP w0.081: JDEG1.6 34.85,5.9 v2(33.99,6.76)
  IN1 w0.064: v4(37.06,7.37) 36.19,7.37 v2(36.15,7.32) 36.15,6.89 35.54,6.28 34.47,6.28 v2(33.99,6.76) ; v2(45.98,29.53) 45.98,28.86 v4(46.06,28.78)
  IN3 w0.064: v4(46.06,28.78) 46.06,28.53 45.49,27.97 45.18,27.97 42.31,25.09 42.31,17.46 41.87,17.02 41.87,15.69 40.05,13.87 39.19,13.87 38.36,13.04 38.36,12.13 36.54,10.31 36.54,8.48 36.7,8.32 36.7,7.73 v4(37.06,7.37)
MSDATA: length 31.1
  TOP w0.081: v2(35.33,6.74) RE57.1 34.75,6.52 35.35,5.91 JDEG1.7 ; v2(45.73,30.57) UE1.A41
  IN1 w0.064: v4(36.31,8.17) 36.31,7.94 35.33,6.96 v2(35.33,6.74) ; v4(46,30.19) 45.98,30.19 45.75,30.42 45.75,30.56 v2(45.73,30.57)
  IN3 w0.064: v4(36.31,8.17) 36.31,10.42 38.07,12.17 38.07,13.02 39.17,14.12 39.99,14.12 41.68,15.82 41.68,17.1 42.06,17.48 42.06,25.17 45.62,28.73 45.62,29.86 45.68,29.92 45.73,29.92 v4(46,30.19)
MUX_L_ENA_R: length 1.3
  TOP w0.081: RM36.2 16.01,73.6 16.13,73.48 UM4.16
MUX_L_ENB_R: length 3
  TOP w0.081: RM32.2 20.31,75.48 20.92,74.88 v1(20.92,74.64) 20.92,74.13 20.27,73.48 UM4.10
MUX_L_FLIP#: length 57
  TOP w0.081: RM35.1 v2(19.2,76.6) ; RM33.1 14.48,74.92 14.24,75.16 v1(13.87,75.16) 13.68,74.97 13.68,74.8 v6(13.85,74.63)
  IN1 w0.064: v4(17.61,34.46) 17.64,34.48 17.64,35.57 18.15,36.09 18.15,36.09 18.19,36.13 18.19,38.93 17.61,39.5 17.61,44.33 16.7,45.25 16.7,56.31 15.53,57.48 15.53,60.9 14.86,61.57 14.86,63.87 17.63,66.64 17.66,66.67 17.66,71.12 15.57,73.21 15.47,73.21 14.61,74.07 14.41,74.07 v6(13.85,74.63) 13.85,75.83 14.94,76.92 18.88,76.92 v2(19.2,76.6)
  IN3 w0.064: v5(16.02,33.89) 16.59,34.46 v4(17.61,34.46)
  BOTTOM w0.081: v5(16.02,33.89) RPD127.1 16.32,33.7 16.2,33.58 RPD129.1 RPD128.1
MUX_L_FLIP#_R: length 1.2
  BOTTOM w0.102: UPD1.41 16.68,33.9 RPD127.2
MUX_L_SAI: length 4.3
  TOP w0.081: UM4.14 17.92,74.64 17.67,74.89 16.98,74.89 16.75,74.67 15.56,74.67 RM33.2 15.3,75.58 v1(15.1,75.78)
MUX_L_SBI: length 1.5
  TOP w0.081: RM35.2 19.2,75.38 18.72,74.91 UM4.12
NB_LID#: length 158
  TOP w0.081: v2(44.07,37.23) 43.55,36.71 43.21,36.71 42.57,36.07 39.78,36.07 39.51,35.8 39.51,35.13 38.9,34.52 D462.1 ; v2(60.05,32.46) 58.9,31.31 58.9,30.03 61.76,27.17 61.84,27.17 61.96,27.04 v2(61.96,26.18) ; v2(40.48,47.45) v1(39.06,47.45) 38.56,46.95 32.67,46.95 30.75,48.87 29.48,48.87 28.58,49.77 28.13,49.77 26.25,51.65 24.34,51.65 v2(24.01,51.98)
  IN1 w0.064: v4(2.39,76.53) 4.54,74.38 4.54,73.77 5.26,73.05 6.21,73.05 6.83,72.43 9.64,72.43 11.21,70.86 12.53,70.86 15.53,67.86 15.53,66.44 14.55,65.46 v4(14.55,65.24) ; v2(60.05,32.46) 59.91,32.6 57.45,32.6 55.75,34.31 53.73,34.31 53.52,34.1 49.22,34.1 47.68,35.63 46.31,35.63 45.43,36.51 44.79,36.51 44.07,37.23 v2(44.07,37.23) 44.07,37.84 43.21,38.71 43.21,41.11 42.25,42.07 42.25,45.03 40.51,46.76 40.51,47.42 v2(40.48,47.45) ; v4(20.7,59.87) 20.7,59.6 20.08,58.97 20.08,56.94 21.16,55.86 21.16,54.44 21.41,54.18 21.41,52.55 21.99,51.98 v2(24.01,51.98) ; v2(61.96,26.18) 61.92,26.21 v4(60.86,26.21)
  IN2 w0.066: v4(91.47,8.66) 81,8.66 79.63,10.03 77.94,10.03 77.88,9.97 76.94,9.97 76.94,9.98 71.74,9.98 67.9,13.82 67.9,14.73 67.89,14.74 67.89,14.76 67.31,15.34 66.93,15.34 66.93,15.34 66.32,15.34 63.17,18.49 63.17,20.04 61.87,21.34 61.87,25.2 v4(60.86,26.21)
  IN3 w0.064: v5(89.86,9.81) 90.16,9.81 91,8.96 91.17,8.96 v4(91.47,8.66) ; v5(2.39,76.15) v4(2.39,76.53) ; v4(20.7,59.87) 20.7,60.19 18.28,62.61 17.04,62.61 14.55,65.1 v4(14.55,65.24)
  BOTTOM w0.081: JFP1.3 91.8,8.49 91.63,8.32 90.53,8.32 90.37,8.48 90.37,10.24 90.68,10.55 90.68,11.36 90.59,11.45 EU6.2 90.37,10.97 89.86,10.47 v5(89.86,9.81) ; v5(2.39,76.15) 2.39,75.5 2.6,75.29 R25.1
NB_MUTE#: length 2.9
  TOP w0.081: UE1.A1 41.47,19.48 40.59,18.6 40.59,17.95 RE29.1
NCT7718_DXN: length 152.2
  TOP w0.254: v6(129.96,62.04) 129.96,61.98 130.72,61.22 130.72,60.39 132.22,58.9 132.22,51.59 132.57,51.24 132.57,50.22 C30.2 132.59,50.06 132.59,49.68 132.48,49.57 U3.3
  IN2 w0.254: v6(129.96,62.04) 129.96,67.71 132.27,70.02 133.52,70.02 135.06,71.56 135.06,76.29 135.06,76.29 135.06,76.38 135.55,76.87 136.27,76.87 136.73,77.33 142.13,77.33 142.79,77.99 143.34,77.99 144.07,78.72 145.95,78.72 146.66,78.02 165.68,78.02 166.09,78.42 167.07,78.42 168.19,77.31 185.7,77.31 186.79,78.39 188.31,78.39 v4(188.35,78.44)
  IN3 w0.254: v5(198.01,32.86) 198.87,33.72 198.87,34.69 200.88,36.7 200.88,37.76 201.43,38.31 204.74,38.31 205.32,38.89 205.32,44.03 203.88,45.47 198.93,45.47 198.6,45.8 198.6,53.98 198.93,54.3 198.93,54.34 198.93,54.35 198.93,56.55 198.02,57.46 198.02,60.28 197.29,61 197.29,61 196.8,61.5 196.79,61.5 196.63,61.67 194.34,61.67 193.11,62.9 193.11,64.43 189.76,67.78 189.76,69.81 190.72,70.77 190.72,77.06 189.42,78.36 188.44,78.36 188.42,78.38 188.41,78.38 v4(188.35,78.44)
  BOTTOM w0.254: Q13.3 197.37,32.4 C29.2 198.03,32.83 v5(198.01,32.86)
NCT7718_DXP: length 155.4
  TOP w0.254: U3.2 133.13,49.37 132.97,49.53 132.97,50.05 C30.1 132.95,50.29 132.95,51.4 132.6,51.75 v7(132.6,56.29) 132.6,59.05 131.1,60.55 131.1,61.52 v6(130.55,62.07)
  IN2 w0.254: v6(130.55,62.07) 130.5,62.12 130.5,67.71 132.42,69.64 133.68,69.64 135.44,71.4 135.44,76.13 135.44,76.13 135.44,76.22 135.71,76.49 136.43,76.49 136.89,76.95 142.29,76.95 142.95,77.61 143.5,77.61 144.23,78.34 145.79,78.34 146.5,77.63 165.84,77.63 166.24,78.04 166.91,78.04 168.03,76.93 185.86,76.93 186.89,77.96 188.3,77.96 v4(188.35,77.9)
  IN3 w0.254: v5(198.03,31.81) 197.54,32.31 197.54,32.95 198.48,33.89 198.48,34.85 200.49,36.86 200.49,37.92 201.27,38.69 204.58,38.69 204.94,39.05 204.94,43.87 203.73,45.09 198.78,45.09 198.22,45.64 198.22,54.14 198.54,54.46 198.54,54.5 198.55,54.5 198.55,56.39 197.64,57.3 197.64,60.12 196.91,60.84 196.91,60.85 196.64,61.12 196.64,61.12 196.47,61.29 194.18,61.29 192.73,62.74 192.73,64.27 189.38,67.62 189.38,69.97 190.34,70.92 190.34,76.9 189.26,77.98 188.43,77.98 v4(188.35,77.9)
  BOTTOM w0.254: Q13.1 195.84,31.38 Q13.2 196.1,32.63 196.92,31.81 v5(198.03,31.81)
NGFF_CONFIG_0: length 47.5
  TOP w0.081: RE549.2 53.82,16.52 55.23,16.52 55.46,16.75 RE478.1 55.8,17.02 55.93,17.15 55.93,17.46 57.45,18.98 57.45,20.32 57.96,20.83 57.96,22.3 58.33,22.66 58.33,31.38 59.85,32.91 60.12,32.91 62.43,35.22 62.43,40.53 62.8,40.89 62.8,42.04 v1(62.7,42.13) 62.5,42.33 v2(62.5,42.5)
  IN1 w0.064: v2(62.5,42.5) 63.08,43.08 63.08,53.4 60.81,55.67 v4(60.26,55.67)
  IN3 w0.064: v5(60.26,57.08) v4(60.26,55.67)
NGFF_CONFIG_1: length 58
  TOP w0.081: UE1.A60 40.11,23.18 39.41,22.49 38.52,22.49 38.29,22.25 v2(38.29,22.17) 38.29,21.73 RE479.1
  IN1 w0.064: v2(38.29,22.17) 38.29,22.25 38.47,22.43 39.6,22.43 39.77,22.26 41.25,22.26 41.87,22.87 42.51,22.87 42.95,23.32 42.95,24.02 44.11,25.18 44.11,26.16 42.16,28.11 41.86,28.11 39.99,29.97 39.99,30.95 39.56,31.38 39.56,31.9 40.31,32.65 40.31,33.17 40.47,33.34 40.47,33.78 40.42,33.84 40.42,34.07 42.35,36 42.35,37.5 40.98,38.87 40.98,44.5 39.12,46.36 39.12,49.49 39.15,49.52 39.15,50.38 39.52,50.75 39.52,51.74 40.12,52.34 40.12,53.12 39.93,53.31 39.93,55.33 40.44,55.84 v4(40.54,55.84)
  IN3 w0.064: v4(40.54,55.84) 41.16,55.22 41.52,55.22 41.82,54.91 45.26,54.91 45.61,55.26 47.72,55.26 v5(48.28,54.7)
  BOTTOM w0.081: v5(48.28,54.7) 48.28,56.07 48.26,56.09 JNGFF1.69
NRB_BIT: length 3.8
  TOP w0.081: RC112.2 142.43,53.77 v1(141.82,53.77) v2(141.07,53.02)
  IN1 w0.064: v4(140.01,52.9) 140.95,52.9 v2(141.07,53.02)
  IN3 w0.064: v4(140.01,52.9) 140.05,52.9 140.26,53.1 v5(140.26,53.13)
  BOTTOM w0.081: UC1.CE29 140.49,53.37 v5(140.26,53.13)
NRESET_IN: length 36.9
  TOP w0.081: v2(64.72,29.87) 65.02,29.56 v1(65.02,28.32) 65.18,28.17 65.18,25.08 64.43,24.33 RE511.1 64.43,23.26 RE544.2 64.27,23.09 UE5.4 ; UE1.B2 42.48,21.3 42.57,21.39 44.56,21.39 44.76,21.6 45.19,21.6 v2(45.27,21.51)
  IN1 w0.064: v2(64.72,29.87) 64.65,29.94 60.92,29.94 59.33,28.35 58.45,28.35 56.29,26.19 55.87,26.19 54.93,25.25 54.36,25.25 54.11,25 54.11,24.98 53.4,24.26 52.32,24.26 52.25,24.32 51.37,24.32 50.78,24.91 49.94,24.91 49.75,25.1 47.13,25.1 45.53,23.49 45.53,21.76 v2(45.27,21.51)
NV_GPIO9: length 2.6
  TOP w0.081: RV93.1 99.31,66.22 99.42,66.11 100.56,66.11 v6(100.67,66.23)
  BOTTOM w0.081: v6(100.67,66.23) 101.26,66.23
NV_GPIO16: length 6.4
  BOTTOM w0.081: RV4991.1 99.68,74.53 99.68,73.86 100.22,73.32 100.22,71.39 101.86,69.75 UV1.D5
OSC_CLK: length 3
  TOP w0.081: XE1.3 32.33,21.35 32.45,21.47 34.35,21.47 RE554.2
OTGEN/CMIN_CHG: length 2.9
  BOTTOM w0.203: PRB10.1 193.19,23.43 193.43,23.67 PUB01.20
  BOTTOM w0.254: PRB13.1 192.3,22.63 192.85,23.18 PRB10.1
OVERT#: length 4.7
  BOTTOM w0.081: UV1.A6 99.79,70.47 99.79,72.52 99.15,73.17 99.15,73.76 RV69.1 RV76.1
P_SENSOR_PWR_SAVE#: length 187.8
  TOP w0.081: v6(122.17,29.4) 122.17,28.25 v3(122.14,28.22)
  IN2 w0.066: v4(32.85,69.66) 32.86,69.67 33.53,69.67 34.17,70.3 38.08,70.3 39.4,68.99 39.4,68.34 40.86,66.87 40.86,64.85 41.68,64.03 41.68,62.19 41.22,61.73 41.22,61.24 37.85,57.86 36.51,57.86 35.89,57.24 35.89,56.49 36.14,56.24 36.4,56.24 36.65,55.99 36.65,53.49 37.35,52.8 37.35,48.9 44.57,41.67 50.58,41.67 51.55,40.7 51.87,40.7 53.53,39.04 58.27,39.04 64.71,32.59 65.55,32.59 66.98,31.16 66.98,23.6 68.52,22.06 68.74,22.06 72.74,18.06 79.59,18.06 79.85,17.8 95.92,17.8 98.09,19.97 103.37,19.97 105.52,17.82 109.39,17.82 109.91,18.34 114.33,18.34 114.53,18.14 117.46,18.14 118.05,18.72 118.05,22.49 118.72,23.17 121.57,23.17 122.29,23.89 122.29,28.07 122.17,28.19 v6(122.17,29.4) 122.17,30.25 129.02,37.1 129.02,38.56 129.27,38.81 129.96,38.81 130.02,38.87 130.02,40.81 131.76,42.55 v4(132.71,42.55)
  IN3 w0.064: v4(132.71,42.55) 130.7,42.55 v5(130.68,42.53) ; v4(32.85,69.66) 31.08,69.66 30.82,69.92 30.82,70.56 30.14,71.25 29.4,71.25 28.49,72.16 23.04,72.16 21.68,70.8 v5(20.85,70.8)
  BOTTOM w0.081: v5(130.68,42.53) 130.68,42.57 RC517.2 131.08,43.17 131.23,43.32 133.67,43.32 133.99,43 134.78,43 134.94,42.84 135.05,42.84 UC1.CP12
PANEL_BKEN_EC: length 55
  TOP w0.081: UE1.B40 47.48,29.29 v2(47.78,29) ; D463.3 36.64,66.23 v2(36.92,65.95)
  IN1 w0.064: v2(47.78,29) 47.64,29.14 47.64,30.44 48.42,31.23 48.42,31.91 48.86,32.34 48.86,33.11 47.53,34.44 45.99,34.44 45.64,34.1 45.64,33.55 45.71,33.49 46.41,33.49 46.49,33.41 46.49,32.35 45.75,31.61 45.12,31.61 44.79,31.93 44.79,32.18 44.64,32.33 44.3,32.33 43.81,32.82 43.81,36.82 43.6,37.04 43.6,37.78 42.66,38.71 42.66,40.48 42.06,41.08 42.06,44.95 40.2,46.81 40.2,49.04 40.23,49.07 40.23,49.93 40.7,50.39 40.7,51.39 41.12,51.81 41.12,52.7 41.29,52.87 41.29,53.21 40.82,53.68 40.82,54.95 41.59,55.72 41.59,57.01 41.78,57.2 41.78,59.29 41.24,59.82 41.24,61.35 41.14,61.45 41.14,61.65 40.23,62.56 40.23,63.21 40.5,63.48 40.5,63.86 39.65,64.71 38.76,64.71 38.07,65.4 37.92,65.4 37.69,65.64 37.22,65.64 36.92,65.94 v2(36.92,65.95)
PANEL_MONITOR: length 88.4
  TOP w0.081: RV623.2 34.86,74.75 RV624.1 35.09,75.55 35.09,76.49 34.79,76.8 QV19.1 31.21,76.8 v2(30.67,77.34) ; UE1.B6 44.48,20.95 v2(44.4,21.03)
  IN1 w0.064: v4(44.17,21.88) 44.4,21.65 v2(44.4,21.03) ; v4(33.08,22.09) 33.11,22.09 33.11,22.27 30.93,24.45 30.93,27.06 32.75,28.89 33.59,28.89 35.03,30.33 35.03,31.68 35.5,32.15 35.5,33.17 36.14,33.8 36.66,33.8 37.65,34.8 37.65,34.91 38.04,35.29 38.27,35.29 38.57,35.6 38.57,37.36 39.36,38.15 39.36,44.48 38.03,45.81 38.03,49.75 38.2,49.92 38.2,50.77 38.57,51.14 38.57,52.89 38.98,53.3 38.98,55.87 39.71,56.61 39.71,57.06 39.61,57.16 39.61,58.51 39.11,59.01 39.11,60.89 37.9,62.1 37.9,63.23 37.38,63.75 37.23,63.75 35.86,65.13 35.86,65.53 35.38,66 35.38,68.12 35.62,68.35 35.62,69.98 35.28,70.32 34.58,70.32 33.55,71.35 33.55,71.88 33.34,72.09 32.85,72.09 32.44,72.51 32.39,72.51 31.22,72.51 30.74,72.99 30.74,72.99 30.72,73.01 30.72,77.29 v2(30.67,77.34)
  IN2 w0.066: v4(33.08,22.09) 34.46,22.09 36.09,20.46 37.88,20.46 38.22,20.12 41.45,20.12 43.43,22.1 43.95,22.1 v4(44.17,21.88)
PBAT_CHARGER_SMBCLK: length 234
  TOP w0.081: PR42.2 107.14,7.55 PD5.3 107.77,6.92 108.71,6.92 108.96,7.18 108.96,8.4 109.36,8.79 110.01,8.79 110.11,8.7 110.68,8.7 111.26,9.28 v2(111.53,9.28)
  IN1 w0.061: v4(53.31,24.98) 53.39,24.98 53.84,25.43 v2(53.88,25.43)
  IN1 w0.064: v4(53.31,24.98) 53.01,24.68 52.48,24.68 52.42,24.73 51.5,24.73 50.81,25.42 50.61,25.42 v2(50.6,25.43) ; v4(50.54,10.23) 50.82,9.95 51.58,9.95 54.59,6.94 62.67,6.94 63.8,5.81 79.95,5.81 80.39,6.24 86.29,6.24 86.66,5.87 97.55,5.87 98.62,6.93 99.38,6.93 100.44,8 104.39,8 105.12,7.26 108.65,7.26 108.79,7.39 109.95,7.39 111.49,8.93 111.49,9.24 v2(111.53,9.28) 111.49,9.32 111.49,11.3 111.69,11.5 116.52,11.5 117.11,12.09 118,12.09 120.13,14.22 125.18,14.22 125.96,15 125.96,15.58 127.16,16.78 135.17,16.78 135.37,16.58 135.37,15.94 135.57,15.75 135.57,15.74 135.77,15.55 143.79,15.55 144.59,16.35 145.55,16.35 145.75,16.14 145.75,14.36 147.46,12.65 148.16,12.65 150.2,10.61 159.08,10.61 164,5.68 165.55,5.68 165.99,6.13 169.76,6.13 170.71,5.18 206.51,5.18 207.69,6.35 207.69,10.45 207.69,10.61 207.69,10.76 207.69,10.77 207.69,16.01 201.93,21.77 196.91,21.77 194.02,24.66 192.88,24.66 192.65,24.89 v4(192.65,24.96)
  IN3 w0.064: v4(50.54,10.23) 50.54,11.88 49.99,12.43 49.99,13.41 50.83,14.24 50.83,14.95 51.65,15.78 51.74,15.78 53.34,17.38 53.34,17.89 53.37,17.92 53.37,18.85 54.81,20.29 54.81,20.8 55.37,21.35 55.37,22 55.76,22.4 55.76,23.38 55.07,24.07 55.07,24.38 54.46,24.98 v4(53.31,24.98) ; v5(191.91,24.96) v4(192.65,24.96)
PBAT_CHARGER_SMBDAT: length 239.6
  TOP w0.081: RE8.1 52.66,25.18 52.66,25.51 52.43,25.74 52.17,25.74 51.61,25.18 UE1.A25 ; v2(110.9,9.42) 110.9,9.38 110.55,9.03 110.25,9.03 110.15,9.12 109.22,9.12 108.7,8.61 108.7,7.9 PD5.2 107.91,7.79 PR37.2
  IN1 w0.061: v2(52.67,25.16) 52.64,25.13 52.19,25.13 52.18,25.14 51.98,25.14 51.55,25.57 v4(51.55,25.6)
  IN1 w0.064: v4(192.46,24.44) 192.51,24.44 192.62,24.33 193.89,24.33 196.78,21.44 196.78,21.44 201.79,21.44 207.36,15.87 207.36,10.63 207.36,10.47 207.36,10.31 207.36,9.36 207.36,6.29 206.43,5.37 170.99,5.37 169.9,6.46 165.86,6.46 165.41,6.01 163.94,6.01 159.16,10.8 150.48,10.8 148.3,12.98 147.6,12.98 146.08,14.5 146.08,16.28 145.68,16.68 144.45,16.68 143.65,15.88 135.91,15.88 135.7,16.08 135.7,16.71 135.31,17.11 127.03,17.11 125.63,15.71 125.63,15.14 125.04,14.55 119.99,14.55 117.86,12.42 116.97,12.42 116.38,11.83 111.56,11.83 111.16,11.44 111.16,9.63 110.96,9.42 110.91,9.42 v2(110.9,9.42) 110.9,8.81 109.82,7.72 108.65,7.72 108.52,7.59 105.26,7.59 104.53,8.33 100.3,8.33 99.24,7.26 98.48,7.26 97.42,6.2 86.8,6.2 86.56,6.44 80.31,6.44 79.87,6 63.88,6 62.61,7.27 54.73,7.27 50.79,11.2 48.82,11.2 48.44,11.59 43.14,11.59 v4(42.82,11.91)
  IN3 w0.064: v4(42.82,11.91) 43.44,12.53 43.44,13.57 43.6,13.72 43.6,14.02 43.76,14.18 43.76,14.95 43.61,15.09 43.61,16.14 43.72,16.25 43.72,16.53 44.1,16.91 45.07,16.91 46.76,18.6 46.76,18.82 47.66,19.73 47.66,21.71 47.39,21.99 47.39,24.66 48.01,25.28 50.49,25.28 50.81,25.6 v4(51.55,25.6) ; v5(191.92,24.19) 191.92,24.31 192.06,24.44 v4(192.46,24.44)
PBAT_PRES#: length 265.3
  TOP w0.081: v2(67.35,31.47) v1(67.35,30.38) 67.35,28.88 66.46,28 66.46,24.54 66,24.08 66,13.12 67.04,12.07 67.48,12.07 69.02,10.53 69.02,8.7 v2(68.99,8.66) ; v2(110.77,10.57) 110.77,10.63 PD6.2 109.72,10.92 PR41.1 PR39.2 ; PC1816.1 111.47,16.66 111.47,12.6 v2(111.09,12.22) ; UE1.A45 43.73,30.8 43.45,31.09 43.18,31.09 42.92,31.34 42.5,31.34 41.79,32.06 41.79,32.55 41.47,32.86 41.47,33.25 41.41,33.31 41.41,34.42 41.57,34.57 42.43,34.57 43.41,35.55 CE18.1 43.81,35.58 44.39,36.16 v2(44.73,36.16)
  IN1 w0.064: v2(67.35,31.47) 67.03,31.79 56.23,31.79 54.11,33.91 49.14,33.91 47.6,35.44 46.05,35.44 45.33,36.16 v2(44.73,36.16) ; v4(192.91,28.9) 193.25,28.56 195.69,28.56 198.35,25.9 198.35,22.97 197.74,22.36 196.73,22.36 194.17,24.92 193.23,24.92 192.82,25.32 192.5,25.32 192.1,24.92 192.1,24.21 192.28,24.03 193.82,24.03 196.67,21.18 196.68,21.18 201.68,21.18 207.1,15.76 207.1,10.52 207.1,10.52 207.1,10.36 207.1,10.2 207.1,9.47 207.1,9.47 207.1,7.25 207.1,7.25 207.1,6.88 206.15,5.93 205.77,5.56 174.46,5.56 174.09,5.93 173.96,5.93 173.74,6.16 173.73,6.16 173.66,6.23 170.64,6.23 170.16,6.72 165.75,6.72 165.3,6.27 163.95,6.27 163.69,6.53 163.69,6.53 159.24,10.99 152.35,10.99 149.41,13.93 147.11,13.93 147.1,13.94 147.1,13.94 146.37,14.67 146.37,16.36 145.75,16.98 145.06,16.98 144.39,16.98 143.63,16.22 140.83,16.22 140.31,16.74 140.01,16.74 139.95,16.8 138.96,16.8 138.39,17.37 138.29,17.37 126.92,17.37 125.1,15.56 120.63,15.56 117.75,12.68 116.86,12.68 116.28,12.09 111.21,12.09 v2(111.09,12.22) 110.77,11.9 v2(110.77,10.57) 110.77,10.36 110.01,9.6 108.59,8.17 108.46,8.17 108.33,8.04 105.5,8.04 104.56,8.98 100.21,8.98 99.9,9.28 97.72,9.28 95.08,6.65 86.99,6.65 86.54,7.1 84.86,7.1 84.45,7.51 82.67,7.51 82.11,8.06 77.26,8.06 77.08,7.89 75.47,7.89 75.43,7.84 71.28,7.84 70.46,8.66 v2(68.99,8.66)
  IN3 w0.064: v5(192.33,28.6) 192.61,28.6 v4(192.91,28.9)
PCH_BATLOW#: length 1.8
  TOP w0.081: v2(143.9,58.05) RC96.1
  IN1 w0.064: v2(143.9,58.05) 143.9,58.21 143.79,58.32 v4(143.71,58.32)
  IN3 w0.064: v4(143.71,58.32) 143.74,58.35 144.18,58.35 v5(144.41,58.12)
  BOTTOM w0.081: v5(144.41,58.12) 144.37,58.08 UC1.BV36
PCH_JTAG_TCK: length 0.9
  IN1 w0.064: v4(169.3,39.03) 169.48,38.85 v2(169.81,38.85)
  IN3 w0.064: v5(168.96,39.03) v4(169.3,39.03)
PCH_PCIE_WAKE#: length 22.8
  TOP w0.081: RC92.2 144.73,53.73 v2(144.73,53.79)
  IN1 w0.064: v4(127.26,50.78) 127.73,50.31 132.43,50.31 133.27,51.15 134.57,51.15 135.14,51.72 135.61,51.72 135.67,51.65 137.16,51.65 137.24,51.73 137.52,51.73 137.84,52.05 139.27,52.05 139.27,52.06 139.54,52.06 139.95,52.47 140.47,52.47 140.68,52.68 141.11,52.68 141.84,53.41 143.14,53.41 143.32,53.59 143.32,53.59 143.35,53.62 143.89,53.62 144.09,53.82 v4(144.39,53.82) 144.7,53.82 v2(144.73,53.79)
  IN3 w0.064: v5(144.74,54.01) 144.71,54.01 144.51,53.82 v4(144.39,53.82)
  IN3 w0.089: v5(127.75,50.73) 127.3,50.73 v4(127.26,50.78)
  BOTTOM w0.081: RC102.2 127.74,50.75 v5(127.75,50.73) 127.39,50.73 126.96,50.31 v1(126.47,50.31) ; v5(144.74,54.01) 144.88,54.01 144.89,54.02 UC1.BU30
PCH_PLTRST#: length 23.9
  TOP w0.081: UC4.1 UC4.2 137.77,66.83 137.66,66.72 v1(137.66,66.26) 137.66,64.59 v6(137.12,64.05)
  BOTTOM w0.081: UC1.BJ35 150.05,57.18 150.38,57.51 150.38,57.73 150.36,57.76 150.36,58.13 150.38,58.15 150.38,58.92 150.93,59.47 150.93,61.49 148.76,63.66 138.07,63.66 137.68,64.05 v6(137.12,64.05)
PCH_POPIRCOMP: length 2.9
  TOP w0.305: v1(143.97,50.54) 143.48,50.04 v2(143.48,49.58)
  IN1 w0.305: v2(143.48,49.58) 143.48,49.98 v4(143.55,50.05)
  IN3 w0.305: v4(143.55,50.05) 143.55,50.61 v5(143.68,50.74)
  BOTTOM w0.305: v5(143.68,50.74) 143.68,50.76 143.91,51 UC1.BW25
PCH_PWROK: length 32.2
  TOP w0.081: v2(128.52,50.75) v3(128.52,51.27)
  IN1 w0.064: v4(121.17,54.97) 121.26,54.97 122.9,53.32 124.31,53.32 125.94,51.69 126.98,51.69 127.91,50.75 v2(128.52,50.75) 132.24,50.75 133.08,51.59 134.38,51.59 134.95,52.16 135.22,52.16 135.46,52.41 136.74,52.41 137.01,52.67 137.54,52.67 137.71,52.5 139.08,52.5 139.89,53.3 140.72,53.3 140.92,53.5 141.48,53.5 141.67,53.69 143.15,53.69 143.31,53.85 143.57,53.85 144.09,54.37 144.95,54.37 145.03,54.45 145.71,54.45 145.93,54.67 v4(146.58,54.67)
  IN3 w0.064: v4(121.17,54.97) 121.11,55.02 120.67,55.02 v5(120.59,54.94) ; v4(146.58,54.67) v5(146.92,54.67)
  BOTTOM w0.081: v5(120.59,54.94) RC381.1 120.68,55.58 121.28,56.18 UC10.4
PCH_RSMRST#: length 6.4
  TOP w0.081: v1(50.15,35.21) 50.13,35.18 50.13,33.99 49.8,33.66 RE537.1 49.78,33.37 v2(49.36,32.95)
  IN1 w0.064: v2(49.36,32.95) 49.36,32.57 48.61,31.83 48.61,29.66 v2(48.48,29.53)
PCH_RSMRST#_Q: length 36
  IN2 w0.066: v4(146.52,54.02) 146.2,54.34 143.67,54.34 143.42,54.08 142.4,54.08 141.91,54.57 141.49,54.57 141.3,54.38 140.81,54.38 140.51,54.69 139.19,54.69 139.05,54.83 138.87,54.83 138.86,54.83 136.19,54.83 136.19,54.83 136.17,54.83 135.65,54.3 134.44,54.3 133.91,53.78 133.91,53.16 133.51,52.76 132.9,52.76 132.43,52.29 132.43,51.81 129.23,48.6 128.29,48.6 127.33,49.57 126.09,49.57 v4(126.07,49.58)
  IN3 w0.064: v4(146.52,54.02) v5(146.92,54.02)
  IN3 w0.089: v4(126.07,49.58) 125.64,49.58 v5(125.62,49.56)
  BOTTOM w0.081: UC5.4 122.8,52.96 123.36,52.96 123.91,52.4 123.91,51.42 RC75.2 123.83,50.83 125.09,49.56 v5(125.62,49.56) 125.98,49.19 v1(125.98,48.82) ; v5(146.92,54.02) 146.44,54.5 146.44,56.02 146.57,56.15 146.57,56.5 146.52,56.56 146.52,57.38 UC1.BR36
PCH_RSMRST#_R: length 148.9
  TOP w0.081: v6(52.83,18.24) 53,18.41 54.53,18.41 54.71,18.23 55.71,18.23 57.02,19.54 57.02,20.5 57.54,21.02 57.54,22.47 57.9,22.83 57.9,29.63 57.43,30.1 56.53,30.1 55.82,29.39 ; v6(70.62,40.4) 70.47,40.25 70.47,37.71 68.03,35.26 v2(68.03,34.6) ; v2(49.72,35.1) 49.78,35.04 RE537.2 ; 55.82,29.39 55.48,29.73 55.48,30.23 56.34,31.09 v1(56.34,32.65) 56.5,32.81 56.5,34.1 v2(55.33,35.26) ; 55.82,29.39 56.16,29.05 56.16,28.2 56.2,28.15 56.2,28.1 56.29,28.01 56.29,26.94 RE26.1 55.62,25.68 RE536.1
  IN1 w0.064: v2(68.03,34.6) 57.14,34.6 56.35,35.39 55.46,35.39 v2(55.33,35.26) 55.33,35.52 55.27,35.58 50.21,35.58 v2(49.72,35.1) ; v4(100.9,33.71) 100.86,33.75 100.86,34.96 104.32,38.42 106.26,38.42 106.72,38.88 v4(108.22,38.88) ; v2(35.45,14) v4(35.45,14.34)
  IN2 w0.066: v6(52.83,18.24) 52.83,18.01 53.59,17.26 53.59,14.43 53.07,13.91 49.29,13.91 48.56,13.18 42.72,13.18 41.11,14.78 35.9,14.78 v4(35.45,14.34)
  IN3 w0.064: v5(121.31,52.45) 121.19,52.57 119.99,52.57 119.54,52.13 118.34,52.13 118.01,51.79 116.33,51.79 115.5,50.97 114.79,50.97 111.8,47.98 111.8,47.27 110.63,46.1 110.63,44.22 109.82,43.41 109.82,42.81 108.8,41.79 108.8,40 108.22,39.42 v4(108.22,38.88) ; v6(70.62,40.4) 70.62,40.92 71,41.3 73.48,41.3 73.88,41.7 74.83,41.7 75.29,41.24 77.35,41.24 78.42,40.18 78.42,38.92 84.09,33.25 99.57,33.25 100,33.67 100.86,33.67 v4(100.9,33.71)
  BOTTOM w0.081: UC5.1 121.31,52.07 v5(121.31,52.45)
PCH_RTCRST#: length 83.1
  TOP w0.081: JAPS1.9 129.95,72.24 130.23,71.96 130.23,71.15 129.86,70.78 v3(128.87,70.78) 128.34,70.78 v2(127.89,70.33)
  IN1 w0.064: v4(146.14,55.89) 146.04,55.79 144.79,55.79 144.28,56.3 144.28,56.3 144.11,56.47 144.11,56.47 143.26,57.32 142.97,57.32 142.77,57.51 142.2,57.51 141.46,58.25 141.31,58.25 141.22,58.16 139.84,58.16 139.52,57.85 137.98,57.85 137.98,57.85 137.68,57.85 137.68,57.85 137.6,57.85 136.88,57.12 132.81,57.12 130.89,59.04 130.89,61.25 131.03,61.4 131.03,62.28 130.13,63.18 130.13,64.17 129.81,64.49 129.81,68 129.81,68 129.81,68.52 128,70.33 v2(127.89,70.33)
  IN2 w0.066: v4(126.76,55.03) 126.25,55.03 125.77,55.51 123.38,55.51 121.12,57.77 121.12,62.11 122.8,63.79 127.69,63.79 128.57,62.91 128.57,62.03 129.42,61.18 129.45,61.18 129.48,61.15 131.78,61.15 131.89,61.26 132.23,61.26 132.53,60.97 134.06,60.97 134.48,61.39 137.03,61.39 137.35,61.06 137.57,61.06 137.75,60.89 138.05,60.89 138.64,60.3 139.05,60.3 139.16,60.41 144.07,60.41 146.14,58.34 v4(146.14,55.89)
  IN3 w0.064: v4(146.14,55.89) 146.23,55.99 v5(146.23,56.36) ; v4(126.76,55.03) 127.03,54.76 v5(127.08,54.76)
  BOTTOM w0.081: v5(127.08,54.76) 127.21,54.62 127.21,52.93 RC82.2 126.16,52.03 126,51.87 CC8.1 125.27,51.87 125.25,51.89 CLRP2.1
PCH_RTCX1: length 24
  IN1 w0.064: v4(146.83,55.48) 146.6,55.95 146.5,56.04 146.29,56.26 146.24,56.26 145.74,56.35 144.55,56.35 143.58,57.32 143.58,57.51 142.52,58.58 142.31,58.58 141.73,59.16 140.86,59.49 138.8,59.49 138.63,59.32 132.76,59.32 132.62,59.37 132.3,59.5 v4(132.28,59.51)
  IN3 w0.064: v4(146.83,55.48) 146.84,55.47 146.84,55.41 146.91,55.34 146.91,55.28 147.52,54.67 v5(147.84,54.67) ; v4(132.28,59.51) 132.31,59.4 131.64,58.25 131.64,56.57 v5(131.57,56.25)
  BOTTOM w0.081: YC2.1 130.37,55.6 130.51,55.46 131.1,55.46 RC95.1 CC11.1 131.39,56.08 v5(131.57,56.25)
PCH_RTCX2: length 25.1
  IN1 w0.064: v4(147.27,55.8) 146.52,56.39 145.87,56.58 144.84,56.58 144.48,56.77 144.28,56.93 144.19,57.05 144.14,57.16 143.98,57.44 143.82,57.65 143.36,58.12 143.31,58.22 143.05,58.64 142.05,59.65 140.95,60.07 139.72,60.07 139.05,59.81 132.89,59.81 v4(132.78,59.7)
  IN3 w0.064: v4(147.27,55.8) 147.76,55.32 v5(147.84,55.32) ; v5(131.78,55.47) 131.84,55.49 132.25,56.26 132.25,57.74 132.51,58.64 132.52,58.65 132.76,59.68 v4(132.78,59.7)
  BOTTOM w0.081: v5(131.78,55.47) 131.17,54.86 RC95.2 CC12.1 130.71,54.17 YC2.2
PCH_SRTCRST#: length 3.1
  BOTTOM w0.081: UC1.BR37 146.23,58.72 144.98,59.97 144.98,60.16 CC7.1 144.56,60.26 144.53,60.29 RC77.2
PCH_SUSCLK: length 8.9
  TOP w0.081: RE554.1 35.43,21.47 v2(35.87,21.47) ; UE1.A62 40.14,22.18 v2(39.88,21.92) 39.46,21.5 RE533.1
  IN1 w0.064: v4(39.46,21.18) 39.46,21.19 39.46,21.68 39.7,21.92 v2(39.88,21.92) ; v4(35.92,21.14) 35.87,21.2 v2(35.87,21.47)
  IN3 w0.064: v4(35.92,21.14) 35.92,22 36.22,22.3 36.72,22.3 37.33,21.69 37.76,21.69 38.09,22.02 38.62,22.02 v4(39.46,21.18)
PCH_TBT_PERST#: length 157.5
  TOP w0.081: RT284.1 31.63,62.19 v2(31.83,61.99) 31.9,61.91 31.9,60.92 v1(32.47,60.35)
  IN1 w0.064: v2(31.83,61.99) 32.2,61.61 v4(34.03,61.61)
  IN2 w0.066: v4(128.06,39.53) 128.06,39 128.74,38.32 128.74,37.1 121.69,30.05 121.69,27.78 121.96,27.51 121.96,23.92 121.47,23.43 118.63,23.43 117.75,22.55 117.75,18.72 117.47,18.43 114.68,18.43 114.52,18.59 109.79,18.59 109.27,18.07 105.54,18.07 103.36,20.26 98.06,20.26 95.8,17.99 80.07,17.99 79.25,18.82 74.62,18.82 74.43,19.01 72.06,19.01 69.21,21.86 68.82,22.25 68.61,22.25 67.17,23.69 67.17,31.4 65.75,32.81 64.77,32.81 58.21,39.37 55.4,39.37 52.23,42.54 51.74,42.54 51.32,42.11 51.02,42.11 50.8,42.33 50.8,42.33 50.68,42.46 45.03,42.46 37.73,49.75 37.73,52.96 37.05,53.64 37.05,56.64 36.55,57.14 v4(36.3,57.14)
  IN3 w0.064: v4(36.3,57.14) 36.4,57.24 36.4,57.37 36.59,57.56 36.59,58.43 34.79,60.24 34.79,60.84 34.03,61.59 v4(34.03,61.61) ; v4(128.06,39.53) 127.97,39.53 127.64,39.86 v5(127.64,39.88)
  BOTTOM w0.081: v5(127.64,39.88) 127.64,39.91 127.62,39.93 127.62,40.06 127.63,40.07 127.63,42.26 128.8,43.42 RC574.2 129.88,43.42 RC395.2 130.14,43.9 130.27,44.03 131.15,44.03 131.43,44.31 132.73,44.31 133.03,44.01 133.92,44.01 134.1,43.83 UC1.CR14
PCIE_CRX_C_DTX_N13: length 4.6
  BOTTOM w0.091: UT1.V22 21.52,53.31 21.05,53.31 19.52,51.78 18.08,51.78 CT7.2
PCIE_CRX_C_DTX_N14: length 4.5
  BOTTOM w0.091: CT9.2 18.12,54.05 19.63,54.05 20.83,55.25 20.98,55.25 21.09,55.15 21.51,55.15 UT1.P22
PCIE_CRX_C_DTX_N15: length 4.4
  BOTTOM w0.091: CT357.2 18.1,56.49 18.12,56.49 18.12,56.49 19.69,56.49 20.48,57.28 20.48,57.28 20.6,57.4 20.66,57.4 20.89,57.4 20.89,57.4 21.02,57.4 21.08,57.46 21.5,57.46 UT1.K22
PCIE_CRX_C_DTX_N16: length 4.2
  BOTTOM w0.091: UT1.F22 21.52,59.28 21.09,59.28 20.96,59.16 20.69,59.16 20.69,59.16 19.46,59.16 19,58.7 18.13,58.7 CT358.2
PCIE_CRX_C_DTX_P13: length 4.6
  BOTTOM w0.091: UT1.V23 21.34,53.54 21.37,53.58 21.37,53.67 21.28,53.77 21.06,53.77 20.97,53.67 20.97,53.52 20.85,53.4 20.85,53.39 19.44,51.98 18.15,51.98 CT6.2
PCIE_CRX_C_DTX_P14: length 4.4
  BOTTOM w0.091: UT1.P23 21.39,55.38 21.44,55.43 21.44,55.54 21.39,55.6 21.11,55.6 20.97,55.46 20.76,55.46 19.55,54.25 18.11,54.25 CT8.2
PCIE_CRX_C_DTX_P15: length 4.4
  BOTTOM w0.091: CT359.2 18.12,56.29 19.77,56.29 20.68,57.2 20.89,57.2 21.08,57 21.38,57 21.47,57.09 21.47,57.16 21.41,57.22 UT1.K23
PCIE_CRX_C_DTX_P16: length 4.2
  BOTTOM w0.091: UT1.F23 21.41,59.06 21.48,58.99 21.48,58.89 21.43,58.84 21.06,58.84 20.94,58.96 20.61,58.96 20.6,58.96 19.55,58.96 19.08,58.5 18.1,58.5 CT360.2
PCIE_CRX_DTX_N1: length 112.6
  TOP w0.091: RN115.1 55.4,57.94 55.1,58.23 55.1,58.4 v6(55.28,58.58)
  IN3 w0.079: v5(142.17,38.38) 142.23,38.45 142.23,38.64 142.15,38.73 141.76,38.73 141.51,38.98 141.51,40.01 140.55,40.97 139.94,40.97 139.74,40.77 137.32,40.77 137.05,40.5 135.51,40.5 133.12,38.12 132.43,38.12 132.26,37.95 131.3,37.95 131,38.25 128,38.25 127.89,38.36 127.56,38.36 127.45,38.25 123.85,38.25 123.54,38.57 121.28,38.57 121.17,38.46 120.69,38.46 113.62,31.39 112.88,31.39 112.04,30.54 101.53,30.54 100.07,32 83.52,32 76.01,39.51 75.09,39.51 74.78,39.83 73.56,39.83 73.16,39.43 69.94,39.43 64.66,44.72 64.66,49.79 64.35,50.1 64.35,51.27 60.8,54.82 60.8,57.13 60.07,57.87 56.58,57.87 55.43,59.02 55.21,59.02 55.1,58.92 55.1,58.8 55.11,58.8 55.11,58.76 v6(55.28,58.58)
PCIE_CRX_DTX_N9: length 50.9
  IN3 w0.079: v5(146.79,38.38) 146.65,38.52 146.57,38.6 146.22,38.6 145.58,37.96 145.58,37.66 145.67,37.57 145.67,37.49 145.66,37.49 145.66,36.96 145.27,36.56 144.22,36.56 142.44,34.78 142.44,34.52 140.97,33.05 140.52,33.05 139.45,34.12 139.45,34.24 139.23,34.46 139.11,34.46 138.37,35.2 133.64,35.2 133.47,35.03 130.07,35.03 129.86,34.83 128.12,34.83 128.08,34.87 127.75,34.87 127.71,34.83 125.85,34.83 124.12,33.1 122.86,33.1 122.64,33.1 122.64,33.1 122.19,33.1 121.24,32.15 120.44,32.15 118.12,29.83 118.12,24.28 116.72,22.88 116.55,22.88 115.4,21.73 115.2,21.73 v5(115.1,21.62)
  BOTTOM w0.091: v5(115.1,21.62) 115.18,21.71 115.25,21.71 115.41,21.71 115.54,21.58 115.54,19.99 115.82,19.71 115.82,18.22 116.37,17.68 116.74,17.68 116.89,17.52 JSSD1.5
PCIE_CRX_DTX_N10: length 50
  IN3 w0.079: v5(147.71,39.03) 147.62,38.94 147.43,38.94 147.22,38.73 147.22,37.98 147.54,37.65 147.54,37.14 147.54,37.14 147.54,36.84 147.54,36.83 147.54,36.36 146.39,35.21 145.44,35.21 145.05,34.81 145.05,30.84 143.13,28.92 141.04,28.92 139.1,26.98 131.89,26.98 130.96,26.06 130.65,25.75 130.55,25.71 129.42,25.24 129.35,25.21 129.17,25.03 127.27,25.03 126.64,24.41 126.64,23.06 125.81,22.22 124.27,22.22 123.64,22.85 121.58,22.85 121.22,22.49 121.22,21.68 121.05,21.5 120.37,21.5 119.74,22.14 119.74,23.11 119.49,23.36 119.49,23.36 119.24,23.61 118.11,23.61 116.84,22.34 116.68,22.34 115.8,21.46 115.8,20.93 116.06,20.67 116.24,20.67 v5(116.33,20.59)
  BOTTOM w0.091: v5(116.33,20.59) 116.47,20.73 116.76,20.73 116.96,20.52 JSSD1.17
PCIE_CRX_DTX_N11: length 49.8
  IN3 w0.079: v5(147.71,41.25) 147.54,41.07 147.46,41.07 147.38,41.15 147.38,41.84 147.03,42.19 145.61,42.19 145.29,41.88 143.41,41.88 142.86,41.32 142.86,39.97 143.89,38.93 143.89,38.51 143.78,38.4 143.78,37.27 141.81,35.3 141.49,35.3 141.28,35.51 139.21,35.51 138.63,36.1 134.12,36.1 134.01,35.98 133.31,35.98 133.15,35.81 130.41,35.81 130.12,36.11 129.06,36.11 128.77,35.82 128.38,35.82 128.22,35.66 125.58,35.66 123.86,33.95 122.64,33.95 121.93,33.95 121.92,33.95 121.12,33.95 117.26,30.08 117.26,25.72 115.91,24.38 115.91,23.84 116.1,23.65 116.41,23.65 v5(116.5,23.56)
  BOTTOM w0.091: v5(116.5,23.56) 116.59,23.65 116.79,23.65 116.91,23.52 JSSD1.29
PCIE_CRX_DTX_N12: length 50.9
  IN3 w0.079: v5(122.59,21.66) 122.53,21.59 122.53,21.49 122.68,21.35 123.22,21.35 123.39,21.17 123.46,21.17 123.9,20.74 127.42,20.74 128.16,21.47 131.07,21.47 132.32,20.23 136.72,20.23 139.51,23.02 139.51,25.72 141.04,27.25 143.99,27.25 144.31,27.58 144.31,28.44 146.67,30.8 146.67,33.67 146.9,33.9 146.9,34.87 148.44,36.41 148.44,37.62 148.14,37.92 148.14,38.54 148.33,38.73 148.49,38.73 148.54,38.73 148.64,38.83 v5(148.64,39.03)
  BOTTOM w0.091: v5(122.59,21.66) 122.59,21.86 122.53,21.92 122.53,25.72 121.22,27.03 JSSD1.43
PCIE_CRX_DTX_N13: length 182.6
  IN3 w0.079: v5(17.35,51.63) 17.37,51.66 17.37,51.82 17.3,51.89 17.24,51.89 17.23,51.9 17.06,51.9 16.94,51.78 16.94,49.87 17.95,48.86 20.68,48.86 21.68,47.86 38.24,47.86 39.13,46.96 43.43,46.96 45.53,44.87 53.22,44.87 56.11,41.99 57.26,41.99 57.61,41.63 58.49,41.63 64.78,35.34 65.34,35.34 70.38,30.3 70.76,30.3 70.87,30.19 75.39,30.19 76.54,29.04 76.54,23.95 81.44,19.05 87.37,19.05 87.63,18.79 93.37,18.79 93.6,19.02 94.64,19.02 95.21,18.44 98.98,18.44 100.74,16.69 108.39,16.69 108.98,16.11 110.56,16.11 111.38,16.92 112.67,16.92 114.08,15.51 121.95,15.51 122.05,15.62 122.55,15.62 123.21,14.95 127.87,14.95 127.97,15.05 129.06,15.05 129.78,14.33 132.66,14.33 132.96,14.63 133.01,14.63 133.52,15.14 134.48,15.14 134.57,15.05 137.18,15.05 137.33,15.19 137.82,15.19 138.31,15.19 138.4,15.1 143.7,15.1 143.81,15.21 143.81,15.46 144.14,15.79 144.62,15.79 144.88,15.53 145.7,15.53 146.63,16.45 148.71,16.45 151.17,18.9 152.27,18.9 152.98,19.61 152.98,34.08 153.02,34.13 153.02,35.72 152.33,36.42 151.55,36.42 151.5,36.47 150.68,36.47 149.06,38.08 149.06,38.47 149.21,38.61 149.21,38.62 149.26,38.68 149.59,38.68 149.67,38.76 149.67,38.92 v5(149.56,39.03)
PCIE_CRX_DTX_N14: length 186.2
  IN3 w0.079: v5(150.48,39.03) 150.58,38.94 150.58,38.76 150.49,38.68 150.18,38.68 149.98,38.47 149.98,38.31 149.97,38.31 149.97,38.16 150.87,37.26 152.33,37.26 153.61,35.98 153.61,33.05 153.56,33 153.56,19.34 152.51,18.29 151.4,18.29 148.97,15.86 146.91,15.86 146.55,15.5 146.55,14.86 146.21,14.52 138.16,14.52 138.07,14.61 137.57,14.61 137.43,14.46 134.33,14.46 134.23,14.55 133.76,14.55 133.25,14.05 133.2,14.05 132.52,13.36 129.92,13.36 128.81,14.46 128.21,14.46 128.12,14.37 122.17,14.37 121.69,14.85 120.7,14.85 120.69,14.85 109.37,14.85 108.12,16.1 100.49,16.1 98.88,17.71 91.69,17.71 91.53,17.87 91.45,17.87 91.44,17.87 87.5,17.87 86.91,18.46 81.19,18.46 75.96,23.69 75.96,28.53 74.99,29.5 70.36,29.5 65.1,34.76 64.53,34.76 58.82,40.48 56.73,40.48 52.92,44.29 45.28,44.29 43.19,46.38 38.71,46.38 37.82,47.27 21.32,47.27 20.34,48.26 17.43,48.26 16.32,49.37 16.32,53.45 17.02,54.16 17.21,54.16 17.35,54.02 v5(17.35,53.87)
PCIE_CRX_DTX_N15: length 195.8
  IN3 w0.079: v5(17.35,56.66) 17.23,56.54 17,56.54 15.5,55.04 15.5,46.28 16.75,45.03 19.21,45.03 20.45,46.27 23.44,46.27 23.72,45.99 25.54,45.99 26.04,46.49 37.39,46.49 38.29,45.6 42.87,45.6 44.96,43.5 52.53,43.5 56.38,39.65 58.53,39.65 64.21,33.97 64.77,33.97 67.16,31.59 67.16,30.92 67.5,30.59 68.16,30.59 70.03,28.72 70.05,28.72 70.23,28.54 74.82,28.54 75.17,28.18 75.17,23.33 80.83,17.67 86.41,17.67 87.05,17.03 91.07,17.03 91.31,16.79 98.66,16.79 100.17,15.28 107.61,15.28 108.88,14.01 119.99,14.01 120.42,13.59 125.4,13.59 125.56,13.43 127.72,13.43 128.57,12.58 132.84,12.58 133.53,13.26 135.66,13.26 136.34,12.58 145.98,12.58 146.35,12.72 147.66,14.03 149.39,14.03 150.01,14.65 150.01,15.78 151.72,17.49 152.85,17.49 154.92,19.57 154.92,24.92 154.47,25.38 154.47,36.06 154.5,36.08 154.5,37.41 154.05,37.86 153.26,37.86 153.07,38.05 151.31,38.05 151.1,38.26 151.1,38.43 151.2,38.52 151.27,38.52 v5(151.41,38.38)
PCIE_CRX_DTX_N16: length 198.6
  IN3 w0.079: v5(17.35,58.9) 17.35,58.82 17.46,58.71 17.68,58.71 17.87,58.52 17.87,58.02 15.09,55.24 15.09,46.13 16.62,44.6 19.98,44.6 21.27,45.89 23.25,45.89 23.58,45.56 25.9,45.56 26.45,46.1 37.21,46.1 38.1,45.21 42.71,45.21 44.8,43.12 52.23,43.12 56.1,39.26 58.36,39.26 64.11,33.5 64.62,33.5 66.74,31.39 66.74,30.51 69.19,28.06 74.43,28.06 74.79,27.7 74.79,23.15 80.65,17.28 83.42,17.28 83.43,17.29 86.26,17.29 86.89,16.65 87.48,16.65 87.5,16.63 87.58,16.63 88.95,16.63 89.36,16.22 98.66,16.22 100.03,14.85 107.38,14.85 108.61,13.62 119.31,13.62 119.94,12.98 127.62,12.98 128.41,12.19 146.05,12.19 149.42,13.48 150.44,14.5 150.44,15.62 151.85,17.02 152.98,17.02 155.31,19.34 155.31,25.11 154.85,25.56 154.85,35.52 154.89,35.56 154.89,37.57 154.17,38.29 153.84,38.29 153.43,38.7 152.21,38.7 152.13,38.62 152.13,38.46 152.21,38.38 v5(152.33,38.38)
PCIE_CRX_DTX_P1: length 112.6
  TOP w0.091: RN116.1 54.61,57.91 54.9,58.2 54.9,58.38 v6(54.7,58.58)
  IN3 w0.079: v6(54.7,58.58) 54.9,58.78 54.9,59 55.12,59.22 55.51,59.22 56.67,58.07 60.15,58.07 61,57.21 61,54.9 64.55,51.36 64.55,50.18 64.86,49.88 64.86,44.8 70.03,39.63 73.08,39.63 73.48,40.03 74.86,40.03 75.18,39.71 76.1,39.71 83.61,32.2 100.15,32.2 101.62,30.74 111.95,30.74 112.8,31.59 113.53,31.59 120.6,38.66 121.09,38.66 121.2,38.77 123.62,38.77 123.94,38.46 127.37,38.46 127.48,38.57 127.97,38.57 128.08,38.46 131.08,38.46 131.38,38.15 132.18,38.15 132.34,38.32 133.04,38.32 135.42,40.7 136.97,40.7 137.24,40.97 139.66,40.97 139.85,41.17 140.64,41.17 141.72,40.09 141.72,39.06 141.85,38.93 142.07,38.93 v5(142.17,39.03)
PCIE_CRX_DTX_P9: length 50.9
  IN3 w0.079: v5(115.1,22.01) 115.18,21.93 115.31,21.93 116.47,23.09 116.64,23.09 117.92,24.36 117.92,29.91 120.35,32.35 121.15,32.35 122.11,33.3 122.64,33.3 124.04,33.3 125.77,35.03 127.62,35.03 127.67,35.07 128.16,35.07 128.21,35.03 129.78,35.03 129.99,35.23 133.39,35.23 133.55,35.4 138.46,35.4 139.19,34.66 139.31,34.66 139.65,34.33 139.65,34.2 140.6,33.25 140.88,33.25 142.24,34.61 142.24,34.87 144.14,36.76 145.18,36.76 145.46,37.04 145.46,37.49 145.38,37.57 145.38,38.04 146.14,38.8 146.56,38.8 v5(146.79,39.03)
  BOTTOM w0.091: JSSD1.7 116.88,18.03 116.73,17.88 116.45,17.88 116.02,18.31 116.02,19.8 115.74,20.08 115.74,21.66 115.49,21.91 115.26,21.91 115.19,21.91 v5(115.1,22.01)
PCIE_CRX_DTX_P10: length 50
  IN3 w0.079: v5(116.32,21.04) 116.32,20.94 116.26,20.87 116.14,20.87 116,21.01 116,21.38 116.76,22.14 116.93,22.14 118.2,23.41 119.16,23.41 119.54,23.03 119.54,22.05 120.29,21.3 121.13,21.3 121.42,21.59 121.42,22.41 121.67,22.65 123.55,22.65 124.18,22.02 125.89,22.02 126.85,22.98 126.85,24.33 127.35,24.83 129.26,24.83 129.46,25.04 129.5,25.06 130.62,25.52 130.77,25.58 131.05,25.86 131.97,26.78 139.19,26.78 141.12,28.72 143.21,28.72 145.25,30.76 145.25,34.73 145.53,35.01 146.48,35.01 147.74,36.27 147.74,36.38 147.89,36.53 147.89,36.69 147.74,36.84 147.74,37.06 147.92,37.23 147.92,37.34 147.74,37.51 147.74,37.58 147.74,37.58 147.74,37.74 147.42,38.06 147.42,38.65 147.51,38.74 147.66,38.74 147.75,38.65 147.75,38.42 v5(147.71,38.38)
  BOTTOM w0.091: v5(116.32,21.04) 116.43,20.93 116.84,20.93 116.94,21.03 JSSD1.19
PCIE_CRX_DTX_P11: length 49.8
  IN3 w0.079: v5(116.5,23.94) 116.41,23.85 116.19,23.85 116.11,23.92 116.11,24.3 117.46,25.64 117.46,29.99 121.21,33.75 122.01,33.75 122.01,33.75 122.64,33.75 123.94,33.74 125.66,35.46 128.3,35.46 128.46,35.62 128.86,35.62 129.14,35.9 130.04,35.9 130.33,35.61 133.23,35.61 133.4,35.78 134.09,35.78 134.2,35.89 138.54,35.89 139.13,35.31 141.2,35.31 141.41,35.1 141.89,35.1 143.98,37.19 143.98,38.32 144.09,38.43 144.09,38.93 144.09,38.93 144.09,39.01 143.06,40.05 143.06,41.24 143.5,41.68 145.38,41.68 145.69,41.99 146.95,41.99 147.18,41.76 147.18,41.06 147.31,40.93 147.31,40.93 147.37,40.87 147.76,40.87 147.85,40.78 147.85,40.47 v5(147.71,40.33)
  BOTTOM w0.091: v5(116.5,23.94) 116.59,23.85 116.76,23.85 116.93,24.03 JSSD1.31
PCIE_CRX_DTX_P12: length 50.9
  IN3 w0.079: v5(148.64,38.38) 148.49,38.53 148.42,38.53 148.34,38.45 148.34,38.01 148.64,37.71 148.64,36.33 147.1,34.79 147.1,33.82 146.87,33.59 146.87,30.72 144.51,28.36 144.51,27.49 144.07,27.05 141.13,27.05 139.71,25.64 139.71,22.94 136.8,20.03 132.23,20.03 130.99,21.27 128.24,21.27 127.51,20.54 123.81,20.54 123.38,20.97 123.31,20.97 123.14,21.15 122.59,21.15 122.46,21.28 122.46,21.28 122.31,21.43 122.31,21.58 v5(122.21,21.68)
  BOTTOM w0.091: JSSD1.41 118.4,26.52 118.5,26.63 118.5,26.73 118.6,26.82 121.14,26.82 122.33,25.63 122.33,21.93 122.21,21.82 v5(122.21,21.68)
PCIE_CRX_DTX_P13: length 182.6
  IN3 w0.079: v5(149.56,38.38) 149.47,38.47 149.35,38.47 149.26,38.39 149.26,38.17 150.76,36.67 151.59,36.67 151.64,36.62 152.41,36.62 153.22,35.8 153.22,34.04 153.18,34 153.18,19.52 152.35,18.7 151.25,18.7 148.8,16.25 146.71,16.25 145.79,15.32 144.8,15.32 144.53,15.59 144.23,15.59 144.01,15.37 144.01,15.13 143.78,14.9 138.32,14.9 138.23,14.99 137.91,14.99 137.41,14.99 137.27,14.85 134.49,14.85 134.39,14.94 133.6,14.94 133.09,14.43 133.04,14.43 132.74,14.12 129.69,14.12 128.97,14.85 128.05,14.85 127.96,14.75 123.13,14.75 122.46,15.42 122.14,15.42 122.03,15.31 114,15.31 112.59,16.72 111.46,16.72 110.65,15.9 108.9,15.9 108.31,16.49 100.65,16.49 98.9,18.24 95.13,18.24 94.56,18.81 93.68,18.81 93.45,18.58 87.55,18.58 87.29,18.85 81.36,18.85 76.34,23.86 76.34,28.96 75.31,29.99 70.79,29.99 70.67,30.1 70.3,30.1 65.26,35.14 64.69,35.14 58.41,41.43 57.53,41.43 57.17,41.79 56.03,41.79 53.14,44.67 45.44,44.67 43.35,46.76 39.05,46.76 38.16,47.65 21.6,47.65 20.59,48.66 17.86,48.66 16.74,49.79 16.74,51.86 16.97,52.1 17.26,52.1 v5(17.35,52.19)
PCIE_CRX_DTX_P14: length 186.3
  IN3 w0.079: v5(150.48,38.38) 150.39,38.48 150.27,38.48 150.18,38.39 150.18,38.24 150.96,37.46 152.41,37.46 152.47,37.4 152.47,37.4 153.81,36.06 153.81,32.97 153.76,32.92 153.76,19.26 152.59,18.09 151.48,18.09 149.05,15.66 146.99,15.66 146.75,15.42 146.75,14.77 146.29,14.31 138.08,14.31 137.98,14.41 137.66,14.41 137.51,14.26 134.24,14.26 134.15,14.35 133.84,14.35 133.34,13.85 133.29,13.85 132.6,13.16 129.83,13.16 128.73,14.26 128.29,14.26 128.2,14.17 122.08,14.17 121.6,14.65 120.61,14.65 120.61,14.65 109.29,14.65 108.04,15.9 100.4,15.9 98.8,17.51 91.61,17.51 91.45,17.67 87.42,17.67 86.82,18.26 81.1,18.26 75.76,23.61 75.76,28.45 74.9,29.3 70.27,29.3 65.02,34.56 64.45,34.56 58.73,40.28 56.65,40.28 52.84,44.09 45.2,44.09 43.11,46.18 38.63,46.18 37.74,47.07 21.24,47.07 20.25,48.06 17.35,48.06 16.12,49.29 16.12,53.54 16.94,54.36 17.17,54.36 17.18,54.36 17.28,54.36 17.29,54.37 17.29,54.37 v5(17.35,54.43)
PCIE_CRX_DTX_P15: length 195.7
  IN3 w0.079: v5(17.35,56.1) 17.4,56.15 17.4,56.27 17.33,56.34 17.08,56.34 15.7,54.96 15.7,46.37 16.83,45.23 19.13,45.23 20.37,46.48 23.52,46.48 23.81,46.19 25.46,46.19 25.96,46.69 37.48,46.69 38.37,45.8 42.95,45.8 45.04,43.7 52.61,43.7 56.46,39.85 58.61,39.85 64.29,34.18 64.86,34.18 67.36,31.67 67.36,31.01 67.58,30.79 68.24,30.79 70.12,28.92 70.13,28.92 70.31,28.74 74.9,28.74 75.37,28.27 75.37,23.41 80.91,17.88 86.49,17.88 87.14,17.23 91.06,17.23 91.07,17.24 91.15,17.24 91.39,16.99 98.74,16.99 100.25,15.48 107.7,15.48 108.97,14.21 120.08,14.21 120.51,13.79 125.48,13.79 125.64,13.63 127.8,13.63 128.65,12.78 132.76,12.78 133.45,13.46 135.74,13.46 136.43,12.78 145.94,12.78 146.24,12.89 147.58,14.23 149.31,14.23 149.81,14.74 149.81,15.87 151.64,17.69 152.77,17.69 154.72,19.65 154.72,24.84 154.27,25.29 154.27,36.14 154.3,36.17 154.3,37.33 153.97,37.66 153.66,37.66 153.65,37.66 153.18,37.66 152.98,37.85 151.22,37.85 150.9,38.17 150.9,38.51 151.06,38.67 151.06,38.67 151.11,38.73 151.43,38.73 151.49,38.79 151.49,38.95 v5(151.41,39.03)
PCIE_CRX_DTX_P16: length 198.7
  IN3 w0.079: v5(152.33,39.03) 152.46,38.9 153.51,38.9 153.92,38.49 154.25,38.49 155.09,37.65 155.09,35.48 155.05,35.44 155.05,25.64 155.51,25.19 155.51,19.26 153.06,16.82 151.93,16.82 150.65,15.53 150.65,14.42 149.53,13.3 146.09,11.99 128.33,11.99 127.54,12.78 119.86,12.78 119.22,13.42 108.52,13.42 107.29,14.65 99.94,14.65 98.57,16.02 89.28,16.02 88.86,16.43 87.66,16.43 87.41,16.43 87.4,16.45 86.81,16.45 86.17,17.09 83.51,17.09 83.51,17.08 80.57,17.08 74.59,23.06 74.59,27.61 74.35,27.86 69.11,27.86 66.54,30.43 66.54,31.3 64.53,33.3 64.03,33.3 58.27,39.06 56.01,39.06 52.15,42.92 44.72,42.92 42.62,45.01 38.02,45.01 37.13,45.9 26.53,45.9 25.99,45.36 23.5,45.36 23.17,45.69 21.36,45.69 20.06,44.39 16.54,44.39 14.89,46.04 14.89,55.32 17.67,58.1 17.67,58.44 17.59,58.51 17.46,58.51 17.35,58.4 v5(17.35,58.34)
PCIE_CRX_L_DTX_N1: length 2.6
  TOP w0.091: v6(55.3,55.77) 55.09,55.98 55.09,56.18 55.4,56.48 RN115.2
  BOTTOM w0.091: v6(55.3,55.77) 55.11,55.97 55.11,56.2 55.26,56.36 JNGFF1.41
PCIE_CRX_L_DTX_P1: length 2.6
  TOP w0.091: RN116.2 54.61,56.48 54.89,56.2 54.89,55.94 v6(54.72,55.77)
  BOTTOM w0.091: v6(54.72,55.77) 54.9,55.96 54.9,56.27 54.76,56.41 JNGFF1.43
PCIE_CTX_C_DRX_N1: length 1.5
  TOP w0.091: RN118.1 53.79,53.7 LN19.4 53.79,53.44 53.65,53.29 53.65,52.74 CN72.2

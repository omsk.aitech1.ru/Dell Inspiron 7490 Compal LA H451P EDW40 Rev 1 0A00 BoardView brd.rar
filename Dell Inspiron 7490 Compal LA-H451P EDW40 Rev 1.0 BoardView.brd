# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_P6: length 135.1
  IN3 w0.079: v5(31.69,65.91) 31.77,65.99 31.77,66.2 31.96,66.4 32.87,66.4 36,63.26 36,63.21 36.97,62.24 38.46,62.24 40.9,59.81 41.36,59.81 42.1,59.06 42.1,58.55 43.21,57.44 44.63,57.44 45.17,56.9 49.53,56.9 50.23,56.19 50.84,56.19 51.06,56.41 55.51,56.41 56.69,55.22 56.69,53.34 63.11,46.93 63.11,44 65.65,41.46 65.65,40.76 65.91,40.5 66.61,40.5 70.37,36.74 70.69,36.74 71.29,36.74 71.29,36.74 76.11,36.74 83.05,29.81 83.13,29.81 83.2,29.73 90.32,29.73 90.32,29.73 91.93,29.73 103.03,28.4 111.66,28.4 112.05,28.02 114.36,28.02 120.88,34.54 123.01,34.54 123.62,34.53 125.5,36.41 128.53,36.41 128.81,36.69 130.36,36.69 130.66,36.4 132.9,36.4 133.07,36.57 133.76,36.57 134.93,37.73 137.82,37.73 139.39,36.16 141.57,36.16 141.65,36.23 v5(141.65,36.33)
  BOTTOM w0.091: R12.1 31.65,66.37 L3.4 31.78,66.24 31.78,66 v5(31.69,65.91)
USB20_P6_R: length 8.1
  BOTTOM w0.091: R12.2 31.63,66.95 L3.3 31.78,67.09 31.78,67.78 31.62,67.93 ED12.9 ED12.1 31.62,69.37 31.77,69.52 31.77,69.83 31.62,69.99 31.19,69.99 31.17,70 v7(29.81,70) 29.54,70 28.69,70.86 28.69,71.37 28.69,71.38 28.69,71.53 28.69,71.53 28.69,71.94 28.76,72.01 28.76,72.22 28.75,72.23 JEDP1.31
USB_EN#: length 164.8
  TOP w0.081: v2(52.94,15.21) 52.94,15.46 52.24,16.16 51.87,16.16 51.67,16.36 50.92,16.36 50.84,16.45 50.84,16.55 RE19.2 50.39,16.52 50.39,16.45 50.22,16.28 RE512.2
  IN1 w0.064: v2(52.94,15.21) 52.94,15.29 53.24,15.59 55.5,15.59 56.18,16.27 58.83,16.27 59.26,15.84 59.72,15.84 60.41,15.15 60.41,14.41 63.73,11.09 71.18,11.09 72.1,10.17 75.15,10.17 75.45,10.47 82.62,10.47 83.54,9.55 91.45,9.55 92.32,8.68 92.89,8.68 95.6,11.39 97.84,11.39 99.91,13.46 107.07,13.46 107.96,14.35 114.3,14.35 115.08,15.14 116.97,15.14 119.61,17.78 122.89,17.78 125.35,20.24 131.58,20.24 132.23,19.59 138.71,19.59 138.96,19.84 140.24,19.84 140.34,19.74 143.3,19.74 143.86,20.3 143.97,20.41 147.78,20.41 150.83,17.36 153.77,17.36 155.28,15.85 155.28,14.37 155.44,14.21 155.44,14.21 155.65,14 161.04,14 161.13,13.91 161.16,13.91 164.36,10.72 165.22,10.72 166.46,9.48 171.44,9.48 171.95,8.97 179.98,8.97 181.9,10.89 183.79,10.89 184.61,10.07 190.36,10.07 190.36,10.07 194.66,10.07 194.83,10.24 194.83,10.24 195.02,10.44 195.02,10.84 195.1,10.91 195.1,11.86 v2(195.49,12.25)
USB_OC0#: length 80.7
  TOP w0.081: v1(137.86,39.93) 137.86,39.58 137.31,39.03 v2(137.12,39.03) RC189.1
  IN1 w0.064: v2(195.49,12.75) 195.47,12.73 194.58,12.73 191.75,15.56 189.41,15.56 188.73,16.25 188.73,20.77 188.75,20.8 188.75,22.1 188.73,22.12 188.73,23.85 188.73,24.24 184.91,28.05 184.53,28.05 167.6,28.05 167.39,27.84 166.78,27.84 166.56,28.06 166.2,28.06 165.98,27.84 165.39,27.84 164.81,27.27 156.45,27.27 156.05,27.67 151.77,27.67 150.57,28.87 141.76,28.87 140.64,29.98 140.64,31.6 139.69,32.55 139.69,32.56 139.08,33.18 v4(139.08,34.09) ; v2(137.12,39.03) 137.55,39.03 v4(137.79,39.27)
  IN2 w0.066: v4(139.08,34.09) 139.08,34.19 138.93,34.34 138.77,34.5 138.77,37.47 138.2,38.04 138.2,38.85 v4(137.79,39.27)
  IN3 w0.064: v4(137.79,39.27) v5(137.55,39.03)
USB_OC1#: length 5.2
  BOTTOM w0.081: RC190.1 134.15,38.7 134.43,38.42 135.32,38.42 135.42,38.52 135.73,38.52 135.85,38.39 136.21,38.39 136.36,38.55 137.07,38.55 137.24,38.38 UC1.CK5
USB_OC2#: length 4.1
  TOP w0.081: v2(138.27,39.88) 138.27,41.09 v1(138.14,41.23) 137.87,41.49 RC191.1
  IN1 w0.064: v2(138.27,39.88) 138.33,39.83 138.55,39.83 v4(138.61,39.88)
  IN3 w0.064: v4(138.61,39.88) 138.14,40.35 137.57,40.35 v5(137.55,40.33)
USB_OC3#: length 7.1
  BOTTOM w0.081: UC1.CK9 137.55,40.93 137.01,40.39 134.85,40.39 134.79,40.33 134.27,40.33 134.16,40.44 132.82,40.44 RC188.1 132.59,40.34 132.59,40.53 132.38,40.73 131.79,40.73 131.45,40.39 v1(131.45,40.22)
USB_PWR_EN#: length 3.8
  TOP w0.081: UE1.A14 48.73,18.84 48.51,18.61 48.51,18.19 48.74,17.96 48.74,17.44 48.91,17.27 49.81,17.27 49.95,17.13 RE512.1
VDIFFA_CPU: length 1.8
  BOTTOM w0.203: PUZ01.6 151.86,22.48 PRZ47.1
VDIFFB_CPU: length 2.5
  BOTTOM w0.203: PRZ43.1 151.83,25.4 152.05,25.18 152.05,24.66 152.62,24.08 PUZ01.10
VDIFFC_CPU: length 1.7
  BOTTOM w0.203: PUZ01.14 154.45,26.19 PRZ35.1
VFBA_CPU: length 2.5
  BOTTOM w0.203: PUZ01.7 152.14,22.88 151.98,23.04 PRZ47.2 151.01,23.04 PRZ46.1
VFBB_CPU: length 3.7
  BOTTOM w0.203: PUZ01.11 152.72,24.48 152.41,24.79 152.41,25.8 151.89,26.31 PRZ43.2 151.39,26.14 PRZ42.1
VFBC_CPU: length 2.3
  BOTTOM w0.203: PUZ01.15 154.85,26.52 154.49,26.89 PRZ35.2 PRZ36.1
VGA_CORE_EN: length 145.7
  TOP w0.081: DV4.1 118.24,44.65 CV197.2 118.14,45.44 118.13,45.44 RV105.2 118.09,45.48 118.21,45.6 118.69,45.6 119.31,44.97 121.07,44.97 121.3,45.21 121.3,45.94 121.68,46.32 121.68,46.47 121.9,46.69 122.03,46.69 122.71,47.37 122.71,51.2 123.56,52.05 123.56,52.51 122.5,53.57 122.5,54.75 121.39,55.86 121.39,55.95 121.22,56.12 121.22,56.62 119.87,57.97 118.71,57.97 117.92,58.76 117.92,60.17 v1(117.78,60.31) 117.31,60.78 117.31,61.33 117.22,61.42 v2(117.22,61.76)
  IN1 w0.064: v2(37.87,68.02) 38.04,68.02 38.41,68.38 38.41,69.89 38.01,70.28 36.12,70.28 35.52,70.89 34.92,70.89 34.7,71.12 34.7,71.75 34.86,71.91 34.86,72.09 34.89,72.13 34.89,72.38 34.26,73 33.71,73 33.62,73.09 33.31,73.09 32.98,73.42 32.98,75.06 35.31,77.39 37.67,77.39 39.75,79.47 46.63,79.47 46.75,79.35 46.81,79.34 47.15,79.2 50.3,79.2 50.7,79.59 71.44,79.59 72.16,78.87 76.59,78.87 77.26,78.2 79.29,78.2 81.07,79.98 99.66,79.98 99.98,80.3 101.52,80.3 101.84,79.98 112.41,79.98 113.83,78.55 113.83,77.27 114.67,76.44 116.71,76.44 117.25,75.9 117.25,74.45 116.83,74.03 115.56,74.03 114.58,73.06 v2(114.58,73) 114.58,72.55 114.48,72.44 114.48,70.11 116.36,68.23 116.36,66.59 116.67,66.27 116.67,64.22 116.42,63.96 116.42,62.53 117.19,61.76 v2(117.22,61.76)
VGA_CORE_EN#: length 0.5
  TOP w0.081: 114.58,75.53 114.58,75.78 v3(114.77,75.97)
VIDALERT#: length 12.7
  BOTTOM w0.089: UC1.AA3 167.37,37.22 167.24,37.35 167,37.35 166.85,37.2 166.85,36.97 167,36.82 167,36.14 167.12,36.02 167.5,36.02 167.63,35.88 167.63,35.15 167.83,34.95
  BOTTOM w0.114: 167.83,34.95 168.27,34.52 168.27,34.17 167.92,33.82 167.45,33.82 167.31,33.68 167.31,33.47 v1(167.42,33.36) 168.19,33.36 168.58,33.75 168.74,33.75 168.85,33.63 168.85,31.89 168.71,31.75 168.31,31.75 168.16,31.9 168.16,32.8 168.05,32.91 167.42,32.91 167.33,32.82 167.33,32.58 RC135.1
VIDSCLK: length 12.8
  BOTTOM w0.089: 167.08,34.41 167.31,34.64 167.31,35.63 UC1.AA1
  BOTTOM w0.114: RC264.1 163.76,29.24 163.35,29.65 163.35,29.8 163.5,29.95 163.74,29.95 163.93,29.75 164.28,29.75 164.64,29.39 164.83,29.39 165.04,29.6 165.04,29.79 164.9,29.93 164.9,30.12 165.03,30.25 165.22,30.25 165.36,30.11 165.55,30.11 v1(166.24,30.8) 167.01,31.57 167.01,32.08 166.81,32.28 166.81,32.74 166.68,32.87 166.47,32.87 166.23,32.63 166.07,32.63 165.93,32.77 165.93,33.2 166.06,33.33 166.68,33.33 166.81,33.46 166.81,34.14 167.08,34.41
VIDSOUT: length 12.7
  BOTTOM w0.089: UC1.AA2 167.7,36.33 167.95,36.08 167.95,35.49 168.04,35.4
  BOTTOM w0.114: RC263.1 168.59,29.72 168.71,29.84 168.71,31.12 168.82,31.23 170.95,31.23 171.07,31.35 171.07,31.92 170.95,32.03 170.71,32.03 170.4,31.73 169.56,31.73 169.46,31.83 169.46,31.97 169.75,32.26 169.75,32.46 169.35,32.86 169.35,33.81 168.71,34.45 168.71,34.73 168.04,35.4
VORTNA_CPU: length 2.3
  BOTTOM w0.203: PRZ44.2 151.6,24.6 152.53,23.68 PUZ01.9
VORTNB_CPU: length 2.2
  BOTTOM w0.203: PUZ01.13 154.05,26.09 153.8,26.34 153.17,26.34 152.83,26.69 PRZ40.2
VORTNC_CPU: length 1.5
  BOTTOM w0.203: PRZ39.2 156.01,26.95 155.66,26.59 PUZ01.17
VOSENA_CPU: length 2.2
  BOTTOM w0.203: PUZ01.8 152.35,23.28 151.79,23.84 PRZ45.2
VOSENB_CPU: length 2.8
  BOTTOM w0.203: PUZ01.12 152.91,24.88 152.79,25 152.79,26.01 152.06,26.73 PRZ41.2
VOSENC_CPU: length 1.4
  BOTTOM w0.203: PRZ38.2 155.23,27.08 155.23,26.61 155.25,26.59 PUZ01.16
VR_CAP: length 3.9
  TOP w0.254: v2(45.46,20.03) 45.48,20.06 UE1.B8
  IN1 w0.254: v2(43.38,17.5) 43.55,17.5 44.03,17.97 44.03,18.56 44.68,19.21 44.68,19.39 45.33,20.03 v2(45.46,20.03)
VR_SVID_ALERT#: length 12.1
  BOTTOM w0.114: RC135.2 167.53,31.23 RC134.2 167.42,31.1 167.24,31.1 165.34,29.2 v1(165.34,27.03) 165.34,24.89 164.68,24.23 164.68,23.9 163.47,22.7 162.72,22.7 PRZ28.2
VR_SVID_CLK: length 10.7
  BOTTOM w0.114: RC264.2 163.81,28.33 163.81,28 163.91,27.9 164.71,27.9 164.84,27.77 164.84,27.58 164.71,27.45 v1(163.96,27.45) 163.93,27.45 163.8,27.32 163.8,27.13 163.94,26.99 164.71,26.99 164.84,26.86 164.84,26.67 164.71,26.53 164.06,26.53 163.92,26.4 163.92,26.21 164.06,26.08 164.71,26.08 164.84,25.94 164.84,25.1 164.62,24.88 164.45,24.88 164.31,25.02 164.31,25.54 164.23,25.62 164.01,25.62 163.78,25.38 163.78,25.2 163.64,25.06 PRZ27.2
VR_SVID_DATA: length 8.1
  BOTTOM w0.114: PRZ29.2 166.12,24.71 v1(166.12,25.83) 166.12,29.27 166.76,29.92 166.76,29.92 167.19,30.34 RC136.2 167.4,30.32 RC263.2
VRA_VDD18: length 4.6
  BOTTOM w0.203: PUZ01.26 159.77,24.48 160.18,24.88 160.18,25.17 160.72,25.71 161.13,25.71 PCZ12.1 161.4,25.94 162.18,26.73 162.22,26.73 PRZ54.2
VRA_VDD33: length 4.5
  BOTTOM w0.203: PCZ11.1 157.84,17.43 PRZ53.2 156.76,17.97 155.93,17.97 155.66,18.25 PUZ01.44
VRACPU_VINSEN: length 6.1
  BOTTOM w0.203: PRZ55.2 PCZ13.1 150.96,17.42 151.08,17.3 PRZ56.1 151.37,17.42 151.76,17.8 152.39,17.8 152.54,17.95 153.24,17.95 154.45,19.16 PUZ01.47
VRACPU_VTEMP: length 92.8
  IN1 w0.203: v4(156.55,16.35) 156.93,15.97 157.44,15.97 158.92,14.49 161.12,14.49 164.64,10.98 165.47,10.98 v4(165.98,10.47)
  IN2 w0.203: v4(144.42,18.96) 144.35,18.88 144.35,18.56 146.22,16.69 149.53,16.69 150.11,17.26 155.11,17.26 155.64,16.73 155.64,16.54 155.91,16.27 156.47,16.27 v4(156.55,16.35)
  IN3 w0.203: v4(156.55,16.35) 156.55,16.35 v5(157,15.9) ; v4(144.42,18.96) 142.51,18.96 142.4,19.07 141.31,19.07 v5(141.25,19.01) ; v4(165.98,10.47) 165.98,10.55 166.5,11.06 166.5,11.84 166.94,12.28 v5(167.79,12.28) 168.63,12.28 169.28,12.92 170.04,12.92 170.37,12.59 170.37,10.44 171.32,9.49 173.04,9.49 173.95,10.39 173.95,11.83 174.45,12.33 175.54,12.33 v5(175.61,12.26) 175.94,12.26 177.32,10.88 177.32,10.24 178.44,9.13 180.86,9.13 182.03,10.31 182.03,11.89 182.42,12.28 PUI03.11 v5(183.38,12.28) 183.38,12.85 188.8,18.26 189.73,18.26 190.4,18.94 190.4,24.01 195.58,29.19 196.02,29.19 197.81,30.98 198.45,30.98 199.23,31.76 200.42,31.76 201.94,33.28 v5(201.94,36.03)
  BOTTOM w0.203: v5(157,15.9) 156.53,16.37 PRZ33.2 ; v5(141.25,19.01) 141.33,19.09 PUA01.11 ; PUG01.11 v5(201.94,36.03)
VRAM_ID1: length 15.8
  IN3 w0.064: v5(140.15,51.9) 140.03,51.78 139.13,51.78 138.87,51.52 138.87,51.24 138.45,50.82 138.45,50.25 138.04,49.84 138.04,49.84 137.86,49.66 137.86,49.66 137.56,49.36 137.56,49.36 136.68,48.48 136.67,48.48 136.61,48.41 134.03,48.41 133.16,48.41 132.59,47.85 v5(129.07,47.85)
  BOTTOM w0.081: RC120.1 129.55,48.48 v1(129.32,48.24) 129.07,48 v5(129.07,47.85) ; v5(140.15,51.9) 140.32,52.07 UC1.CE27
  BOTTOM w0.089: RC120.1 RC118.2
VRAM_ID2: length 1.8
  TOP w0.081: RC117.2 RC119.1 135.38,49.02 135.38,49.3 v2(135.43,49.35)
  IN1 w0.064: v2(135.43,49.35) v4(135.86,49.78)
  IN3 w0.064: v4(135.86,49.78) 135.86,49.77 v5(135.61,49.52)
VRAM_VDD_CTL: length 2.8
  TOP w0.081: v6(98.36,67.38) 98.3,67.31 RV4989.1
  BOTTOM w0.081: v6(98.36,67.38) 99.51,66.23 100.07,66.23
VRHOT#_CPU: length 7
  BOTTOM w0.203: PUZ01.31 159.96,22.48 160.1,22.34 160.31,22.34 161.12,21.53 161.12,20.46 161.33,20.26 162.85,20.26 163.12,19.99 163.42,19.99 PRZ21.2 163.8,20.36 PRZ26.1
VRRDY_CPU: length 3.7
  BOTTOM w0.203: PUZ01.30 160.26,22.88 161.47,21.66 161.47,21 PRZ10.1
VSA_SEN+: length 16.6
  TOP w0.203: RC164.2 v2(151.15,39.22)
  IN1 w0.203: v4(151,39.65) 151.15,39.5 v2(151.15,39.22)
  IN2 w0.203: v4(155.92,28.43) 154.09,28.43 152.85,29.67 152.85,37.8 v4(151,39.65)
  IN3 w0.203: v4(151,39.65) 151.37,39.65 v5(151.41,39.68) ; v4(155.92,28.43) 155.87,28.48 v5(155.57,28.48)
  BOTTOM w0.203: PRZ38.1 155.25,28.16 v5(155.57,28.48)
VSA_SEN-: length 16.8
  IN1 w0.203: v2(151.61,38.69) 151.61,39.11 v4(152,39.5)
  IN2 w0.203: v4(152,39.5) 152,39.19 153.23,37.95 153.23,29.97 154.06,29.14 155.96,29.14 156.58,28.52 v4(156.58,27.73)
  IN3 w0.203: v4(156.58,27.73) 156.18,27.73 v5(156,27.91) ; v4(152,39.5) 152.11,39.61 152.26,39.61 v5(152.33,39.68)
VSYS_CHG: length 3
  BOTTOM w0.203: PCB35.1 PRB21.1 199.22,24.59 199.09,24.47 PUB01.3
VTTREF_1.2V: length 1.3
  BOTTOM w0.254: PUM01.7 194.54,70.9 194.48,70.95 PCM19.1
WHITE_LED_BAT: length 54.3
  TOP w0.254: v2(30.72,40.44) 31.63,40.44 33.52,42.32 v1(33.52,42.84) 34.06,43.39 Q32.1
  IN1 w0.254: v2(30.72,40.44) 29.24,40.44 v4(28.31,39.51)
  IN2 w0.254: v4(28.31,39.51) 27.45,40.38 27.45,47 23.68,50.77 21.52,50.77 18.28,54 13.15,54 12.42,53.27 7.38,53.27 6.96,53.27 5.75,54.48 5.75,57.97 5.8,58.02 5.8,58.06 7.28,59.53 7.31,59.53 7.45,59.67 7.87,59.67 13.09,59.67 v4(13.17,59.59)
  IN3 w0.254: v4(13.17,59.59) 13.18,59.6 v5(13.61,59.6)
WHITE_LED_BAT_R: length 12.5
  IN3 w0.254: v5(4.84,56.4) 5.36,56.92 5.36,58.7 5.99,59.34 7.45,59.34 8.03,59.91 11.26,59.91 11.65,59.53 12.53,59.53 13.37,58.69 v5(13.61,58.69)
  BOTTOM w0.254: LED1.2 v5(4.84,56.4)
WIFI_RF_EN: length 18.8
  TOP w0.081: v2(133.8,63.64) 133.48,63.96 133.48,65.26 133.49,65.27 RC571.2 133.46,65.78 133.06,65.78 RW60.1 ; v2(131.72,61.39) 131.46,61.13 131.46,60.61 132.89,59.18 132.89,51.93 133.36,51.47 v1(133.36,51.1) 133.7,50.75 133.83,50.75 v6(133.84,50.76)
  IN1 w0.064: v2(133.8,63.64) 133.8,63.41 131.78,61.39 v2(131.72,61.39)
  BOTTOM w0.081: UC1.CR24 134.6,50.17 134.02,50.76 v6(133.84,50.76)
WIFI_RF_EN_R: length 2.2
  TOP w0.081: v6(132.17,65.14) 132.19,65.14 132.37,65.32 RW60.2
  BOTTOM w0.081: WL1.28 133.23,65.25 133.03,65.45 132.48,65.45 v6(132.17,65.14)
WLAN_COEX1: length 114.4
  TOP w0.081: v1(50.3,51.92) 50.3,51.56 49.8,51.06 49.8,49.85 v2(49.91,49.74)
  IN1 w0.064: v4(51.8,51.77) 51.71,51.77 50.14,50.2 50.14,49.96 v2(49.91,49.74)
  IN2 w0.066: v4(51.8,51.77) 52.12,52.08 53.85,52.08 56.14,49.79 60.32,49.79 62.45,51.92 62.45,55.73 65.54,58.82 67.12,58.82 68.18,59.87 69.17,59.87 73.03,63.73 73.03,75.81 75.7,78.49 77.3,78.49 78.22,79.4 95.61,79.4 96.75,78.26 105.74,78.26 106.15,77.86 106.15,77.24 106.4,76.99 109.08,76.99 111.17,74.9 117.46,74.9 118.29,75.73 124.28,75.73 124.53,75.48 130.11,75.48 130.29,75.3 v4(130.62,75.3)
  IN3 w0.064: v5(134.23,73.75) 132.78,75.2 130.72,75.2 v4(130.62,75.3)
  BOTTOM w0.081: WL1.11 v5(134.23,73.75)
WLAN_COEX2: length 113
  TOP w0.081: v2(51.08,49.74) 51.08,51.47 v1(51.59,51.98)
  IN1 w0.064: v2(51.08,49.74) 51.41,50.07 51.41,50.59 v4(52.24,51.41)
  IN2 w0.066: v4(130.24,74.27) 124.98,74.27 123.73,75.52 118.52,75.52 117.69,74.69 110.99,74.69 108.9,76.77 106.31,76.77 105.88,77.21 105.88,77.82 105.67,78.04 96.58,78.04 95.43,79.19 78.3,79.19 75.43,76.32 73.93,76.32 73.29,75.68 73.29,63.73 69.25,59.68 68.26,59.68 67.2,58.62 65.62,58.62 62.64,55.65 62.64,51.84 60.4,49.6 56.06,49.6 54.24,51.41 v4(52.24,51.41)
  IN3 w0.064: v4(130.24,74.27) 130.43,74.27 131.46,73.25 v5(134.24,73.25)
  BOTTOM w0.081: WL1.12 v5(134.24,73.25)
WLAN_COEX3: length 111.3
  TOP w0.081: v1(51.47,50.62) 51.66,50.43 v2(51.66,49.74)
  IN1 w0.064: v4(52.49,50.91) 52.05,50.91 51.6,50.46 51.6,49.79 v2(51.66,49.74)
  IN2 w0.066: v4(130.22,73.65) 129.73,73.15 125.26,73.15 123.13,75.28 118.94,75.28 118.11,74.45 110.86,74.45 108.77,76.54 106.22,76.54 105.6,77.15 105.6,77.76 105.52,77.84 96.42,77.84 95.31,78.95 78.34,78.95 75.29,75.9 73.98,75.9 73.49,75.41 73.49,63.65 69.33,59.49 68.34,59.49 67.28,58.43 65.7,58.43 62.93,55.66 62.93,51.85 60.48,49.41 55.58,49.41 54.08,50.91 v4(52.49,50.91)
  IN3 w0.064: v4(130.22,73.65) 131.12,72.75 v5(134.3,72.75)
  BOTTOM w0.081: WL1.13 v5(134.3,72.75)
WWAN_BB_RST#: length 149.6
  IN2 w0.066: v4(41.58,61.58) 41.58,61.25 38.12,57.78 38.12,50.14 38.86,49.39 38.86,49.31 42.38,45.79 43.42,45.79 46.17,43.05 52.38,43.05 54.66,40.77 57.66,40.77 63.4,35.02 64.75,35.02 72.05,27.73 76.01,27.73 81.61,22.13 88.86,22.13 90.02,20.96 96.23,20.96 97.32,22.05 114.44,22.05 117.47,25.08 117.47,28.61 118.91,30.05 119.32,30.05 122.7,33.44 123.08,33.44 123.4,33.44 126.09,36.12 126.09,39.44 128.16,41.5 128.64,41.5 129.31,41.5 134.21,46.41 134.4,46.41 135.71,47.72 136.41,47.72 136.52,47.6 136.52,47.6 136.69,47.43 137.14,47.43 137.61,47.9 137.61,48.34 138,48.73 138.69,48.73 139.1,49.14 139.1,49.69 v4(139.03,49.76)
  IN3 w0.064: v4(139.03,49.76) 139.19,49.92 v5(139.19,50.29) ; v5(46.14,61.62) 46.1,61.66 43.61,61.66 43.26,61.3 42.38,61.3 42.1,61.58 v4(41.58,61.58)
  BOTTOM w0.081: v5(139.19,50.29) UC1.CG23 ; v5(46.14,61.62) 46.47,61.29 RN73.1
WWAN_BB_RST#_R: length 8.8
  IN3 w0.064: v5(49.72,60.35) 49.72,59.29 49.29,58.85 48.84,58.85 v5(48.48,58.49)
  BOTTOM w0.081: JNGFF1.67 48.76,58.21 v5(48.48,58.49) ; v1(47.59,62.13) 47.59,61.18 47.12,60.71 RN73.2 47.12,60.61 48.08,60.61 RN199.1 CN59.1 49.12,60.71 49.47,60.35 v5(49.72,60.35)
WWAN_COEX1: length 2.8
  TOP w0.081: v2(49.36,49.15) RW14.1 49.91,48.42 49.87,48.38 v1(49.87,48.31)
  IN1 w0.064: v2(49.36,49.15) 49.44,49.07 49.44,48.99 v4(49.7,48.73)
  IN3 w0.064: v4(49.7,48.73) 49.62,48.81 49.62,49.35 49.51,49.46 v5(49.51,49.53)
WWAN_COEX2: length 3.6
  TOP w0.081: v1(50.74,47.36) 50.74,47.59 50.26,48.07 50.26,48.41 50.49,48.64 v2(50.49,49.15) RW15.1
  IN1 w0.064: v4(50.09,49.1) 50.44,49.1 v2(50.49,49.15)
  IN3 w0.064: v4(50.09,49.1) 50.09,49.45 v5(50.01,49.53)
WWAN_COEX3: length 3.7
  TOP w0.081: v2(51.33,48.31) 51.42,48.22 51.64,48.22 v1(51.71,48.3) 51.71,49.1 RW16.1 RW13.1
  IN1 w0.064: v2(51.33,48.31) 51.33,48.45 v4(51.54,48.66)
  IN3 w0.064: v4(51.54,48.66) 51.25,48.95 51.25,49 50.72,49.53 v5(50.51,49.53)
WWAN_FULL_PWR_EN: length 113.6
  TOP w0.081: CN18.1 64.26,51.37 RN7.2 63.7,51.37 v6(63.6,51.28) 63.6,51.07 v1(63.36,50.83)
  IN1 w0.064: v4(60.3,41.25) 60.3,41.47 60.55,41.72 60.59,41.72 60.59,41.72 62.12,41.72 62.55,42.15 65.09,42.15 65.26,42.31 65.26,42.55 65.09,42.72 64.69,42.72 63.77,43.63 63.77,51.1 v6(63.6,51.28)
  IN2 w0.066: v4(136.58,49.43) 136.35,49.43 136.11,49.19 135.72,49.19 134.5,47.96 133.83,47.96 133.57,47.7 133.57,47.4 128.83,42.66 127.67,42.66 123.85,38.84 123.85,36.84 123.46,36.45 123.4,36.45 121.74,34.79 121.07,34.79 113.13,26.85 112.36,26.85 112.09,27.11 112.09,28.13 111.84,28.39 111.68,28.39 111.68,28.39 109.15,28.39 108.56,28.99 99.85,28.99 99.67,29.17 81.46,29.17 81.1,28.81 72.39,28.81 65.83,35.37 65.83,35.39 60.3,40.92 v4(60.3,41.25)
  IN3 w0.064: v5(136.26,49.52) 136.35,49.43 v4(136.58,49.43)
  BOTTOM w0.081: JNGFF1.6 64.01,50.86 v6(63.6,51.28)
WWAN_GPIO_CTRL: length 37.5
  TOP w0.081: RN90.1 57.07,42.25 56.94,42.12 56.29,42.12 55.54,41.37 54.05,41.37 53.46,40.78 53.46,39.58 54.25,38.79 54.25,37.58 57.17,34.66 57.17,30.68 58.11,29.74 58.11,22.74 57.75,22.38 57.75,20.92 57.23,20.41 57.23,19.28 v1(56.78,18.83) 55.97,18.02 54.63,18.02 54.45,18.2 53.44,18.2 53.04,17.8 52.55,17.8 51.98,18.37 51.19,18.37 50.85,18.71 50.06,18.71 49.73,19.03 UE1.A16
WWAN_GPIO_CTRL#: length 3
  TOP w0.081: UN4.6 57.01,40.37 56.97,40.41 RN89.2 55.48,40.41 55.15,40.08 QN3.1
WWAN_GPIO_CTRL_R: length 3.2
  TOP w0.081: QN3.2 55.59,42.31 55.81,42.31 55.93,42.43 56.4,42.43 RN90.2 RN91.1 56.49,43.75 56.8,44.06 v1(56.87,44.06)
WWAN_GPIO_PERST#: length 118.7
  TOP w0.081: RN113.1 54.43,50.16 v2(54.84,50.16) ; RN85.2 55.17,45.57 v2(55.42,45.82) 55.42,45.25 v1(55.69,44.98)
  IN1 w0.064: v2(54.84,50.16) 54.84,49.41 55.42,48.83 v2(55.42,45.82) 55.42,45.5 57.12,43.8 57.12,43.21 56.56,42.66 v4(56.31,42.66)
  IN2 w0.066: v4(56.31,42.66) 56.55,42.66 58.8,40.41 58.8,40.27 62.26,36.81 63.24,36.81 72.03,28.02 76.12,28.02 81.82,22.32 88.94,22.32 89.97,21.29 93.7,21.29 93.83,21.15 96.15,21.15 97.25,22.25 114.33,22.25 117.2,25.13 117.2,28.64 118.82,30.25 119.25,30.25 122.62,33.63 123.29,33.63 125.89,36.23 125.89,39.52 128.08,41.7 128.72,41.7 129.23,41.7 134.13,46.6 134.32,46.6 136,48.28 136.9,48.28 136.9,48.28 136.92,48.28 v4(138.17,49.53)
  IN3 w0.064: v4(138.17,49.53) v5(138.54,49.9)
WWAN_GPIO_PERST#_R: length 0.9
  TOP w0.081: RN97.1 v1(56.87,46.59)
WWAN_GPIO_WAKE#: length 98.7
  TOP w0.081: RN80.1 60.25,42.06 59.8,42.06 59.54,42.33 RN82.1 59.91,42.52 60.02,42.41 60.57,42.41 v1(60.7,42.53) 60.99,42.53 61.26,42.27 61.26,40.98 v2(61.4,40.83)
  IN1 w0.064: v2(61.4,40.83) 61.36,40.79 v4(60.95,40.79)
  IN2 w0.066: v4(60.95,40.79) 60.95,40.64 66.02,35.57 66.02,35.45 72.47,29 81.02,29 81.38,29.36 99.75,29.36 99.93,29.18 108.64,29.18 109.23,28.59 111.76,28.59 111.76,28.58 111.92,28.58 111.92,28.58 112.32,28.58 112.83,28.07 113.41,28.07 120.75,35.41 121.79,35.41 122.54,36.15 122.54,38.34 127.53,43.33 128.68,43.33 132.99,47.64 132.99,47.96 133.76,48.74 v4(133.76,48.78)
  IN3 w0.064: v5(137.42,49.6) 137.42,49.42 136.61,48.6 133.94,48.6 v4(133.76,48.78)
  BOTTOM w0.081: v5(137.42,49.6) 137.24,49.79 UC1.CK23
WWAN_GPIO_WAKE#_R: length 1.4
  TOP w0.081: UN4.1 60.21,40.37 60.64,40.81 RN80.2
WWAN_PERST#: length 3.7
  TOP w0.081: v2(53.47,48.73) 53.16,48.73 52.83,49.06 RN88.1 RN87.2 RN113.2
  IN1 w0.064: v4(53.8,49.26) 53.47,48.93 v2(53.47,48.73)
  IN3 w0.064: v4(53.8,49.26) 53.41,49.65 53.13,49.65 v5(53.01,49.53)
WWAN_PERST#_R: length 5.9
  TOP w0.081: v2(53.81,47.56) 53.15,46.9 UN5.4 ; v1(54.41,50.54) 54.06,50.19 v2(54,50.19) 53.75,50.19 53.42,49.86 RN87.1
  IN1 w0.064: v2(53.81,47.56) 54.37,48.12 54.37,48.37 54.44,48.45 54.44,49.18 54,49.62 v2(54,50.19)
WWAN_PEWAKE#: length 15.1
  TOP w0.081: RN74.1 58.34,42.53 RN81.2 58.95,42.52 RN82.2 RN112.2 58.95,43.22 58.67,43.5 v1(58.67,44.36) 58.56,44.48 57.86,44.48 57.04,43.65 v2(56.81,43.65)
  IN1 w0.064: v2(56.81,43.65) 56.81,43.54 56.61,43.34 55.04,43.34 54.42,43.96 54.42,44.28 53.2,45.49 53.2,47.18 52.91,47.48 52.91,48.5 53.02,48.61 v4(53.02,48.63)
  IN3 w0.064: v5(52.01,49.53) 52.01,49.26 52.59,48.68 52.97,48.68 v4(53.02,48.63)
WWAN_PEWAKE#_R: length 1.4
  TOP w0.081: UN4.4 57.91,41.67 57.99,41.76 57.99,42.02 57.76,42.25 RN81.1
WWAN_RADIO_DIS#: length 119.1
  TOP w0.081: RC565.1 v2(140.09,48.76) ; v2(57.75,30.84) 57.75,31.11 v1(60.02,33.38) 61.45,34.82 61.45,36.15 61.66,36.36 QN8.3
  IN1 w0.064: v2(140.09,48.76) 140.09,48.64 139.99,48.53 139.97,48.53 139.92,48.49 v4(139.88,48.49) ; v4(67.73,31.16) 67.42,30.84 v2(57.75,30.84)
  IN2 w0.066: v4(67.73,31.16) 67.73,23.75 68.65,22.83 69.59,22.83 71.08,21.34 72.85,21.34 72.85,21.34 73.95,22.44 73.95,22.44 74.06,22.55 75.2,22.55 75.24,22.6 75.25,22.6 75.54,22.89 79.77,22.89 81.82,20.83 86.95,20.83 87.48,21.36 88.98,21.36 90.55,19.8 91.82,19.8 92.4,20.38 96.47,20.38 97.56,21.47 104.09,21.47 104.68,20.88 105.07,20.88 105.66,21.47 114.75,21.47 118.57,25.29 118.57,25.86 119.24,26.54 119.61,26.54 120.08,27.01 120.08,29.22 121.22,30.35 121.22,30.44 126.68,35.89 126.68,39.21 128.39,40.92 129.55,40.92 131.83,43.21 133.34,43.21 133.73,43.6 133.79,43.6 134.22,44.03 134.22,44.83 134.95,45.56 136.2,45.56 137.19,46.55 139.51,46.55 139.88,46.92 v4(139.88,48.49)
  IN3 w0.064: v5(139.84,48.86) 139.84,48.72 139.92,48.64 139.92,48.53 v4(139.88,48.49)
WWAN_RADIO_DIS#_R: length 17.1
  TOP w0.081: QN8.4 63,36.36 62.66,36.7 62.66,40.08 v1(62.97,40.39) 63.15,40.57 63.15,42.38 v2(62.21,43.32)
  IN1 w0.064: v4(61.47,46.52) 62.32,45.67 62.32,43.43 v2(62.21,43.32)
  IN3 w0.064: v5(61.58,45.81) 61.58,46.4 v4(61.47,46.52)
  BOTTOM w0.081: v5(61.58,45.81) 63.51,47.74 JNGFF1.8
WWAN_WAKE#_R: length 26.5
  TOP w0.081: RN92.2 56.22,39.41 57.57,39.41 57.73,39.25 QN7.4 58.1,38.9 58.23,39.03 58.23,39.54 58.66,39.97 60.49,39.97 v1(60.77,40.26) 61,40.48 61,42.1 v2(60.93,42.17)
  IN1 w0.064: v4(59.7,55.67) 59.75,55.67 60.13,55.3 60.91,55.3 62.89,53.32 62.89,43.29 62.38,42.78 62.38,42.78 62.21,42.62 62.21,42.62 61.77,42.17 v2(60.93,42.17)
  IN3 w0.064: v4(59.7,55.67) 59.76,55.74 v5(59.76,57.08)
XCLK_BIASREF: length 2.5
  BOTTOM w0.081: UC1.CJ1 138.08,34.64 138.96,33.76 RC83.1
XDP_BPM#0: length 3
  TOP w0.081: v2(170.24,36.68) 170.26,36.69 TP135.1
  IN1 w0.064: v4(170.42,35.23) 170.42,35.66 170.69,35.93 170.69,36.23 v2(170.24,36.68)
  IN3 w0.064: v5(169.81,35.68) 170.18,35.32 170.21,35.32 170.3,35.23 v4(170.42,35.23)
XDP_BPM#1: length 1.5
  IN1 w0.064: v2(169.38,36.41) 169.71,36.08 v4(170.22,36.08)
  IN3 w0.064: v5(169.81,36.33) 170.06,36.08 v4(170.22,36.08)
XDP_BPM#2: length 3.7
  BOTTOM w0.081: UC1.U3 169.81,36.82 170.12,36.51 170.12,34.68 170.74,34.05 TP4.1
XDP_BPM#3: length 5.4
  BOTTOM w0.081: TP5.1 170.45,33.13 170.45,34.03 169.79,34.7 169.79,35.17 169.51,35.45 169.51,37.33 169.81,37.63 UC1.U4
XDP_DBRESET#: length 2.7
  TOP w0.081: JXDP1.48 137.83,10.04 138.8,11.01 CC105.1 RC248.1
XDP_ITP_PMODE: length 1
  IN1 w0.064: v4(168.7,37.94) 168.54,37.78 168.54,37.7 168.54,37.37 v2(168.53,37.37)
  IN3 w0.064: v4(168.7,37.94) 168.5,37.74 v5(168.5,37.63)
XDP_OBS0: length 6.4
  TOP w0.081: RC245.2 129.34,12.31 129.37,12.27 v2(129.37,11.93)
  IN1 w0.064: v2(129.37,11.93) 129.37,10.82 129.96,10.24 129.96,7 v2(129.73,6.77)
XDP_OBS1: length 6.4
  TOP w0.081: RC246.2 129.93,12.13 v2(129.76,11.95)
  IN1 w0.064: v2(129.76,11.95) 129.76,10.82 130.33,10.25 v2(130.33,6.77)
XDP_PIN1: length 4.2
  TOP w0.081: JXDP1.1 123.73,7.91 122.92,8.72 122.92,10.08 RC253.2
XDP_PRSENT#: length 63.9
  TOP w0.081: JXDP1.60 141.43,9.97 142.04,10.58 RC533.2 142.36,11.42 142.5,11.55 142.5,14.54 140.78,16.26 140.78,16.68 139.6,17.86 139.6,19.45 139.81,19.66 139.81,29.77 135.48,34.1 134.74,34.1 132.23,36.6 132.23,40.41 v1(132.17,40.48) 130.36,42.29 130.36,44.12 128.37,46.11 128.37,49.96 130.77,52.36 130.77,56.96 130.87,57.07 130.87,57.29 131.17,57.58 v2(131.25,57.58)
  IN1 w0.064: v2(131.25,57.58) 131.25,57.51 132.68,56.08 133.23,56.08 133.23,56.08 133.39,56.08 133.74,55.73 134.28,55.73 135.3,54.72 137.43,54.72 v2(137.57,54.57)
XDP_PWRBTN#: length 8.5
  TOP w0.081: v2(133.83,11.76) 133.83,11.91 133.18,12.57 CC109.1 RC535.1 RC247.2
  IN1 w0.064: v2(133.83,11.76) 133.9,11.7 134.66,11.7 135.73,10.63 v2(135.73,6.77)
XDP_RST#: length 2.3
  TOP w0.081: JXDP1.46 137.23,11.03 RC538.2 137.58,11.13 137.66,11.22 RC249.1
XDP_TCK1: length 7.2
  TOP w0.081: JXDP1.55 139.93,8.12 140.34,8.53 143.14,8.53 RC238.2 143.64,8.98 143.94,8.68 144.76,8.68 v1(145.07,8.99)
XTAL24_IN: length 5.8
  BOTTOM w0.089: UC1.CK3 137.12,36.48 137.02,36.38 136.78,36.38 136.59,36.2 136.59,35.98 136.69,35.87 136.69,34.92 136.16,34.39 136.16,33.19 136.99,32.35 RC89.1
XTAL24_IN_R: length 2.3
  BOTTOM w0.076: 136.58,31.78 136.56,31.78 RC90.1 136.25,31.87 CC9.1 135.47,31.87 YC1.3
  BOTTOM w0.081: RC89.2 136.82,31.7 136.74,31.78 136.58,31.78
XTAL24_OUT: length 6.3
  BOTTOM w0.089: UC1.CK2 137.4,36.12 137.01,35.74 137.01,34.81 136.51,34.31 136.51,33.72 137.63,32.6 137.63,31.12 RC91.1
XTAL24_OUT_R: length 3.6
  BOTTOM w0.076: 136.58,31.14 136.58,31.19 RC90.2 136.4,31.26 CC10.1 135.79,31.26 135.52,31.54 134.62,31.54 YC1.1
  BOTTOM w0.081: 136.58,31.14 136.66,31.06 RC91.2
XTAL_25_IN: length 3.8
  BOTTOM w0.081: RT394.1 19.59,62.26 19.71,62.14 19.71,61.59 21.07,60.23 21.54,60.23 21.74,60.03 UT1.D22
XTAL_25_OUT: length 2.2
  BOTTOM w0.081: RT40.1 20.5,60.49 21.01,59.98 UT1.D23
XTAL_25_OUT_R: length 3.1
  BOTTOM w0.081: RT40.2 19,61.08 CT20.1 18.45,60.96 17.34,60.96 YT1.3
XTAL_IN: length 11.3
  BOTTOM w0.081: YV1.1 96.63,75.24 96.63,74.39 96.46,74.21 CV210.2 96.46,73.45 96.82,73.08 96.82,72.76 96.82,72.75 96.82,72.15 96.82,72.14 96.82,71.66 97.2,71.28 v7(97.2,70.91) 97.2,70.43 96.51,69.73 96.51,67.67 97.02,67.16 97.38,67.16 97.78,66.75 UV1.C11
XTAL_OUT: length 7.6
  BOTTOM w0.081: RV22.1 97.45,73.19 97.03,72.77 v7(97.03,72.44) 97.03,71.74 97.41,71.36 97.41,70.35 96.71,69.65 96.71,67.75 97.1,67.36 UV1.B10
XTAL_OUT_R: length 1.6
  BOTTOM w0.081: YV1.3 97.42,74.63 97.06,74.26 CV209.2 96.99,73.89 96.99,73.55 RV22.2
XTAL_OUTBUFF: length 1.8
  TOP w0.081: RV20.1 97.9,66.47 98.07,66.47 v6(98.35,66.2)
  BOTTOM w0.081: v6(98.35,66.2) 98.35,66.35 98.37,66.37 UV1.C10
XTAL_SSIN: length 4
  BOTTOM w0.081: UV1.A10 97.27,67.95 97.27,69.43 97.94,70.1 RV21.1
N2683228: length 2.1
  BOTTOM w0.203: PUV02.10 54.19,74.27 53.99,74.47 53.48,74.47 53.04,74.92 PRV23.1
N2712313:
  vias: v6(52.49,74.51)
N2712398: length 1.8
  BOTTOM w0.203: PRV22.2 53.8,74.92 53.95,74.77 54.17,74.77 54.59,74.35 PUV02.11
N2712532: length 1.5
  BOTTOM w0.203: PUV02.12 54.99,74.59 54.56,75.03 PRV25.2
N2726002: length 2.3
  BOTTOM w0.203: PRV29.1 52.97,67.35 53.35,66.97 53.95,66.97 54.21,66.7 PUV03.10
N2726376: length 1.7
  BOTTOM w0.203: PUV03.12 55.01,66.99 54.5,67.5 PRV31.2
N20727249: length 0.4
  TOP w0.081: v1(116.74,74.07) 116.74,73.69
N20754656: length 19.2
  IN3 w0.064: v5(113.4,73.65) 113.17,73.88 111.53,73.88 110.22,75.19 v5(110.22,76.06)
  BOTTOM w0.081: RV76.2 98.52,75.04 98.52,75.66 99.76,76.9 109.39,76.9 v5(110.22,76.06) ; v5(113.4,73.65) 113.47,73.58 QV147.2
N26715581: length 14.7
  TOP w0.081: R63.2 60.03,28.59 59.48,29.14 58.88,29.14 58.69,28.95 v1(58.69,26.23) 58.53,26.07 58.53,22.58 58.17,22.21 58.17,20.49 58.32,20.33 60.33,20.33 Q18.1
N26762425: length 0.9
  BOTTOM w0.081: v1(174.89,61.91) RD26.1
N26877476: length 7.2
  TOP w0.081: Q15.2 38.5,42.83 37.78,42.11 37.55,42.11 37.3,41.85 37.3,39.41 37.57,39.14 v1(37.74,39.14) 37.96,39.14 38.53,39.71 R89.2 38.53,41.06 Q15.5
N26881990: length 4.3
  TOP w0.081: v1(35.38,9.31) 35.17,9.53 RZ25.1 35.77,10.83 QZ3.1
N28778657: length 1.2
  TOP w0.081: QV145.3 95.27,33.05 95.14,32.92 RV2006.2
N30699666: length 0.7
  TOP w0.081: RV5001.1 115.77,41.11 QV3.2
N30856173: length 6.5
  TOP w0.081: v6(93.68,58.01) 93.15,58.54 92.79,58.54 90.24,61.09 90.24,61.98 T20.1
  BOTTOM w0.089: UV1.F22 v6(93.68,58.01)
N30856176: length 10
  TOP w0.081: v6(95.41,56.22) 95.41,57.04 95.05,57.41 94.85,57.41 93.45,58.81 92.89,58.81 90.64,61.07 90.64,62.87 90.84,63.07 T21.1
  BOTTOM w0.089: v6(95.41,56.22) 94.84,56.22 UV1.J22
N31419621: length 1.7
  TOP w0.081: v1(59.91,48.14) 59.57,48.47 RS3.1 59.03,48.77 59,48.79 CS1.2
N31764539: length 0.8
  BOTTOM w0.203: PRZ46.2 150.64,22.29 150.47,22.12 PCZ10.1
N31764585: length 0.8
  BOTTOM w0.203: PCZ09.1 150.73,25.4 PRZ42.2
N31764615: length 1
  BOTTOM w0.076: 153.47,28.8 152.83,28.8 v1(152.6,29.02)
  BOTTOM w0.081: PCZ08.1 153.47,28.8
N32054988: length 0.9
  TOP w0.081: RT285.2 32.34,62.95 32.38,62.91 UT14.1
N32054990: length 0.8
  TOP w0.081: RT284.2 32.1,62.37 32.21,62.26 UT14.2
N32488305: length 1.3
  TOP w0.254: U16.B2 71.4,73.95 71.33,73.88 RS10.1 RS5.2
N32831687: length 2.2
  TOP w0.081: QN4.4 60.55,38.53 60.46,38.44 60.21,38.44 59.55,37.78 QN4.1
N33308105:
  vias: v1(103.3,9.2)
N33308155: length 1.7
  BOTTOM w0.081: PRB43.1 188.55,29.06 188.63,29.14 PRB23.1 188.95,28.12 PQB04.2
N33308352: length 2.3
  BOTTOM w0.203: PCB42.1 197.45,30.27 v1(196.86,29.68) 196.72,29.54 PRB30.2
N33308363: length 1.3
  BOTTOM w0.081: PRB29.1 194.77,30.34 194.4,29.97 194.1,29.97 ZTB01.1
N33311343: length 0.9
  IN1 w0.064: v2(146.63,49.93) 147,49.93 147.03,49.91 v4(147.06,49.91)
  IN3 w0.064: v5(147.16,50.3) 147.16,50.05 147.08,49.97 147.08,49.93 v4(147.06,49.91)
N33312418: length 1.8
  TOP w0.254: PC1811.1 66.68,20.12 66.85,20.29 PR1804.2 67.12,20.26 PR1805.1
N35403675: length 3.1
  TOP w0.081: v1(99.33,27.79) 99.35,27.77 PR105.1 100.05,26.71 PC100.2 100.27,26.7 PQ100.2
N35404139: length 3.1
  TOP w0.081: PQ100.3 100.31,26.05 PC100.1 100.1,25.95 99.38,25.95 PR101.2 99.18,25.76 v1(99.18,24.87)
N35404409: length 3
  TOP w0.081: PQ100.5 103.85,26.7 PR104.1 PR103.2 103.85,25.56 v1(103.28,24.98)
N35676409: length 3.8
  BOTTOM w0.081: UC1.CP36 135.11,57.53 131.96,57.53 T18.1
N35676427: length 3.5
  BOTTOM w0.081: T27.1 180.57,56.99 180.13,56.56 UC1.A34
N35676429: length 4.6
  BOTTOM w0.081: UC1.B35 178.81,56.86 179.82,56.86 180.87,57.91 182.24,57.91 T28.1
N35676431: length 5.6
  BOTTOM w0.081: v1(182.32,55.14) RC420.1 182.32,56 179.72,56 179.46,56.25 178.88,56.25 178.73,56.1 178.41,56.1 178.11,56.4 UC1.C34
N35676631: length 2
  TOP w0.081: T4989.1 163.51,52.54 163.23,52.26 v2(163.23,52.19)
  IN1 w0.064: v4(163.22,51.59) 163.23,51.6
  IN1 w0.094: 163.23,51.6 v2(163.23,52.19)
  IN3 w0.064: v4(163.22,51.59) 163.21,51.61 v5(162.87,51.61)
N35676633: length 2.9
  TOP w0.081: v1(163.54,51.21) 163.54,51.42 v2(162.83,52.14) 162.5,52.47 RC436.2
  IN1 w0.094: v2(162.83,52.14) 162.83,52.06 v4(162.42,51.65)
  IN3 w0.064: v5(162.42,52.07) v4(162.42,51.65)
N35774230: length 1.8
  BOTTOM w0.203: PUV03.11 54.61,66.8 54.15,67.27 54.11,67.27 53.73,67.64 PRV28.2
N35920315: length 2
  TOP w0.081: Q29.3 62.7,16.8 62.79,16.71 RE477.2 63.66,16.71 v1(64.08,16.29)
N36044932: length 2.1
  TOP w0.081: UZ9.6 46.99,45.28 47,45.3 CZ235.1 v1(47.89,45.68)
N36098789: length 20
  TOP w0.081: RE535.1 50.74,17.38 50.68,17.32 v2(50.18,17.32) ; v2(42.19,6.77) 42.43,6.77 v1(42.63,6.57)
  IN1 w0.064: v4(42.19,7.74) v2(42.19,6.77) 43.25,5.72 v2(43.25,5.49) ; v4(48.37,17.32) 48.5,17.46 49.25,17.46 49.39,17.32 v2(50.18,17.32)
  IN3 w0.064: v4(42.19,7.74) 42.19,8.46 42.39,8.66 45.03,8.66 45.51,9.14 45.78,9.14 46.76,10.12 46.76,11.91 47.56,12.71 47.56,13.75 47.72,13.91 47.72,14.17 48.1,14.55 48.1,15.15 48.37,15.41 v4(48.37,17.32)
N36100634: length 2.1
  TOP w0.081: v1(58.61,15.04) 58.79,15.22 RE213.2 59.5,15.5 QE11.1
N36372155: length 8.4
  TOP w0.081: TP86.1 35.72,21.14 37.03,21.14 37.31,20.86 v2(37.31,20.58) ; UE1.B66 v2(41.21,21.93)
  IN1 w0.064: v2(41.21,21.93) 40.64,21.36 40.64,21.18 39.61,20.14 37.57,20.14 37.31,20.4 v2(37.31,20.58)
N36804565: length 1.4
  TOP w0.081: v1(44.83,7.53) 45.77,6.6 PR524.2
N40235254: length 3.7
  BOTTOM w0.081: UC1.CR35 131.14,57.21 T4990.1
N40449957: length 3.8
  TOP w0.081: v1(110.3,15.61) 110.19,15.72 PQ1402.2 110.6,17.09 PC1816.2 112.03,17.77 PR1815.1
N40451324: length 5.8
  TOP w0.081: PQ1.2 116.49,13.88 116.88,14.26 PR4.2 118.26,14.26 PQ2.1 v1(120.45,16.45)
N41366254: length 2.6
  TOP w0.081: TP105.1 123.84,10.81 124.63,10.02 JXDP1.4
N41366256: length 1.2
  TOP w0.081: JXDP1.6 125.23,9.82 124.84,10.21 TP106.1
N41366258: length 2.9
  TOP w0.081: TP107.1 125.12,11.28 126.43,9.97 JXDP1.10
N41366267: length 1.4
  TOP w0.081: JXDP1.12 127.03,9.9 TP108.1
N41366269: length 1.4
  TOP w0.081: JXDP1.16 128.23,10.03 TP109.1
N41366285: length 1
  TOP w0.081: JXDP1.18 128.83,10.66 TP110.1
N41366301: length 2.3
  TOP w0.081: TP111.1 130.03,11.65 JXDP1.22
N41366303: length 1.1
  TOP w0.081: TP112.1 130.63,10.54 JXDP1.24
N41366319: length 4.1
  TOP w0.081: TP113.1 134.35,11.52 133.49,10.66 132.77,10.66 132.32,10.21 132.04,10.21 131.83,10 JXDP1.28
N41366321: length 5.7
  TOP w0.081: JXDP1.30 132.43,10.02 132.86,10.45 134.34,10.45 134.69,10.8 134.69,12.84 TP114.1
N41366330: length 6.8
  TOP w0.081: JXDP1.34 133.63,10.01 133.86,10.24 134.44,10.24 134.89,10.69 134.89,13.59 134.26,14.23 TP115.1
N41366332: length 5.7
  TOP w0.081: JXDP1.36 134.23,9.94 134.3,10.01 134.56,10.01 135.1,10.56 135.1,14.05 TP116.1
N41366348: length 6.3
  IN1 w0.064: v2(126.13,6.77) 126.13,8.17 127.09,9.13 127.09,11.09 127.16,11.16 127.16,11.8 127,11.96 v2(126.4,11.96)
N41366350: length 6.9
  IN1 w0.064: v2(127.23,13.25) 127.23,12.01 127.46,11.78 127.46,8.76 126.73,8.03 v2(126.73,6.77)
N41366366: length 5.4
  IN1 w0.064: v2(127.67,12.03) 127.93,11.77 v2(127.93,6.77)
N41366382: length 5.4
  IN1 w0.064: v2(128.53,6.77) 128.53,11.55 v2(128.96,11.97)
N41366384: length 5.3
  IN1 w0.064: v2(131.57,11.72) 131.13,11.27 131.13,7.17 v2(131.53,6.77)
N41366386: length 4.7
  IN1 w0.064: v2(132.13,6.77) 131.34,7.56 131.34,9.71 v2(132.32,10.69)
N41366395: length 5.2
  IN1 w0.064: v2(133.14,11.68) 132.93,11.48 132.93,7.31 133.33,6.91 v2(133.33,6.77)
N41366411: length 4.7
  IN1 w0.064: v2(134.19,10.78) 133.18,9.77 133.18,7.52 v2(133.93,6.77)
N41366427: length 8
  TOP w0.081: TP125.1 144.36,6.65 142.8,5.1 139.23,5.1 138.73,5.6 JXDP1.51
N41366429: length 5.4
  TOP w0.081: JXDP1.53 139.33,5.88 139.71,5.5 142.53,5.5 143.06,6.02 143.12,6.02 TP126.1
N41366445: length 4.3
  TOP w0.081: TP127.1 143.64,8.13 140.92,8.13 140.53,7.74 JXDP1.57
N41366447: length 3.7
  TOP w0.081: TP128.1 139.7,12.27 139.7,10.87 139.03,10.2 JXDP1.52
N41366449: length 2.1
  TOP w0.081: TP129.1 140.17,10.66 139.63,10.12 JXDP1.54
N41366458: length 3.7
  TOP w0.081: TP130.1 140.69,11.87 140.69,10.58 140.23,10.12 JXDP1.56
N41366474: length 1.4
  TOP w0.081: TP131.1 141.25,10.45 140.83,10.03 JXDP1.58
N41366476: length 4.5
  TOP w0.081: JXDP1.5 124.93,7.72 123.52,9.13 TP132.1
N41366492: length 7.8
  TOP w0.081: JXDP1.3 124.33,7.82 123.19,8.96 123.19,11.64 123.01,11.81 TP133.1
N42766510: length 1.8
  BOTTOM w0.254: PUH01.14 126.72,20.33 126.19,19.81 PCH09.1
N42766662: length 0.9
  BOTTOM w0.254: PRH09.2 124.56,18.14 PCH12.2
N43968416: length 4.9
  TOP w0.254: PUW01.15 65.89,54.18 65.63,54.43 64.55,54.43 64.17,54.05 v1(63.73,54.05) 62.87,54.05 PCW35.1 PRW24.1
N44377954: length 2.7
  BOTTOM w0.254: PUF01.7 113.46,43.21 113.2,42.94 113.2,42.93 112.76,42.5 PCF09.1
N44377971: length 2.3
  BOTTOM w0.254: PCF01.1 PRF01.2 116.94,43.22 PUF01.4
N45032542: length 0.7
  TOP w0.081: 116.33,53.7 v1(116.33,53)
N45072311: length 5.8
  TOP w0.457: QV151.3 121.76,48.74 122.22,49.19 122.22,49.85
  TOP w0.508: RV5005.2 121.63,53.3 v1(122.28,52.65) 122.28,49.9 122.22,49.85
N45072322: length 5.5
  TOP w0.081: v1(79.39,34.89) 79.51,34.89 QV152.3
  TOP w0.508: RV5007.2 82.39,32.1 81.89,32.61 81.89,32.8 81.14,33.55 QV152.3
N50440735: length 1.7
  BOTTOM w0.081: RT394.2 19.02,61.43 CT21.1 18.07,61.43 YT1.1
N57652736: length 2.1
  TOP w0.081: PQ100.6 103.73,27.35 PR102.1 103.85,28.54 v1(103.85,28.54)

## Copper pours and planes (outline as drawn)
1.0VS_DGPU_EN# on TOP (solid shape): 94.17,36.44 94.17,35.88 94.3,35.75 94.81,35.75 94.86,35.7 94.86,35.04 94.81,34.99 93.64,34.99 93.43,35.19 93.43,36.24 93.69,36.49 94.12,36.49
1.2V_DDR_OT on BOTTOM (solid shape): 195.24,67.43 195.24,66.64 195.99,65.88 196,65.88 196.05,65.83 196.88,65.83 196.96,65.75 196.96,64.76 196.86,64.66 196.32,64.66 196.26,64.72 196.26,65.49 196.17,65.58 195.87,65.58 194.9,66.54 194.9,67.48 194.96,67.54 195.14,67.54
1.2V_VTT_PWRGD on BOTTOM (solid shape): 194.7,67.48 194.7,66.53 195.78,65.44 196.06,65.44 196.13,65.37 196.13,63.77 196.56,63.34 198.34,63.34 198.4,63.27 198.4,62.77 198.27,62.64 196.24,62.64 195.49,63.39 195.49,64.68 195.48,64.69 195.48,65.34 194.38,66.45 194.38,67.47 194.43,67.53 194.66,67.53
1.35V_PWR_EN# on TOP (solid shape): 79.34,33 79.34,31.83 79.19,31.68 77.95,31.68 77.9,31.74 77.9,32.13 77.92,32.16 78.52,32.16 78.6,32.24 78.6,33.04 78.71,33.15 79.19,33.15
3V3_5V on BOTTOM (solid shape): 13.53,27.65 13.53,26.99 13.27,26.74 13.07,26.74 12.87,26.53 12.87,25.57 12.76,25.47 12.61,25.47 12.51,25.57 12.51,26.61 12.23,26.89 12.23,27.57 12.38,27.73 13.45,27.73
+0.6V_DDR_VTT on TOP (solid shape): outline of 210 points within 139.74,69.47 195.55,79.17
+0.6V_DDR_VTT on BOTTOM (solid shape): 186.07,77.9 186.07,77.09 186.05,77.07 182.38,77.07 182.34,77.11 182.34,77.63 182.3,77.67 181.66,77.67 181.61,77.63 181.61,77.13 181.55,77.07 179.59,77.07 179.57,77.09 179.57,77.5 179.58,77.51 180.04,77.51 180.64,78.1 185.86,78.1
+0.6V_DDR_VTT on BOTTOM (solid shape): 167.76,77.5 172.1,77.5 172.71,78.11 178.05,78.11 178.05,77.61 178.37,77.61 178.37,77.11 178.31,77.05 175.78,77.05 175.72,77.11 175.72,77.67 175.67,77.71 174.52,77.71 174.43,77.62 174.43,77.09 174.39,77.06 173.94,76.61 167.54,76.61 167.04,77.1 164.12,77.1 164.07,77.05 161.77,77.05 161.73,77.09 161.73,77.64 161.7,77.67 161.08,77.67 161.04,77.63 161.04,77.11 160.98,77.05 158.97,77.05 158.84,77.18 158.84,78.04 158.92,78.11 167.14,78.11
+0.6V_DDR_VTT on IN1 (solid shape): outline of 363 points within 184.44,57.8 199.41,78.1
+0.6VSP on TOP (solid shape): 197.09,71.87 197.09,71.51 197.09,71.51 197.09,70.92 196.87,70.7 196.87,69.7 196.62,69.45 195.37,69.45 195.13,69.69 195.13,70.47 195.13,70.48 195.67,70.48 195.69,70.49 195.69,70.93 195.67,70.95 195.14,70.95 195.13,70.96 195.13,71.91 195.28,72.06 196.89,72.06
+0.6VSP on BOTTOM (solid shape): 197.05,71.73 197.05,70.86 197.03,70.83 197,70.83 196.71,70.55 195.79,70.55 195.74,70.49 195.67,70.49 195.36,70.18 195.36,69.96 195.11,69.71 194.97,69.71 194.87,69.81 194.87,71.72 195.03,71.88 196.9,71.88
+0.9V_TBT_LVR_OUT on TOP (solid shape): 29.64,57.55 30.21,57.55 30.31,57.44 30.31,56.96 30.25,56.91 30.24,56.91 29.88,56.91 29.84,56.87 29.84,56.31 29.8,56.27 29.01,56.27 29.01,55.71 28.88,55.58 28.88,54.98 28.82,54.92 28.36,54.92 28.24,55.04 28.24,57.03 28.28,57.07 28.67,57.07 28.83,57.22 28.83,57.62 28.88,57.66 29.53,57.66
+0.9V_TBT_LVR_OUT on IN1 (solid shape): 28.97,58.58 29.02,58.36 29.14,58.18 29.27,58.05 29.29,58.02 29.44,57.87 29.58,57.87 29.61,57.84 29.65,57.76 29.69,57.7 29.93,57.61 30.16,57.71 30.3,57.71 30.39,57.62 30.39,57.03 30.36,56.96 30.29,56.93 30.16,56.9 30.05,56.81 29.51,56.81 29.45,56.86 29.41,56.89 28.97,57.32 28.97,57.57 28.81,57.74 28.59,57.74 28.41,57.92 28.41,58.35 28.39,58.38 28.36,58.45 28.36,58.52 28.37,58.55 28.41,58.63 28.41,58.65 28.44,58.68 28.71,58.68 28.72,58.69 28.97,58.69
+0.9V_TBT_LVR_OUT on IN3 (solid shape): 29.49,58.61 29.49,57.93 29.31,57.76 29.14,57.76 29.02,57.88 29.02,57.98 28.83,58.17 28.19,58.17 28.18,58.18 28.18,58.46 28.49,58.76 29.33,58.76
+0.9V_TBT_PCIE on TOP (solid shape): 23.86,57.03 23.86,55.82 23.76,55.71 23.43,55.71 23.28,55.57 21.69,55.57 21.38,55.88 21.38,57.03 21.51,57.15 22.23,57.15 22.33,57.25 23.63,57.25
+0.9V_TBT_PCIE on IN1 (solid shape): 23.72,57.44 23.72,57.05 23.85,56.92 24.3,56.92 24.38,56.84 24.38,56.4 24.28,56.3 23.94,56.3 23.8,56.16 23.8,56.09 23.81,56.09 23.81,55.95 23.62,55.76 22.47,55.76 22.4,55.82 22.4,56.21 22.28,56.33 21.89,56.33 21.71,56.51 21.71,56.9 21.8,56.98 22.27,56.98 22.58,57.29 23.12,57.29 23.38,57.55 23.61,57.55
+0.9V_TBT_PCIE on IN3 (solid shape): 22.81,57.87 22.9,57.82 22.9,57.72 23.09,57.37 23.29,57.72 23.29,57.82 23.38,57.87 24.3,57.87 24.55,57.62 24.61,57.62 24.61,57.34 24.54,57.25 24.43,57.27 24.4,57.3 24.4,57.31 23.89,57.45 24.03,56.94 24.04,56.94 24.21,56.77 24.33,56.7 24.47,56.71 24.56,56.69 24.61,56.61 24.61,55.97 24.51,55.87 24.46,55.92 24.45,55.93 24.12,56.19 23.85,55.86 23.82,55.78 23.75,55.75 23.3,55.75 23.29,55.77 23.09,55.88 22.9,55.77 22.89,55.75 22.78,55.75 22.64,55.89 22.64,56.19 22.65,56.41 22.46,56.53 22.4,56.56 22.37,56.63 22.37,56.67 22.39,56.71 22.43,56.72 22.66,56.89 22.55,57.15 22.5,57.2 22.5,57.27 22.51,57.33 22.51,57.38 22.66,57.52 22.64,57.72 22.64,57.82 22.73,57.87
+0.9V_TBT_SVR on TOP (solid shape): 25.73,57.8 25.73,55.28 25.81,55.2 26.41,55.2 26.45,55.25 26.45,57.78 26.5,57.84 26.87,57.84 26.91,57.8 26.91,57.29 27.01,57.18 27.01,55.31 27.08,55.24 27.08,54.92 27.26,54.75 27.75,54.75 27.81,54.69 27.81,54.19 27.78,54.17 21.98,54.17 21.96,54.19 21.96,54.57 22.01,54.62 24.15,54.62 24.49,54.97 24.94,54.97 25.21,55.24 25.21,57.76 25.28,57.84 25.69,57.84
+0.9V_TBT_SVR on TOP (solid shape): 31.68,68.81 31.68,64.01 30.35,62.67 30.33,62.67 30.2,62.65 30.09,62.57 30.02,62.54 29.94,62.57 29.72,62.67 29.49,62.58 29.42,62.56 29.35,62.58 29.02,62.65 28.8,62.41 28.79,62.37 26.49,62.37 26.07,62.78 26.07,64.49 26.2,64.49 29.15,65.74 29.86,68.86 29.91,68.92 31.58,68.92
+0.9V_TBT_SVR on IN1 (solid shape): 27.68,58.58 27.68,57.87 27.64,57.83 27.05,57.83 26.99,57.77 26.99,55.33 27.19,55.13 27.49,55.13 27.73,54.89 28.05,54.89 28.18,55.01 28.18,55.16 28.18,55.19 28.19,55.23 28.18,55.28 28.18,55.31 28.18,55.58 27.81,55.95 27.81,56.18 27.92,56.29 28.52,56.29 28.54,56.28 28.59,56.26 28.63,56.25 28.67,56.24 28.87,56.04 28.87,55.09 28.86,55.05 28.85,55.02 28.83,55 28.8,54.99 28.78,54.98 28.71,55 28.66,55 28.62,55 28.57,54.99 28.52,54.98 28.48,54.95 28.44,54.92 28.4,54.89 28.38,54.85 28.36,54.8 28.34,54.75 28.34,54.71 28.34,54.66 28.35,54.61 28.37,54.56 28.39,54.53 28.39,54.43 28.13,54.17 24.38,54.17 24.22,54.33 23.93,54.33 23.86,54.4 23.86,54.87 23.99,54.99 24.43,54.99 24.54,54.88 24.99,54.88 25.15,55.04 25.15,57.68 25.73,57.68 25.73,55.05 25.88,54.9 26.35,54.9 26.48,55.03 26.48,57.67 26.29,57.86 25.9,57.86 25.73,57.68 25.15,57.68 25.15,57.75 24.99,57.9 24.69,57.9 24.55,58.04 24.55,58.65 24.61,58.71 27.55,58.71
+0.9V_TBT_SVR on IN2 (solid shape): outline of 337 points within 23.65,53.97 28.97,63.71
+0.9V_TBT_SVR on IN1: 27.8,65.37 29.58,65.37 29.71,65.24 29.71,64.42 29.57,64.28 28.86,64.28 28.35,63.77 28.35,63.45 28.17,63.27 26.63,63.27 26.5,63.39 26.5,63.59 26.64,63.73 26.64,64.22
+0.9V_TBT_SVR on IN3: outline of 132 points within 23.93,54.11 29.1,63.71
+1.0VGAP on BOTTOM (solid shape): 114.34,44.79 114.34,44.19 114.19,44.03 113.22,44.03 112.56,43.37 112.56,43.19 112.32,42.95 111.91,42.95 111.89,42.96 109.6,42.96 109.16,42.53 109.16,42.07 108.92,41.83 107.15,41.83 107.08,41.9 107.08,43.43 107.58,43.93 107.99,43.52 108.37,43.91 107.96,44.31 108.39,44.74 108.8,44.74 109.39,44.16 112.36,44.16 113.09,44.9 114.24,44.9
+1.0VS_DGPU on TOP (solid shape): 115.14,51.77 115.14,51.07 114.25,50.18 114.21,50.16 114.18,50.18 113.93,50.23 113.78,50.02 113.78,49.86 113.74,49.81 113.74,49.67 113.25,49.18 112.28,49.18 110.79,47.69 110.79,47.64 110.6,47.45 110.6,47.45 110,46.86 110,46.85 109.32,46.17 108.54,46.17 108.26,45.88 107.7,45.88 107.48,46.1 107.48,46.24 109.12,47.88 109.68,47.88 110.25,48.45 110.33,48.45 112.05,50.18 112.95,50.18 114.83,52.06 114.85,52.06
+1.0VS_DGPU on BOTTOM (solid shape): outline of 109 points within 101.15,42.06 109.96,49.89
+1.2V_DDR on TOP (solid shape): outline of 5121 points within 137.76,46.62 198.83,77.55
+1.2V_DDR on BOTTOM (solid shape): 154.55,69.54 154.55,68.09 154.24,67.78 152.07,67.78 151.99,67.85 151.99,69.83 152.05,69.89 154.2,69.89
+1.2V_DDR on BOTTOM (solid shape): 174.46,70.25 175.7,70.25 175.78,70.17 175.78,68.19 175.55,67.96 173.55,67.96 173.35,68.16 173.35,70.92 173.39,70.96 173.75,70.96
+1.2V_DDR on BOTTOM (solid shape): 158.33,76.95 158.33,73.62 158.23,73.52 157.49,73.52 157.35,73.66 157.35,73.97 157.39,74 157.39,75.9 157.92,76.43 157.92,76.91 157.98,76.96 158.31,76.96
+1.2V_DDR on BOTTOM (solid shape): 190.41,49.32 190.41,48.15 190.87,47.69 192.67,47.69 192.67,47 189.01,47 189.01,47.01 189.01,47.55 188.96,47.55 188.96,47.93 188.91,47.97 188.91,49.39 188.99,49.47 190.26,49.47
+1.2V_DDR on BOTTOM (solid shape): 178.98,76.91 178.98,76.72 179.72,75.98 179.72,73.62 179.43,73.34 179.37,73.34 179.33,73.33 178.89,73.33 178.58,73.64 178.58,73.91 179.01,74.33 179.01,76.24 178.57,76.68 178.57,76.94 178.6,76.97 178.93,76.97
+1.2V_DDR on BOTTOM (solid shape): 137.83,70.28 138.98,70.28 139.26,70 139.26,68.04 139.1,67.88 138.6,67.88 137.71,66.99 137.71,66.41 137.4,66.11 136.88,66.11 136.83,66.16 136.83,66.53 136.91,66.61 137.37,66.61 137.4,66.64 137.4,67.29 137.36,67.34 136.85,67.34 136.76,67.42 136.76,68.36 136.87,68.47 137.7,68.47 138.03,68.8 138.03,69.58 137.87,69.74 136.84,69.74 136.76,69.81 136.76,70.82 136.82,70.88 137.22,70.88
+1.2V_DDR on BOTTOM (solid shape): 191.15,62.06 191.15,61.93 191.2,61.88 192.26,61.88 192.31,61.83 192.31,60.81 191.63,60.14 190.67,60.14 190.51,59.98 190.51,59.35 190.39,59.22 190.18,59.22 190.17,59.23 190.03,59.27 189.88,59.23 189.87,59.22 189.38,59.22 189.37,59.23 189.22,59.27 189.07,59.22 189.06,59.22 188.89,59.4 188.89,60.85 189.11,61.07 190.02,61.07 190.15,61.2 190.15,62 190.15,62.01 190.15,62.08 190.18,62.11 191.1,62.11
+1.2V_DDR on BOTTOM (solid shape): 151.92,72.09 151.92,70.6 151.92,70.6 151.92,70.1 151.82,70 151.33,70 151.14,69.82 151.14,68.07 150.99,67.92 149.39,67.92 149.28,68.03 149.28,68.36 149.42,68.62 149.28,68.88 149.28,69.18 149.45,69.46 149.28,69.73 149.28,69.84 149.58,70.14 149.82,70.14 150.18,70.51 150.18,71.97 150.34,72.13 151.89,72.13
+1.2V_DDR on BOTTOM (solid shape): 197.95,56.56 197.95,55.69 197.9,55.64 197.36,55.64 197.3,55.7 197.3,55.72 197.15,55.86 195.98,55.86 195.52,55.4 194.75,55.4 194.68,55.32 194.59,55.25 194.54,55.15 194.54,55.14 194.15,54.75 193.89,54.75 193.73,54.91 193.73,55.3 193.84,55.41 194.17,55.41 194.53,55.76 194.53,55.79 194.55,55.8 194.72,56.07 194.55,56.35 194.53,56.36 194.53,56.45 194.6,56.53 197.27,56.53 197.37,56.63 197.89,56.63
+1.2V_DDR on BOTTOM (solid shape): 188.11,71.68 188.11,70.03 188.19,70.03 188.35,69.86 188.35,69.03 188.25,68.92 188.13,68.92 188.02,68.82 188.02,68.44 187.97,68.39 186.96,68.39 186.52,67.96 185.79,67.96 185.69,68.06 185.69,68.35 185.72,68.36 185.89,68.64 185.72,68.91 185.69,68.93 185.69,69.15 185.72,69.16 185.77,69.2 185.82,69.26 186.12,69.26 186.33,69.18 186.54,69.26 186.88,69.26 187.44,69.81 187.44,71.57 187.57,71.69 188.1,71.69
+1.2V_DDR on BOTTOM (solid shape): 166.89,72.87 166.89,70.86 166.81,70.78 166.37,70.78 166.34,70.75 166.34,69.7 166.56,69.48 167.53,69.48 167.68,69.33 167.68,68.59 167.55,68.47 166.99,68.47 166.89,68.37 166.89,67.91 166.87,67.88 166.23,67.88 166.13,67.99 164.5,67.99 164.33,68.16 164.34,68.24 164.36,68.3 164.42,68.34 164.67,68.64 164.42,68.94 164.36,68.97 164.36,69.1 164.42,69.14 164.59,69.23 164.67,69.41 164.68,69.46 165.37,69.46 165.8,69.89 165.8,72.39 166.3,72.89 166.87,72.89
+1.2V_DDR on BOTTOM (solid shape): 192.77,55.88 192.77,53.1 192.51,52.84 191.99,52.84 191.9,52.89 191.9,52.98 191.63,53.42 191.36,52.98 191.35,52.89 191.27,52.84 191,52.84 190.8,53.04 190.8,54.87 191.42,55.5 191.79,55.46 191.91,55.8 191.93,55.89 192.01,55.93 192.71,55.93
+1.2V_DDR on BOTTOM (solid shape): outline of 723 points within 173.29,64.72 188.66,66.99
+1.2V_DDR on BOTTOM (solid shape): outline of 769 points within 138.65,65.01 151.92,67.65
+1.2V_DDR on BOTTOM (solid shape): outline of 1025 points within 152,59.56 167.43,66.99
+1.2V_DDR on BOTTOM (solid shape): outline of 1288 points within 184.85,46.7 190.24,61.79
+1.2V_DDRP on TOP (solid shape): outline of 85 points within 183.16,58.77 199.86,65.41
+1.2V_DTH on BOTTOM (solid shape): 22.49,38.42 22.49,37.6 22.52,37.58 22.52,37.44 22.66,37.3 22.8,37.3 23.35,36.74 23.53,36.74 23.53,36.71 25.63,36.71 25.75,36.59 25.75,35.81 25.44,35.5 24.92,35.5 24.27,36.15 23.05,36.15 22.23,36.97 21.68,36.97 21.36,37.3 16.34,37.3 16.16,37.48 16.16,38.44 16.27,38.55 22.36,38.55
+1.2V_DTH_OUT on TOP (solid shape): 29.88,37.39 29.88,36.66 29.83,36.6 27.97,36.6 27.9,36.52 27.9,36.38 27.84,36.32 27.49,36.32 27.43,36.26 27.38,36.26 27.38,36.22 27.36,36.2 27.36,35.21 27.23,35.08 26.73,35.08 26.73,35.73 26.5,35.73 26.5,36.59 26.65,36.74 27.3,36.74 27.32,36.76 27.38,36.76 27.38,36.81 27.99,37.43 29.84,37.43

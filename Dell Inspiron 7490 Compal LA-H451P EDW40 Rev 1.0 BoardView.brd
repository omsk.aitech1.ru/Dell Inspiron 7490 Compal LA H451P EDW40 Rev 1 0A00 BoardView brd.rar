# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FB_A_D39: length 16.3
  IN1 w0.094: v6(95.41,52.72) 95.22,52.53 95.22,51.97 93.37,50.12 91.62,50.12 91.51,50.02 91.01,50.02 90.89,49.9 90.89,49.78 91.77,48.9 91.77,48.77 91.57,48.56 91.44,48.56 90.56,49.44 90.43,49.44 90.23,49.24 90.23,49.11 91.09,48.25 91.09,48.13 90.88,47.92 90.75,47.92 89.89,48.78 89.77,48.78 89.68,48.69 89.68,48.05 89.21,47.58 88.69,47.58 88.09,46.97 v2(88.03,46.97)
  BOTTOM w0.127: v6(95.41,52.72) 95.43,52.74 UV1.N24
FB_A_D40: length 33.6
  TOP w0.127: v6(80.09,44.19) 80.11,44.21 UV8.U11
  IN3 w0.094: v6(80.09,44.19) 80.1,44.18 80.56,44.18 80.64,44.25 81.17,44.25 81.91,45 83.66,45 86.12,42.53 86.12,41.78 87.13,40.77 87.13,40.22 89.54,37.8 93.86,37.8 96.06,40.01 96.06,44.49 97.62,46.04 97.62,48.45 98.79,49.62 98.79,49.96 98.92,50.09 v5(98.92,50.36)
  BOTTOM w0.127: UV1.V23 v5(98.92,50.36)
FB_A_D41: length 38.1
  TOP w0.127: v6(78.95,43) 78.95,43.54 UV8.U13
  IN3 w0.094: v6(78.95,43) 79.57,43 79.95,43.38 80.89,43.38 80.97,43.46 82.81,43.46 83.37,42.89 84.5,42.89 84.86,42.53 84.86,42.16 84.48,41.78 84.48,40.55 85.89,39.14 85.89,38.94 87.86,36.96 88.9,36.96 88.95,37.01 94.2,37.01 97.25,40.05 97.25,40.83 98.33,41.91 98.33,42.83 99.87,44.38 99.87,45.33 99.49,45.71 99.49,45.79 99.45,45.82 99.45,46.12 98.5,47.07 98.5,48.2 99.59,49.29 99.59,49.63 100.1,50.14 v5(100.1,50.37)
  BOTTOM w0.127: UV1.V22 v5(100.1,50.37)
FB_A_D42: length 33.4
  TOP w0.127: v6(80.72,44.75) 80.72,44.18 UV8.T11
  IN3 w0.094: v6(80.72,44.75) 81.38,45.4 83.82,45.4 86.59,42.63 86.59,41.88 87.53,40.94 87.53,40.38 89.7,38.2 93.68,38.2 95.66,40.18 95.66,44.65 97.22,46.2 97.22,49.15 97.42,49.35 97.42,49.45 98.36,50.4 98.51,50.4 98.82,50.71 98.82,51.1 98.55,51.38 98.49,51.38 v5(98.32,51.55)
FB_A_D43: length 37.2
  TOP w0.127: UV8.T13 v6(79.55,43.59)
  IN3 w0.094: v6(79.55,43.59) 79.74,43.78 80.73,43.78 80.8,43.85 82.08,43.85 82.61,44.38 83.66,44.38 85.26,42.78 85.26,41.96 84.93,41.62 84.93,41.04 88.57,37.41 94.03,37.41 96.85,40.22 96.85,43.89 97.02,44.06 97.02,44.09 98.26,45.33 98.26,45.71 98.01,45.95 98.01,46.64 98.1,46.72 98.1,47.63 98.1,48.37 99.19,49.46 99.19,49.79 99.58,50.19 99.58,50.5 100.08,51.01 v5(100.08,51.55)
  BOTTOM w0.127: UV1.U22 v5(100.08,51.55)
FB_A_D44: length 37
  TOP w0.127: UV8.N11 82.38,42.44 82.37,42.43 82.35,42.37 82.35,42.22 82.36,42.14 82.38,42.11 82.38,41.92 v6(82.34,41.88)
  IN3 w0.094: v5(100.76,48.63) 100.82,48.58 100.83,48.58 101,48.4 101,47.91 101.7,47.22 101.7,42.57 99.18,40.05 99.18,39.15 95.22,35.18 89.83,35.18 89.15,34.5 85.4,34.5 82.07,37.84 82.07,40.27 81.8,40.54 81.8,40.94 82,41.13 82,41.37 82.34,41.72 v6(82.34,41.88)
  BOTTOM w0.127: v5(100.76,48.63) UV1.Y24
FB_A_D45: length 36.7
  TOP w0.127: UV8.N13 v6(81.25,40.76)
  IN3 w0.094: v6(81.25,40.76) 81.25,40.32 81.67,39.9 81.67,37.63 85.19,34.1 89.32,34.1 90,34.78 95.97,34.78 99.58,38.4 99.58,39.89 102.09,42.4 102.09,47.39 101.44,48.04 v5(101.31,48.04)
  BOTTOM w0.127: v5(101.31,48.04) UV1.AA24
FB_A_D46: length 36.3
  TOP w0.127: UV8.M11 82.95,41.87 82.95,41.31 v6(82.94,41.31)
  IN3 w0.094: v5(101.13,50.36) 101.26,50.24 101.26,49.87 100.9,49.51 100.9,49.24 100.34,48.68 100.34,48.48 100.6,48.22 100.6,47.75 101.3,47.06 101.3,42.73 98.67,40.11 98.67,39.46 94.79,35.58 89.67,35.58 88.99,34.9 86.36,34.9 82.88,38.38 82.88,38.66 82.58,38.97 82.58,40.77 82.72,40.91 82.72,41.08 v6(82.94,41.31)
  BOTTOM w0.127: UV1.Y22 101.26,50.24 v5(101.13,50.36)
FB_A_D47: length 39.7
  TOP w0.127: v6(80.36,38.74) 80.36,38.88 81.02,39.53 81.13,39.53 81.81,40.22 UV8.M13
  IN3 w0.094: v5(101.26,49.06) 101.87,49.06 102.49,48.44 102.49,42.23 100.19,39.93 100.19,38.4 96.18,34.39 90.17,34.39 89.48,33.71 85.02,33.71 80.36,38.36 v6(80.36,38.74)
  BOTTOM w0.127: UV1.AA23 v5(101.26,49.06)
FB_A_D48: length 17.2
  IN1 w0.094: v6(99.45,42.17) 99.18,42.17 98.64,41.64 98.64,40.44 93.83,35.63 90.43,35.63 90.02,35.22 89.73,35.22 89.45,35.51 89.32,35.51 v2(89.17,35.66)
  BOTTOM w0.127: UV1.AD27 100.8,44.54 100.8,43.19 99.78,42.17 v6(99.45,42.17)
FB_A_D49: length 22.2
  IN1 w0.094: v2(88.03,34.52) 89.13,34.52 89.43,34.83 90.19,34.83 90.32,34.95 93.72,34.95 100.64,41.88 100.64,43.5 v6(99.4,44.74)
  BOTTOM w0.127: v6(99.4,44.74) 99.4,45.05 99.96,45.61 99.96,45.94 99.73,46.17 99.73,46.5 100.14,46.91 UV1.AB25
FB_A_D50: length 18.2
  TOP w0.127: v2(89.57,35.81) 89.16,36.22 UV8.B11
  IN1 w0.094: v2(89.57,35.81) 89.8,36.03 93.67,36.03 98.24,40.61 98.24,41.8 99.81,43.37 v6(100.19,43.37)
  BOTTOM w0.127: UV1.AD26 101.16,44.97 100.55,44.97 100.37,44.79 100.37,43.55 v6(100.19,43.37)
FB_A_D51: length 20.5
  IN1 w0.094: v2(87.47,35.09) 88.36,35.09 88.77,35.49 88.77,35.68 88.91,35.83 88.91,35.97 89,36.05 89.14,36.05 89.79,36.7 93.77,36.7 97.85,40.77 v6(97.85,42.32)
  BOTTOM w0.127: UV1.AC25 101.29,45.69 100.9,45.3 100.5,45.3 100.11,44.92 100.11,44.11 98.73,42.72 98.11,42.72 97.85,42.46 v6(97.85,42.32)
FB_A_D52: length 18.3
  IN1 w0.094: v6(98.49,46.14) 97.34,46.14 95.25,44.04 95.25,41.94 95.04,41.73 94.59,41.73 94.53,41.8 94.08,41.8 92.93,40.64 92.93,40.54 92.07,39.69 91.73,39.69 91.49,39.93 91.14,39.93 90.98,39.78 90.62,39.78 90.44,39.96 88.1,39.96 87.63,39.48 87.26,39.48 86.48,38.7 86.48,38.34 v2(86.9,37.92)
  BOTTOM w0.127: UV1.AA27 98.7,46.34 v6(98.49,46.14)
FB_A_D53: length 19.9
  IN1 w0.094: v2(85.77,36.79) 85.94,36.95 85.94,37.01 86.42,37.49 87.29,37.49 87.54,37.49 87.56,37.49 88.06,37.99 88.34,37.99 88.65,38.3 90.99,38.3 91.14,38.15 93.21,38.15 96.27,41.21 96.27,43.31 96.78,43.82 96.78,43.82 97.02,44.06 97.02,44.06 97.46,44.5 97.46,44.51 97.7,44.74 97.7,44.74 98.07,45.11 98.07,45.11 98.3,45.35 98.31,45.35 98.5,45.54 v6(99.11,45.54)
  BOTTOM w0.127: UV1.AA26 99.43,46.78 99.43,46.22 99.11,45.9 v6(99.11,45.54)
FB_A_D54: length 18.5
  TOP w0.127: UV8.F11 v2(86.86,38.48)
  IN1 w0.094: v6(96.62,44.22) 95.76,43.36 95.76,41.88 95.21,41.33 94.96,41.33 93.29,39.67 93.29,39.52 92.76,38.99 90.63,38.99 90.49,39.13 87.9,39.13 87.47,38.7 87.07,38.7 v2(86.86,38.48)
  BOTTOM w0.127: UV1.W26 98.51,47.96 98.51,47.18 v1(96.62,45.29) v6(96.62,44.22)
FB_A_D55: length 28.4
  IN1 w0.094: v2(85.21,37.35) 85.21,36.12 86.15,35.18 86.82,35.18 87.87,34.12 89.34,34.12 89.65,34.43 90.35,34.43 90.48,34.55 93.88,34.55 101.04,41.71 101.04,42.04 101.04,44.02 100.14,44.93 v6(100.14,48.07)
  BOTTOM w0.127: UV1.Y25 v6(100.14,48.07)
FB_A_D56: length 24.8
  TOP w0.127: UV8.A4 93.41,39.33 v6(93.41,38.94)
  IN3 w0.094: v5(95.5,50.42) 95.44,50.47 93.22,50.47 91.15,48.4 88.79,48.4 87.71,47.32 87.71,46.61 87,45.91 86.87,45.91 86.4,45.44 86.4,43.63 87.07,42.97 87.07,42.07 88,41.14 88,40.58 89.9,38.68 93.15,38.68 v6(93.41,38.94)
  BOTTOM w0.127: UV1.R26 v5(95.5,50.42)
FB_A_D57: length 25.6
  TOP w0.127: UV8.A2 v6(94.75,40.26)
  IN3 w0.094: v5(97.18,50.42) 96.79,50.02 95.27,50.02 95.22,50.07 93.38,50.07 91.31,48 89.63,48 89.01,47.37 88.71,47.37 88.16,46.83 88.16,46.48 88.16,46.47 87.37,45.68 87.37,44.13 87.65,43.85 87.65,42.05 88.4,41.3 88.4,40.74 90.07,39.08 92.76,39.08 93.94,40.26 v6(94.75,40.26)
FB_A_D58: length 20.8
  TOP w0.127: UV8.B4 v6(92.56,39.61)
  IN3 w0.094: v6(92.56,39.61) 91.81,39.61 91.36,40.05 91.23,40.05 90.7,39.52 90.19,39.52 88.8,40.91 88.8,42.88 88.07,43.61 88.07,44 87.76,44.3 87.76,45.5 88.61,46.35 88.61,46.58 88.99,46.95 89.95,46.95 90.36,47.36 91.82,47.36 94.09,49.63 v5(94.79,49.63)
  BOTTOM w0.127: v5(94.79,49.63) 94.3,50.11 UV1.N27
FB_A_D59: length 20.2
  TOP w0.127: UV8.B2 v6(94.24,41.31)
  IN3 w0.094: v5(94.25,49.05) 94.08,49.05 91.88,46.85 90.74,46.85 90.45,46.57 90.22,46.57 90,46.35 89.63,46.35 89.27,45.99 88.91,45.99 88.16,45.25 88.16,44.46 88.6,44.02 88.6,43.64 89.2,43.04 89.2,41.08 89.93,40.35 90.38,40.35 90.65,40.61 93.54,40.61 v6(94.24,41.31)
  BOTTOM w0.127: v5(94.25,49.05) 94.31,48.99 94.73,48.99 95.49,49.74 UV1.R27
FB_A_D60: length 12.1
  TOP w0.127: UV8.E4 90.83,41.91 90.83,42.43 91.41,43.01 v6(91.41,43.02)
  IN3 w0.094: v6(91.41,43.02) 91.32,43.02 91.13,43.21 91.13,43.41 90.91,43.62 90.91,44.37 91.21,44.67 91.63,44.67 91.64,44.68 91.94,44.68 94.15,46.89 95.08,46.89 v5(95.59,47.4)
  BOTTOM w0.127: v5(95.59,47.4) 95.66,47.33 96.28,47.33 96.44,47.5 97.19,47.5 97.68,47.98 97.68,48.53 UV1.V26
FB_A_D61: length 9.9
  TOP w0.127: v6(92.03,43.59) 92.03,43.04 UV8.E2
  IN3 w0.094: v5(96.24,47.96) 96.24,47.35 94.54,45.65 94.39,45.65 94.13,45.91 93.97,45.91 93.86,45.8 93.86,45.64 94.12,45.38 94.12,45.23 94.01,45.12 93.85,45.12 93.6,45.37 93.44,45.37 93.33,45.26 93.33,45.11 93.59,44.85 93.59,44.7 93.35,44.46 92.94,44.46 92.61,44.12 92.56,44.12 v6(92.03,43.59)
  BOTTOM w0.127: UV1.V27 97.11,47.96 v5(96.24,47.96)
FB_A_D62: length 14
  TOP w0.127: UV8.F4 90.3,41.86 89.68,41.24 v6(89.6,41.24)
  IN3 w0.094: v6(89.6,41.24) 89.78,41.24 89.84,41.3 90.59,41.3 90.88,41.01 93.18,41.01 94.24,42.08 94.24,42.24 95.19,43.18 95.19,44.85 96.74,46.4 v5(96.74,46.9)
  BOTTOM w0.127: v5(96.74,46.9) 97.02,47.18 97.4,47.18 97.74,47.53 UV1.W27
FB_A_D63: length 13.1
  TOP w0.127: v6(91.41,44.18) 91.41,43.59 UV8.F2
  IN3 w0.094: v6(91.41,44.18) 91.41,44.17 91.61,43.98 91.61,43.42 92.03,42.99 93.43,42.99 93.74,43.3 94.32,43.3 94.6,43.57 94.6,44.82 v5(96.1,46.32)
  BOTTOM w0.127: v5(96.1,46.32) 96.28,46.14 96.75,46.14 97.4,46.79 97.71,46.79 98.21,47.28 98.21,47.72 97.98,47.94 97.98,48.27 98.37,48.66 UV1.W25
FB_A_DBI0: length 36.3
  TOP w0.127: UV6.D2 v2(87.78,76.86)
  IN1 w0.094: v6(93.68,60.42) 93.68,59.64 93.4,59.36 92.7,59.36 92.64,59.42 91.42,59.42 91.14,59.14 85.76,59.14 78.69,66.2 78.69,70.49 83.16,74.96 85.09,74.96 85.42,75.29 85.42,75.47 87.03,77.07 87.66,77.07 87.78,76.94 v2(87.78,76.86)
  BOTTOM w0.127: UV1.D19 v6(93.68,60.42)
FB_A_DBI1: length 7.9
  TOP w0.127: UV6.D13 v6(94.01,69.65)
  IN3 w0.094: v5(97.01,64.02) 97.01,64.63 96.09,65.56 96.09,65.76 95.88,65.97 95.88,66.86 95.55,67.18 95.55,67.9 94.32,69.14 94.32,69.34 v6(94.01,69.65)
  BOTTOM w0.127: UV1.D14 96.87,63.88 v5(97.01,64.02)
FB_A_DBI2: length 17.4
  TOP w0.127: v2(87.69,64.6) 87.79,64.6 87.91,64.48 88.29,64.48 88.35,64.54
  IN1 w0.094: v6(94.84,62.69) 94.84,63.43 92.9,65.37 92.9,65.97 89.94,68.92 88.05,68.92 86.32,67.2 86.32,66.77 86.7,66.38 86.7,65.02 87.12,64.6 v2(87.69,64.6)
  BOTTOM w0.127: UV1.C17 v6(94.84,62.69)
FB_A_DBI3: length 18.2
  TOP w0.127: 82.13,70.76 81.59,70.76 v6(81.59,70.77)
  IN3 w0.094: v6(81.59,70.77) 82.12,70.24 82.12,69.6 82.61,69.1 82.76,69.1 83.65,68.21 83.65,67.59 83.23,67.18 83.23,64.47 86.65,61.05 89.34,61.05 90.18,60.2 v5(91.21,60.2)
  BOTTOM w0.127: v5(91.21,60.2) 91.21,60.04 91.36,59.89 UV1.C22
FB_A_DBI4: length 15.1
  TOP w0.127: v2(86.41,48) 86.52,48.1 UV8.P2
  IN1 w0.094: v2(86.41,48) 86.42,47.99 86.42,47.45 86.8,47.06 86.8,47.06 86.96,46.91 87.06,46.91 87.48,46.48 87.48,46.21 87.83,45.86 89.14,45.86 89.71,46.43 90.26,46.43 90.59,46.77 91.46,46.77 95.3,50.61 95.3,50.82 96.08,51.6 v6(96.58,51.6)
  BOTTOM w0.127: v6(96.58,51.6) 96.59,51.61 UV1.P24
FB_A_DBI5: length 35.9
  TOP w0.127: UV8.P13 v6(81.21,41.88)
  IN3 w0.094: v6(81.21,41.88) 81.76,41.88 82.25,42.38 82.47,42.38 83.38,41.46 83.38,40.9 83.05,40.57 83.05,39.16 83.36,38.86 83.36,38.58 86.56,35.38 88.79,35.38 89.47,36.06 94.6,36.06 98.2,39.66 98.2,40.3 100.82,42.93 100.82,45.82 100.47,46.17 100.47,46.53 99.49,47.51 v5(99.49,47.61)
  BOTTOM w0.127: v5(99.49,47.61) 99.4,47.61 99.12,47.89 99.12,48.27 99.5,48.66 UV1.W24
FB_A_DBI6: length 22.1
  TOP w0.127: UV8.D13 86.34,35.66 v2(86.35,35.65)
  IN1 w0.094: v6(97.86,44.34) 97.94,44.26 97.94,43.72 96.74,42.51 96.74,41.01 93.4,37.68 89.36,37.68 88.86,37.17 88.41,37.17 88.2,36.96 88.14,36.96 87.59,36.41 87.26,36.41 87.19,36.48 86.84,36.48 86.35,35.98 v2(86.35,35.65)
  BOTTOM w0.127: v6(97.86,44.34) 97.86,44.93 98.3,45.37 98.3,45.72 98.04,45.98 98.04,46.31 98.65,46.92 99.01,46.92 99.39,47.29 99.95,47.29 UV1.AA25
FB_A_DBI7: length 14.6
  TOP w0.127: v6(92.6,41.89) 92.6,41.89 92.6,42.4 UV8.D2
  IN3 w0.094: v5(94.9,48.53) 94.9,48.41 92.23,45.73 91.46,45.73 90.21,44.48 90.21,43.66 90.65,43.21 90.65,42.86 91,42.52 91.28,42.52 91.82,41.98 92.51,41.98 v6(92.6,41.89)
  BOTTOM w0.127: v5(94.9,48.53) 94.93,48.5 95.9,48.5 97.22,49.82 UV1.U25
FB_A_EDC0: length 43.2
  TOP w0.127: v2(88.87,76.99) 88.82,77.05 88.41,77.05 UV6.C2
  IN1 w0.094: v6(94.24,59.78) 94.24,59.25 93.59,58.6 92.48,58.6 92.14,58.26 91.41,58.26 91.01,58.66 85.56,58.66 78.22,66 78.22,70.68 82.97,75.43 84.1,75.43 84.65,75.98 84.95,75.98 85.27,76.31 85.27,76.54 85.88,77.14 85.88,77.4 85.79,77.49 84.58,77.49 84.48,77.59 84.48,77.71 84.59,77.83 87.62,77.83 88.46,76.99 v2(88.87,76.99)
  BOTTOM w0.127: UV1.E19 v6(94.24,59.78)
FB_A_EDC1: length 11.1
  TOP w0.127: UV6.C13 v6(94.57,71.34)
  IN3 w0.094: v6(94.57,71.34) 94.16,70.93 93.85,70.93 92.85,69.93 92.85,68.98 93.27,68.56 94.15,68.56 95,67.71 95,67.06 95.4,66.66 95.4,65.74 v5(95.61,65.53)
  BOTTOM w0.127: UV1.C15 95.35,63.93 95.35,64.49 95.07,64.77 95.07,65.23 95.37,65.53 v5(95.61,65.53)
FB_A_EDC2: length 14.6
  TOP w0.127: UV6.R13 v2(88.33,63.98)
  IN1 w0.094: v6(94.26,63.31) 92.37,65.2 92.37,65.73 91.68,66.42 90.99,66.42 89.56,67.85 89.56,68.01 89.24,68.33 88.77,68.33 88.23,67.78 88.23,67.66 87.46,66.88 87.46,66.75 87.64,66.56 87.64,66.11 87.36,65.82 87.36,65.53 88.33,64.56 v2(88.33,63.98)
  BOTTOM w0.127: v6(94.26,63.31) 94.3,63.34 UV1.B16
FB_A_EDC3: length 16.3
  TOP w0.127: UV6.R2 81.5,70.13 81.5,69.74 v6(81.56,69.67)
  IN3 w0.094: v5(89.57,60.39) 89.32,60.39 89.14,60.57 86.38,60.57 82.73,64.22 82.73,67.47 82.09,68.11 82.09,68.7 81.56,69.23 v6(81.56,69.67)
  BOTTOM w0.127: v5(89.57,60.39) 89.66,60.48 90.33,60.48 90.47,60.34 UV1.B22
FB_A_EDC4: length 17.8
  TOP w0.127: v2(86.34,48.67) UV8.R2
  IN1 w0.094: v6(96.06,50.96) 96.06,50.69 91.17,45.8 90.27,45.8 89.29,44.82 89.04,44.82 88.61,45.25 88.32,45.25 88.07,45 87.6,45 87.5,45.1 87.5,45.32 86.97,45.85 86.6,45.85 86.39,46.06 86.39,46.81 86.17,47.02 85.78,47.02 85.25,47.55 85.25,48.01 85.38,48.14 85.86,48.14 86.22,48.5 86.22,48.55 v2(86.34,48.67)
  BOTTOM w0.127: UV1.R25 96.08,50.98 v6(96.06,50.96)
FB_A_EDC5: length 37.9
  TOP w0.127: v6(80.11,41.86) UV8.R13
  IN3 w0.094: v6(80.11,41.86) 80.57,41.86 81.63,42.92 82.64,42.92 83.17,42.39 83.68,42.39 83.94,42.13 83.94,40.79 83.62,40.46 83.62,40.06 84.66,39.02 84.66,37.95 85.36,37.25 86.66,37.25 86.96,36.96 86.96,36.36 87.47,35.85 88.59,35.85 89.28,36.53 94.4,36.53 97.72,39.86 97.72,40.59 98.91,41.78 98.91,42.74 100.35,44.18 100.35,45.53 99.96,45.91 99.96,46.29 98.98,47.28 98.98,48.01 100.13,49.16 v5(100.13,49.25)
  BOTTOM w0.127: v5(100.13,49.25) 100.07,49.31 UV1.W23
FB_A_EDC6: length 19.7
  TOP w0.127: UV8.C13 v2(87.33,35.66)
  IN1 w0.094: v2(87.33,35.66) 88.07,35.66 88.44,36.02 88.44,36.24 88.72,36.53 88.94,36.53 89.61,37.2 93.6,37.2 97.37,40.97 97.37,42.44 v6(98.25,43.33)
  BOTTOM w0.127: UV1.AB26 100.3,46.17 100.3,45.52 99.83,45.04 99.83,44.54 98.88,43.59 98.52,43.59 v6(98.25,43.33)
FB_A_EDC7: length 17.4
  TOP w0.127: UV8.C2 93.15,41.91 v6(93.15,42.46)
  IN3 w0.094: v6(93.15,42.46) 93.15,42.39 93.02,42.26 93.02,41.64 92.86,41.49 91.64,41.49 91.35,41.77 90.9,41.77 90.71,41.97 90.07,41.97 89.78,42.25 89.78,43.45 89.56,43.67 89.56,44.25 89.28,44.53 89.28,44.8 90.26,45.78 90.84,45.78 91.27,46.22 91.91,46.22 94.85,49.15 95.47,49.15 v5(95.48,49.15)
  BOTTOM w0.127: v5(95.48,49.15) 95.48,49.3 96.03,49.85 UV1.T26
FB_A_MF: length 3.4
  TOP w0.081: UV6.J1 83.88,74.67 82.28,74.67 81.54,75.41 RV116.1
FB_A_SEN: length 1.9
  TOP w0.081: v6(89.05,69.42) 89.13,69.42 89.48,69.07
  BOTTOM w0.081: RV118.1 88.81,69.42 v6(89.05,69.42) 89.05,69.88 v1(88.8,70.13)
FB_A_WCK0: length 21.1
  TOP w0.102: v6(88.92,74.74) UV6.D4
  IN3 w0.089: v6(88.92,74.74) 89.21,74.74 89.95,74 89.95,73.36 87.13,70.54 87.13,68.63 88.01,67.75 88.01,66.61 88.96,65.66 88.96,64.85 89.89,63.92 91.65,63.92 92.14,63.43 92.14,62.36 92.46,62.04 93.05,62.04 93.29,62.29 93.29,62.45 93.38,62.54 v5(93.57,62.54)
  BOTTOM w0.102: v5(93.57,62.54) 93.79,62.54 94.24,62.08 UV1.D18
FB_A_WCK1: length 20.9
  TOP w0.102: UV6.P4 v2(83.26,69.19)
  IN1 w0.089: v6(94.84,61.53) 94.84,61.82 94.17,62.49 93.23,62.49 92.33,61.58 90.54,61.58 90.49,61.64 86.38,61.64 83.13,64.88 83.13,65.45 83.05,65.54 82.64,65.54 82.42,65.76 82.42,66.35 82.61,66.53 83.05,66.53 83.13,66.62 83.13,67.36 83.69,67.92 83.69,68.23 83.41,68.51 83.41,69.03 v2(83.26,69.19)
  BOTTOM w0.102: v6(94.84,61.53) UV1.D17
FB_A_WCK2: length 19.9
  TOP w0.102: UV8.P4 v6(85.77,46.41)
  IN3 w0.089: v5(98.35,50.9) 98.1,50.9 97.72,51.28 97.72,51.55 97,52.27 95.69,52.27 94.57,51.14 92.94,51.14 91.59,49.8 87.81,49.8 86.21,48.2 85.07,48.2 84.6,47.73 84.6,46.76 85.06,46.3 85.35,46.3 85.47,46.41 v6(85.77,46.41)
  BOTTOM w0.102: UV1.T24 97.83,50.9 v5(98.35,50.9)
FB_A_WCK3: length 14.6
  TOP w0.102: v2(91.38,40.63) 91.43,40.68 UV8.D4
  IN1 w0.089: v6(98.39,49.84) 98.39,49.57 98.69,49.27 98.69,48.53 94.74,44.59 94.74,42.67 94.35,42.27 93.89,42.27 92.8,41.19 91.72,41.19 91.38,40.85 v2(91.38,40.63)
  BOTTOM w0.102: v6(98.39,49.84) 98.89,49.84 UV1.V24
FB_A_WCK#0: length 21.2
  TOP w0.102: v6(89.51,75.32) 89.48,75.32 89.38,75.22 89.38,74.83 UV6.D5
  IN3 w0.089: v6(89.51,75.32) 89.26,75.07 89.26,74.98 90.16,74.08 90.16,73.28 87.34,70.46 87.34,68.71 88.22,67.83 88.22,66.7 89.17,65.75 89.17,64.94 89.98,64.13 91.73,64.13 92.34,63.52 92.34,62.44 92.54,62.24 92.96,62.24 93.09,62.37 93.09,62.52 92.94,62.67 92.77,62.67 v5(92.64,62.55)
  BOTTOM w0.102: v5(92.64,62.55) 93.09,62.1 UV1.C18
FB_A_WCK#1: length 20.9
  TOP w0.102: v2(83.89,68.71) 83.82,68.77 83.82,69.07
  IN1 w0.089: v6(95.43,62.13) 95.43,62.03 95.29,61.89 95.06,61.89 94.25,62.69 93.15,62.69 92.24,61.79 90.62,61.79 90.57,61.84 86.46,61.84 83.33,64.97 83.33,65.54 83.13,65.74 82.73,65.74 82.63,65.84 82.63,66.26 82.7,66.33 83.13,66.33 83.33,66.53 83.33,67.27 83.9,67.83 83.9,68.32 83.62,68.59 83.62,68.78 83.68,68.85 83.75,68.85 v2(83.89,68.71)
  BOTTOM w0.102: UV1.D16 v6(95.43,62.13)
FB_A_WCK#2: length 19.9
  TOP w0.102: UV8.P5 v6(85.21,47)
  IN3 w0.089: v6(85.21,47) 85.42,47.22 85.55,47.22 85.68,47.08 85.68,46.91 85.27,46.5 85.14,46.5 84.8,46.84 84.8,47.64 85.15,47.99 86.29,47.99 87.89,49.6 91.68,49.6 93.02,50.94 94.65,50.94 95.78,52.07 96.92,52.07 97.52,51.47 97.52,51.19 97.89,50.82 v5(97.89,50.48)
  BOTTOM w0.102: v5(97.89,50.48) 98.04,50.33 98.29,50.33 UV1.U24
FB_A_WCK#3: length 14.6
  TOP w0.102: UV8.D5 90.86,41.11 v2(90.99,41.23)
  IN1 w0.089: v6(97.82,49.22) 98.04,49.44 98.23,49.44 98.49,49.18 98.49,48.62 94.54,44.67 94.54,42.75 94.26,42.47 93.8,42.47 92.72,41.39 91.63,41.39 91.22,40.98 91.07,40.98 90.99,41.06 v2(90.99,41.23)
  BOTTOM w0.102: UV1.V25 98.31,49.29 97.89,49.29 v6(97.82,49.22)
FB_A_ZQ: length 3.1
  TOP w0.081: RV120.1 93.1,65.64 93.1,65.98 91.71,67.37 UV6.J13
FB_B_MF: length 1.5
  TOP w0.081: UV8.J1 v6(90.73,46.27)
  BOTTOM w0.089: v6(90.73,46.27) 90.84,46.27 91.15,46.58 91.15,46.77 RV2453.1
FB_B_SEN: length 1.7
  TOP w0.081: v6(85.7,41.2) 85.66,41.2 85.21,40.75 UV8.J10
  BOTTOM w0.089: v6(85.7,41.2) 85.49,41.41 RV2448.1
FB_B_ZQ: length 5.5
  TOP w0.081: UV8.J13 83.51,38.48 83.12,38.08 82.84,38.08 82.42,37.66 80.76,37.66 79.66,36.57 79.6,36.57 RV2451.1
FB_CAL_PD_VDDQ: length 12.2
  IN3 w0.064: v5(85.88,52.6) 87.85,52.6 91.02,55.77 91.02,56.48 91.45,56.91 92.01,56.91 93,57.9 93,58.13 v5(91.92,59.21)
  BOTTOM w0.089: RV41.1 85.84,51.92 85.84,52.56 v5(85.88,52.6)
FB_CAL_PU_GND: length 8.8
  IN3 w0.064: v5(90.16,58.58) 90.08,58.58 89.67,58.17 89.67,57.87 89.98,57.57 89.98,57.24 89.07,56.33 87.71,56.33 84.96,53.58 v5(84.96,53.32)
  BOTTOM w0.089: RV42.2 v5(84.96,53.32)
FB_CALTERM_GND: length 8.6
  IN3 w0.064: v5(89.47,58.56) 89.47,58.42 89.4,58.35 89.4,57.84 88.34,56.78 86.78,56.78 86.27,56.28 86.27,55.46 84.59,53.79 v5(84.54,53.79)
  BOTTOM w0.089: RV43.2 v5(84.54,53.79) ; v5(89.47,58.56) 89.33,58.56 89.31,58.58 UV1.B25
FB_GPU: length 3.3
  TOP w0.254: PRV44.1 43.07,62.58 42.06,61.57 41.07,61.57 40.91,61.73 PUV01.10
FB_VREF: length 10
  IN3 w0.064: v5(85.05,52.67) 85.44,53.06 87.07,53.06 91.4,57.39 91.4,58.54 v5(91.32,58.61)
  BOTTOM w0.089: v5(85.05,52.67) T4988.1
FBRTN_GPU: length 3.1
  TOP w0.254: PUV01.9 40.51,61.56 40.94,61.13 42.13,61.13 PRV47.1
FPR_SCAN#: length 69
  TOP w0.081: v2(50.03,25.78) 50.18,25.93 UE1.B28
  IN1 w0.064: v4(49.33,25.72) 49.38,25.78 v2(50.03,25.78)
  IN2 w0.066: v4(94.64,8.65) 94.44,8.65 94.01,8.22 91.24,8.22 91.06,8.04 81.85,8.04 80.93,7.13 78.33,7.13 78.07,7.39 78.07,7.84 78.01,7.9 75.96,7.9 75.89,7.83 75.89,7.17 75.48,6.75 60.98,6.75 59.17,8.57 59.17,9.1 59.58,9.51 59.58,13.72 56.9,16.39 56.43,16.39 54.81,18.01 54.81,18.25 53.59,19.48 53.13,19.48 52.21,20.4 51.04,20.4 50.33,21.11 50.33,22.86 50.47,23 50.47,24.58 v4(49.33,25.72)
  IN3 w0.064: v4(94.64,8.65) 94.8,8.81 94.8,8.97 95,9.17 97.71,9.17 v5(97.86,9.32)
  BOTTOM w0.081: v1(97.62,11.35) R5.2 97.62,9.91 97.86,9.68 v5(97.86,9.32) Q27.1
FPR_SCAN#_CONN: length 26
  IN3 w0.064: v5(91.53,12.54) 91.53,12.61 92.1,13.18 v5(92.26,13.18)
  BOTTOM w0.081: 98.16,11.8 98.54,11.42 v1(98.54,10.16) 98.54,6.24 98.36,6.06 96.95,6.06 96.49,6.52 Q27.3 ; 98.16,11.8 97.51,11.8 96.79,11.08 R6.2 ; 98.16,11.8 98.16,12.96 98.36,13.16 98.36,14.62 98.15,14.83 92.58,14.83 92.26,14.52 v5(92.26,13.18) ; JFP1.2 91.3,9.2 ED11.5 ED11.6 91.3,12.31 v5(91.53,12.54)
GC6_FB_EN1V8: length 10.4
  BOTTOM w0.081: UV1.B2 103.02,72.01 103.85,72.84 103.85,73.55 103.18,74.21 103.18,75.82 RV88.1 104.05,76.68 106.14,76.68 106.73,76.09 106.73,75.57 107.1,75.19 QV8.2
GC6_FB_EN3V3: length 106.8
  TOP w0.081: v2(139.59,56.39) 139.59,56.67 139.12,57.14 138.19,57.14 137.99,57.34 136.31,57.34 v1(134.7,58.95) 134.26,59.38 134.26,60.58 130.81,64.03 129.22,64.03 128.75,64.51 124.56,64.51 124.24,64.18 123.93,63.87 118.04,63.87 116.83,62.66 116.83,61.22 v2(116.95,61.1) ; QV150.2 112.34,47.8 112.11,48.03 112.11,48.23 112.61,48.73 112.98,48.73 113.18,48.53 113.43,48.53 RV113.2 113.53,48.68 113.2,49.01 112.36,49.01 110.96,47.62 v2(110.96,47.29) ; v2(109.03,45.84) 106.45,43.26 106.45,41.69 107.06,41.08 109.26,41.08 111.55,38.79 118.75,38.79 119.16,39.2 119.16,40.08 119.66,40.58 119.9,40.58 UV23.2
  IN1 w0.064: v2(139.59,56.39) 139.88,56.39 140.37,55.89 141.44,55.89 141.89,55.44 142.06,55.44 142.21,55.3 142.51,55.3 v4(142.57,55.36) ; v2(110.96,47.29) 110.96,46.83 109.97,45.84 v2(109.03,45.84) 109,45.84 108.79,46.05 108.79,47.11 109.26,47.59 109.81,47.59 110.72,48.49 110.72,50.03 109.37,51.37 109.37,55.9 112.16,58.69 113.91,58.69 114.28,59.06 115.25,59.06 115.41,58.9 116.48,58.9 116.95,59.36 v2(116.95,61.1) 115.68,62.37 115.68,66.55 109.89,72.33 v6(109.89,72.58)
  IN3 w0.064: v5(142.57,54.94) v4(142.57,55.36)
  BOTTOM w0.081: v5(142.57,54.94) 142.37,54.74 UC1.CA31 ; v6(109.89,72.58) 109.78,72.47 108.93,72.47 108.5,72.9 108.5,75.35 108.01,75.84 QV8.3
GC6_FB_EN3V3_Q: length 2.5
  BOTTOM w0.081: QV8.5 QV8.6 109.22,74.54 RV111.2 109.22,72.94 v1(109.07,72.79)
GPIO5: length 7.9
  TOP w0.081: RM51.2 20.77,35.06 20.45,35.39 20.45,37.29 20.21,37.53 18.83,37.53 18.73,37.63 RM60.2 18.81,37.9 20.53,37.9 20.61,37.82 21.08,37.82 21.31,38.05 UM1.44
GPIO_0: length 2.2
  BOTTOM w0.081: RT505.1 32.84,51.77 32.54,52.07 32.54,52.27 31.88,52.92 31.75,52.92 31.59,53.08 UT1.W1
GPIO_1: length 4.2
  BOTTOM w0.081: RT506.1 34.01,51.59 33.89,51.47 32.81,51.47 32.36,51.91 32.36,52.19 31.82,52.74 31.68,52.74 31.57,52.84 31.08,52.84 30.94,52.98 UT1.W2
GPIO_3: length 2.3
  BOTTOM w0.081: RT507.1 32.91,51.13 32.2,51.85 32.2,52.1 31.73,52.57 31.46,52.57 UT1.Y1
GPP_B22: length 1.4
  TOP w0.081: v2(142.27,54.1) 142.27,54.27 142.44,54.44 RC115.2
  IN1 w0.064: v4(141.92,54.02) 142.1,54.02 142.19,54.1 v2(142.27,54.1)
  IN3 w0.064: v4(141.92,54.02) v5(142.37,54.02)
GPP_B23: length 3.9
  TOP w0.081: v1(140.18,56.81) 140.18,57.13 v2(140.32,57.27) 140.32,57.6 140.88,58.16 141.37,58.16 RC46.1
  IN1 w0.064: v2(140.32,57.27) 140.49,57.27 140.88,56.88 v4(140.88,56.82)
  IN3 w0.064: v5(141.2,56.36) 141.2,56.51 v4(140.88,56.82)
GPP_C2: length 1.8
  TOP w0.081: RC38.1 137.94,44.64 v2(138.16,44.86)
  IN1 w0.064: v4(138.33,45.29) 138.16,45.12 v2(138.16,44.86)
  IN3 w0.064: v5(137.89,44.71) 137.9,44.71 138.33,45.14 v4(138.33,45.29)
GPP_C5: length 3.3
  TOP w0.081: v1(140.14,45.4) 140.14,45.22 v2(139.53,44.6) 139.38,44.45 RC44.1
  IN1 w0.064: v2(139.53,44.6) 139.65,44.6 139.66,44.62 139.79,44.62 v4(139.86,44.54)
  IN3 w0.064: v5(139.49,44.92) 139.76,44.64 139.8,44.64 139.86,44.58 v4(139.86,44.54)
  BOTTOM w0.081: UC1.CG15 139.39,44.92 v5(139.49,44.92)
GPP_D12: length 4.7
  BOTTOM w0.081: RC568.2 131.75,49.69 132.53,49.69 132.66,49.56 RC567.2 133.52,48.53 134.81,48.53 135.15,48.87 UC1.CP22
GPP_H21: length 2
  TOP w0.081: RC62.1 v2(140.58,50.55) v1(140.04,50.55)
  IN1 w0.064: v2(140.58,50.55) 140.58,50.64 140.28,50.94 v4(140.28,50.94)
  IN3 w0.064: v4(140.28,50.94) v5(139.84,50.94)
GPP_H23: length 6.1
  BOTTOM w0.081: RC65.1 131.2,50.99 131.31,50.89 132.61,50.89 v1(132.69,50.97) 133.01,50.97 133.77,51.73 135.69,51.73 135.89,51.81 135.96,51.81 136.15,51.73 136.41,51.48 UC1.CM26
GPS_DISABLE#: length 128.2
  TOP w0.081: v2(90.18,19.68) v1(89.7,19.2) 88.68,18.18 88.68,14.9 88.03,14.24 88.03,14.18 86.89,13.04 86.89,12.66 85.39,11.16 84.84,11.16 v2(84.73,11.05) ; v2(139.46,49.58) 139.6,49.72 RC566.1 ; v2(64.83,13.31) 65.68,14.17 65.68,24.38 66.03,24.72 66.03,35.83 64.5,37.36 QN8.6
  IN1 w0.064: v2(84.73,11.05) 84.69,11.01 84,11.01 83.74,11.28 83.16,11.28 83.02,11.42 75.05,11.42 74.75,11.12 72.49,11.12 71.57,12.04 64.53,12.04 64.33,12.24 64.33,12.81 v2(64.83,13.31) ; v2(139.46,49.58) 139.68,49.36 v4(139.87,49.36) ; v2(90.18,19.68) 90.21,19.68 v4(90.91,20.37)
  IN2 w0.066: v4(90.91,20.37) 91.3,20.77 96.31,20.77 97.4,21.86 114.59,21.86 118.11,25.38 118.11,28.98 118.99,29.86 119.4,29.86 122.78,33.25 123,33.25 123.48,33.25 126.28,36.04 126.28,39.36 128.23,41.31 129.1,41.31 129.39,41.31 134.29,46.21 134.48,46.21 135.79,47.52 136.33,47.52 136.61,47.24 137.22,47.24 137.25,47.27 137.67,47.69 138.13,47.69 138.35,47.91 138.91,47.91 139.49,48.49 139.49,49.19 139.66,49.36 v4(139.87,49.36)
  IN3 w0.064: v5(139.19,48.86) 139.69,49.36 v4(139.87,49.36)
GPS_DISABLE#_R: length 13.9
  TOP w0.081: QN8.1 61.95,37.72 61.77,37.91 v1(61.77,38.89) 61.77,40.98 61.49,41.25 61.49,42.52 61.37,42.65 61.37,43.95 61.25,44.07 61.25,44.85 v6(61.19,44.91)
  BOTTOM w0.081: JNGFF1.26 59.01,46.32 60.48,44.86 61.13,44.86 v6(61.19,44.91)
GPU_B+: length 7.9
  TOP w0.254: 49.42,60.31 49.43,60.3 49.43,60.25 49.24,60.07 45.92,60.07 45.17,60.82 45.17,62.87 44.7,63.34 PRV34.2
  vias: v3(53.34,64.3) v6(51.42,65.7) v6(51.42,65.1) v6(51.66,73.73) v6(51.89,72.3) v6(51.99,64.87) v6(52.25,73.73) v6(52.48,72.3) v6(52.55,64.87)
GPU_CORE_PG: length 132.5
  TOP w0.081: UV11.1 117.78,42.55 117.67,42.55 117.53,42.7 RV4997.2 117.53,42.73 117.42,42.84 116.26,42.84 v2(116.24,42.86) ; PRV43.2 38.63,66.76 39.06,66.33 v2(39.06,66.25) 38.99,66.18 38.99,65.79 38.56,65.36 PUV01.1 ; QV150.4 113.37,45.89 113.37,45.35 113.65,45.07 v2(113.84,44.88)
  IN1 w0.064: v4(40.5,66.43) 40.5,66.04 40.2,65.74 39.32,65.74 39.06,66 v2(39.06,66.25) ; v2(113.84,44.88) 114.66,44.88 115.81,43.73 115.81,43.29 v2(116.24,42.86) 116.24,41.99 118.34,39.9 118.34,39.19 117.73,38.58 117.25,38.58 116.47,39.37 116.02,39.37 115.68,39.03 111.48,39.03 110.28,40.23 v2(109.68,40.23) 109.09,40.82 105.19,40.82 102.24,37.87 102.24,37.5 99.53,34.8 99.53,33.44 97.71,31.62 92.09,31.62 91.66,31.19 86.65,31.19 86.06,31.78 83.18,31.78 83.18,31.79 83.07,31.79 83.07,31.79 83,31.79 79.22,35.57 78.01,35.57 76.74,34.31 75,34.31 74.19,35.11 70.83,35.11 69.91,36.03 58.39,36.03 57.63,36.79 51.77,36.79 49.6,38.95 48.82,38.95 45.68,42.1 45.68,47.91 44.55,49.04 44.55,52.42 46.64,54.51 46.64,59.22 47.28,59.86 47.28,62.71 46.06,63.93 46.06,64.69 45.87,64.88 v4(45.74,64.88)
  IN3 w0.064: v4(40.5,66.43) 40.63,66.3 42.01,66.3 43.39,64.92 45.69,64.92 v4(45.74,64.88)
GPU_EVENT#: length 17.9
  TOP w0.081: DV3.1 122.47,39.86 v2(122.33,39.72)
  IN1 w0.064: v4(128.6,39.52) 127.83,38.76 126.9,38.76 126.63,38.49 123.56,38.49 v2(122.33,39.72)
  IN3 w0.064: v5(128.91,39.73) 128.71,39.52 v4(128.6,39.52)
  BOTTOM w0.081: v5(128.91,39.73) v1(128.91,40.91) 128.91,41.11 129.5,41.69 131.49,41.69 131.75,41.94 133.15,41.94 133.49,42.28 135.57,42.28 135.81,42.52 UC1.CN12
GPU_EVENT#_D: length 63.8
  TOP w0.081: DV3.2 122.15,42.37 120.7,42.37 119.9,43.17 119.57,43.17 119.27,42.88 119.27,42.69 RV72.1 119.07,42.14 118.9,42.14 116.79,40.03 116.19,40.03 115.77,39.61 111.07,39.61 109.38,41.3 107.15,41.3 106.67,41.78 106.67,42.89 v1(107.48,43.7) v2(109.21,45.43)
  IN1 w0.064: v2(109.21,45.43) 109.83,45.43 111.28,46.87 111.28,50.96 109.75,52.48 109.75,55.74 111.9,57.89 114.19,57.89 114.95,58.65 v4(115.14,58.65)
  IN3 w0.064: v4(115.14,58.65) 114.95,58.83 114.95,60.56 114.78,60.73 114.78,63.9 110.99,67.69 106.74,67.69 106.3,67.24 103.5,67.24 102.91,67.83 v5(102.58,67.83)
  BOTTOM w0.081: UV1.D6 101.81,68.55 102.53,67.83 v5(102.58,67.83)
GPU_JTAG_TCK: length 7
  BOTTOM w0.081: T4986.1 119.76,54.92 119.31,55.37 118.92,55.37 118.07,56.22 116.52,56.22 115.48,57.27 115.13,57.27 114.87,57.01 114.33,57.01 UV1.AE5
GPU_JTAG_TDI: length 8.4
  BOTTOM w0.081: UV1.AE6 113.68,56.12 114.34,56.12 114.67,55.79 114.95,55.79 115.4,55.34 115.4,55.01 115.63,54.78 117.89,54.78 118.99,53.68 118.99,52.32 T4985.1
GPU_JTAG_TDO: length 4.8
  BOTTOM w0.081: T4987.1 117.63,54.5 115.56,54.5 115.15,54.9 115.15,55.23 114.84,55.54 114.26,55.54 UV1.AF6
GPU_JTAG_TMS: length 8.1
  BOTTOM w0.081: T4984.1 119.39,53.57 117.4,55.56 116.37,55.56 115.98,55.95 115.68,55.95 114.97,56.66 114.54,56.66 114.34,56.45 113.91,56.45 113.7,56.66 113.15,56.66 UV1.AD6
GPU_JTAG_TRST#: length 5.1
  TOP w0.081: v2(115.89,56.3) v3(115.54,56.65)
  IN1 w0.064: v4(116.26,56.67) v2(115.89,56.3)
  IN3 w0.064: v4(116.26,56.67) 115.9,56.31 v5(115.9,56.31)
  BOTTOM w0.081: v5(115.9,56.31) 116.08,56.31 116.47,55.92 117.67,55.92 RV94.1
GPU_PWR_LEVEL: length 143.9
  TOP w0.081: v2(35.59,31.52) 35.59,31.69 35.7,31.79 35.7,33.19 38.45,35.94 38.45,37.42 40.91,39.88 40.91,40.3 41.57,40.96 41.57,41.69 v1(41.82,41.94) 41.82,42.04 43.4,43.61 v2(44.92,43.61) ; v2(102.07,79.34) 102.08,79.34 DV10.1
  IN1 w0.064: v2(35.59,31.52) 35.59,31 36.02,30.57 36.02,29.82 35.7,29.5 35.7,28.45 37.09,27.06 37.09,26.45 37.49,26.05 37.97,26.05 38.2,26.28 38.62,26.28 39.02,26.68 v2(40.53,26.68) ; v2(102.07,79.34) 101.4,80.01 100.07,80.01 99.78,79.72 81.19,79.72 79.41,77.94 77.17,77.94 76.44,78.68 72.09,78.68 71.36,79.4 53.29,79.4 49.97,76.08 49.97,70.42 48.79,69.24 47.18,69.24 46.92,68.98 46.37,68.98 45.6,69.75 45.18,69.75 43.84,71.09 43.84,72.42 41.6,74.66 36.99,74.66 35.93,73.6 35.93,72.38 37.74,70.57 38.84,70.57 39.75,69.66 39.75,68.51 41.08,67.18 41.08,66.09 43.1,64.07 43.37,64.07 43.37,64.07 43.87,64.07 45.01,62.93 45.01,59.81 45.22,59.61 45.22,58.26 44.73,57.77 44.73,55.41 43.92,54.6 43.92,54.03 43.9,54.01 43.9,53.41 43.59,53.09 43.59,52.46 43.92,52.13 43.92,48.78 44.73,47.97 44.73,43.8 v2(44.92,43.61)
GPU_PWR_LEVEL_R: length 10
  TOP w0.081: RV92.1 100.45,68.78 v6(100.69,68.54) 100.72,68.54 101.28,69.09 101.28,71.53 102.36,72.61 102.36,72.99 102.08,73.27 DV10.2
  BOTTOM w0.081: UV1.D7 v6(100.69,68.54)
GPU_TESTMODE: length 2.5
  TOP w0.081: RV71.1 v1(110.67,56.42)
  TOP w0.089: v2(110.27,55.6) RV71.1
  IN1 w0.064: v4(110.64,55.05) 110.64,55.23 v2(110.27,55.6)
  IN3 w0.064: v5(111.22,54.98) 111.15,55.05 v4(110.64,55.05)
GPU_THM_SMBCLK: length 283
  TOP w0.081: v2(45.24,43.28) 45.23,43.27 43.89,43.27 v1(43.45,42.83) 43.1,42.49 43.1,41 39.18,37.07 39.18,35.28 38.3,34.41 v2(38.3,33.53) ; Q28.6 72.66,71.62 72.75,71.72 72.75,72.24 73.11,72.61 v2(73.11,72.73) ; v2(135.95,44.95) 135.95,44.46 136.45,43.96 RC196.1 ; UE1.B62 41.71,23.93 41.76,23.98 41.76,24.2 41.97,24.41 v2(41.97,25.21) ; v2(36.17,69.17) 35.9,69.17 35.83,69.09 34.8,69.09 34.32,69.58 Q11.3
  IN1 w0.064: v4(106.66,79.46) 103.82,79.46 103.24,78.88 99.77,78.88 99.47,79.32 81.8,79.32 75.34,72.86 73.62,72.86 73.49,72.73 v2(73.11,72.73) 73.11,73.31 72.69,73.73 72.69,75.92 69.52,79.08 53.43,79.08 50.38,76.04 50.38,70.3 48.88,68.8 47.36,68.8 47.1,68.53 46.36,68.53 45.46,69.43 45.05,69.43 43.52,70.96 43.52,72.29 41.47,74.34 37.12,74.34 36.25,73.47 36.25,72.71 36.5,72.46 36.5,72.35 v4(36.66,72.19) 36.66,72.1 37.88,70.88 38.98,70.88 40.07,69.79 40.07,68.64 41.4,67.31 41.4,66.22 43.24,64.39 44.95,64.39 45.75,63.59 45.96,63.59 46.9,62.65 46.9,59.93 46.13,59.15 46.13,58.14 45.05,57.06 45.05,54.7 44.22,53.88 44.22,53.27 43.9,52.96 43.9,52.59 44.23,52.26 44.23,48.91 45.24,47.91 v2(45.24,43.28) 45.24,42 48.63,38.6 49.51,38.6 51.64,36.47 56.53,36.47 57.28,35.71 69.6,35.71 71.47,33.84 76.73,33.84 77.99,35.1 79.06,35.1 82.69,31.47 82.94,31.47 82.94,31.47 83.05,31.47 83.05,31.46 85.93,31.46 87.6,29.8 91.58,29.8 91.77,29.99 91.93,29.99 91.97,29.99 92.15,29.99 92.48,30.32 92.48,30.82 92.96,31.3 97.84,31.3 99.85,33.31 99.85,34.66 104.11,38.93 105.25,38.93 106.45,40.12 106.98,40.12 107.42,39.68 108.58,39.68 108.68,39.78 110.28,39.78 111.39,38.67 115.84,38.67 v4(116.17,39) ; v2(41.97,25.21) 42.5,25.73 42.5,27.32 42.02,27.79 41.73,27.79 39.68,29.84 39.68,30.82 38.92,31.57 38.92,33.14 38.66,33.4 38.43,33.4 v2(38.3,33.53) ; v2(135.95,44.95) 135.6,44.95 v4(135.54,45) ; v2(36.17,69.17) v4(36.17,69.6)
  IN3 w0.064: v4(135.54,45) 135.61,44.93 v5(135.61,44.48) 135.13,44.48 134.72,44.88 133.96,44.88 133.75,45.09 132.64,45.09 131.97,44.42 127.1,44.42 127.05,44.47 126.71,44.47 126.57,44.61 125.91,44.61 125.51,44.21 124.85,44.21 123.82,43.17 121.01,43.17 119.7,41.87 119.15,41.87 116.28,39 v4(116.17,39) ; v4(106.66,79.46) 107.4,78.71 107.4,77.07 108.99,75.48 108.99,74.2 108.07,73.27 v5(108.07,73.04) ; v4(36.17,69.6) 36.17,70 35.06,71.11 35.06,71.67 35.59,72.19 v4(36.66,72.19)
  BOTTOM w0.081: QV2.3 110.43,72.55 110.02,72.13 108.76,72.13 108.07,72.82 v5(108.07,73.04)
GPU_THM_SMBDAT: length 267
  TOP w0.081: v2(46.01,38.23) 45.49,38.23 v1(45.32,38.06) 43.74,36.49 43.37,36.49 42.7,35.82 40.14,35.82 39.76,35.44 39.76,35.09 39.57,34.89 39.57,33.37 39.44,33.24 39.44,33.2 v6(39.43,33.19) ; v2(69.73,70.76) 69.87,70.62 Q28.3 ; UE1.A59 v2(40.35,23.68) ; RC197.1 136.61,44.69 v2(136.35,44.94) ; v2(35.01,71.36) 35.05,71.32 Q11.6
  IN1 w0.064: v4(68.42,74.57) 68.42,72.07 v2(69.73,70.76) ; v4(115.49,38.11) 115.33,38.27 111,38.27 110.58,38.69 110.58,38.69 110.41,38.86 110.41,38.86 109.93,39.33 106.75,39.33 106.03,38.61 104.24,38.61 100.16,34.53 100.16,33.17 97.75,30.76 97.75,30.44 97.37,30.06 92.68,30.06 92.29,29.67 91.97,29.67 91.91,29.67 91.71,29.48 87.46,29.48 85.8,31.15 82.92,31.15 82.92,31.15 82.81,31.15 82.8,31.15 82.55,31.15 82.55,31.16 82.52,31.16 79.02,34.66 77.99,34.66 76.74,33.4 71.29,33.4 69.29,35.4 57.15,35.4 56.4,36.15 51.51,36.15 49.47,38.19 47.74,38.19 47.64,38.09 46.15,38.09 v2(46.01,38.23) 46.19,38.41 46.19,38.93 45.81,39.31 44.77,39.31 44.67,39.41 44.67,42 43.73,42.94 43.73,52.05 43.34,52.44 43.34,52.8 43.01,53.12 43.01,53.62 42.89,53.75 42.89,54.46 43.72,55.29 43.72,56.6 42.73,57.59 42.73,60.21 43.46,60.94 43.46,63.44 40.87,66.04 40.87,67.13 39.25,68.74 v4(39.25,69.65) ; v4(39.74,23.64) 39.79,23.68 v2(40.35,23.68) ; v2(136.35,44.94) 136.38,44.96 v4(136.68,44.96)
  IN1 w0.089: v4(35.43,71.25) 35.12,71.25 v2(35.01,71.36)
  IN2 w0.066: v4(39.74,23.64) 40.56,23.64 41.18,24.26 41.18,25.26 40.11,26.32 39.6,26.32 38.2,27.72 38.2,28.58 38.49,28.87 38.49,31.88 39.43,32.82 v6(39.43,33.19)
  IN3 w0.064: v4(115.49,38.11) 115.99,38.61 116.42,38.61 118.01,40.2 118.01,40.29 119.28,41.55 119.83,41.55 121.14,42.86 123.95,42.86 124.75,43.66 129.19,43.66 129.63,44.1 132.27,44.1 132.83,44.65 133.71,44.65 133.87,44.49 134.65,44.49 135.03,44.11 135.74,44.11 135.83,44.2 136.1,44.2 136.14,44.25 136.42,44.25 136.61,44.44 v5(136.61,44.61) 136.61,44.86 136.68,44.93 136.68,44.96 v4(136.68,44.96) ; v4(35.43,71.25) 35.52,71.16 37.78,71.16 38.06,70.87 38.06,70.32 38.74,69.65 v4(39.25,69.65) 40.18,69.65 40.48,69.95 41.73,69.95 42.43,69.25 43.5,69.25 44.31,68.44 46.79,68.44 48.89,70.54 48.89,76.01 49.62,76.74 49.62,77.78 51.14,79.29 54.54,79.29 57.14,76.7 67.82,76.7 68.42,76.09 v4(68.42,74.57) 69.3,74.57 69.62,74.89 70.83,74.89 75.79,79.85 78.77,79.85 78.99,80.07 106.76,80.07 109.84,76.99 110.29,76.99 111.74,75.54 v5(111.74,74.31)
  BOTTOM w0.081: QV2.6 111.73,74.31 v5(111.74,74.31) ; UC1.CM15 136.48,44.48 v5(136.61,44.61)
H_CPUPWRGD: length 4
  TOP w0.081: v6(157.89,34.32) 157.89,33.68 v3(157.82,33.62)
  BOTTOM w0.081: UC1.AR2 158.45,36.33 158.16,36.04 158.16,35.38 157.89,35.11 v6(157.89,34.32) 158.2,34.01 CC74.2
H_PROCHOT#: length 318.2
  TOP w0.081: v6(147.84,13.45) 148.8,12.49 v1(158.2,12.49) 158.84,12.49 160.55,10.77 160.55,8.83 161.37,8.01 161.37,5.06 162.78,3.65 170.4,3.65 170.59,3.84 191.92,3.84 193.76,5.68 196.43,5.68 197.39,6.64 197.39,28.47 196.78,29.08 v2(194.34,29.08) ; v2(166.78,36.43) RC160.1 166.78,37.09 166.79,37.11 RC1.2 ; CE24.1 54.44,20.21 54.75,20.53 UE2.4 54.75,21.06 54.96,21.27 v2(56.4,21.27) 56.62,21.48 56.62,22.85 56.97,23.2 56.97,25.22 56.78,25.4 RE547.1 ; PR102.2 105.05,27.47 v6(105.44,27.08) ; v6(106.64,23.27) 106.64,23.14 106.51,23.01 106.51,19.78 108.29,18 PQ1402.1 108.36,17.68 108.36,13.74 108.83,13.27 v2(108.83,12.98)
  IN1 w0.064: v2(56.4,21.27) 57.5,21.27 57.95,21.72 62.05,21.72 v4(62.27,21.5) ; v4(193.99,29.13) 194.05,29.07 194.33,29.07 v2(194.34,29.08) ; v2(108.83,12.98) 108.83,12 108.56,11.74 108.56,10.54 v4(108.61,10.49) ; v2(166.78,36.43) 166.4,36.05 166.4,34.68 167.32,33.76 184.13,33.76 184.19,33.7 v4(184.19,33.7)
  IN2 w0.066: v6(166.26,20.14) 165.92,19.8 165.92,15.93 162.91,12.92 161.67,12.92 161.6,12.85 148.67,12.85 148.07,13.45 v6(147.84,13.45) 147.44,13.45 147.16,13.17 142.97,13.17 141.74,14.4 137.48,14.4 133.96,10.87 123.12,10.87 122.76,10.51 121.46,10.51 120.83,9.88 109.56,9.88 108.95,10.49 v4(108.61,10.49) 108.52,10.49 106.92,8.89 96.19,8.89 96.05,9.03 81.34,9.03 79.97,10.4 71.84,10.4 68.92,13.33 68.92,14.33 64.96,18.28 64.96,19.17 62.63,21.5 v4(62.27,21.5)
  IN3 w0.064: v4(184.19,33.7) 184.19,32.39 190.69,25.9 v5(191.02,25.9) 194,28.87 194,29.13 v4(193.99,29.13) 194.5,29.64 194.5,29.96 196.11,31.57 196.11,34.69 196.34,34.91 197.86,34.91 197.86,34.92 197.89,34.92 199.95,36.97 199.95,40.45 199.95,40.46 199.95,40.96 199.4,41.5 199.4,41.76 197.65,43.51 197.65,54.26 198.08,54.7 198.08,56.2 196.29,57.99 196.29,60.5 v5(196.45,60.65)
  BOTTOM w0.081: v6(105.44,27.08) 105.44,23.71 105.88,23.27 v6(106.64,23.27) ; PRM19.1 196.78,64.1 197.23,64.54 198.4,64.54 198.81,64.14 199.14,63.02 199.36,62.79 199.36,62.29 198.57,61.51 197.3,61.51 v5(196.45,60.65)
  BOTTOM w0.089: PRZ26.2 166.04,20.36 v6(166.26,20.14)
H_PROCHOT#_R: length 2.1
  TOP w0.081: RC160.2 167.23,36.97 167.23,37.13 167.6,37.5 v2(167.64,37.5)
  IN1 w0.064: v2(167.64,37.5) v4(168.06,37.93)
  IN3 w0.064: v5(167.93,37.31) 167.93,37.8 v4(168.06,37.93)
H_THERMTRIP#: length 2.3
  BOTTOM w0.091: UC1.BJ1 150.29,35.55 150.91,34.92 150.91,34.2 151.07,34.04 RC2.2
HDA_BIT_CLK: length 2.2
  BOTTOM w0.081: UC1.BN37 147.53,59.07 147.87,59.4 RC48.2
HDA_BIT_CLK_R: length 112.1
  IN1 w0.064: v4(194.74,22.37) 195.49,21.62 v2(195.49,21.25)
  IN2 w0.066: v4(138.4,61.73) 138.42,61.75 138.42,61.81 138.49,61.88 139.15,61.88 139.27,62 150.4,62 150.65,61.75 152.96,61.75 153.26,62.05 153.29,62.05 153.3,62.05 153.76,62.05 153.76,62.05 177.25,62.05 182.25,57.05 182.25,56.96 182.16,56.88 182.08,56.88 179.92,59.03 179.83,59.03 179.74,58.95 179.74,58.86 182.28,56.33 182.28,56.31 182.28,56.31 182.28,45.23 182.29,45.23 182.29,44.25 182.28,44.25 182.28,40.82 182.36,40.75 182.36,38.27 185.44,35.18 185.44,35.1 185.35,35.01 185.27,35.01 183.59,36.69 183.51,36.69 183.42,36.6 183.42,36.51 185.53,34.4 185.53,33.09 185.78,32.84 185.78,32.84 191.27,27.35 192.67,27.35 194.58,25.44 194.58,22.53 v4(194.74,22.37)
  IN3 w0.064: v4(138.4,61.73) 138.39,61.74 138.09,61.74 v5(138.07,61.73)
  BOTTOM w0.081: v5(138.07,61.73) 138.31,61.97 v1(145.53,61.97) 146.5,61.97 146.75,61.71 147.59,61.71 147.74,61.86 CC6.1 147.92,62.13 148.18,61.88 148.18,61.3 RC48.1
HDA_SDIN0: length 91.6
  IN1 w0.064: v2(195.49,14.25) 195.44,14.2 193.9,14.2 191.98,16.12 190.48,16.12 189.47,17.14 189.47,17.21 189.46,17.21 189.46,19.13 189.47,19.14 189.47,19.44 189.47,19.44 189.47,19.65 v4(189.1,20.02)
  IN2 w0.066: v4(147.25,56.43) 147.71,56.89 147.71,60.33 148.17,60.8 149.95,60.8 150.2,60.54 175.16,60.54 175.32,60.7 175.98,60.7 176.02,60.67 176.49,60.67 177.89,59.27 177.89,57.87 181.13,54.63 181.13,37.25 v6(181.9,36.47)
  IN3 w0.064: v4(147.25,56.43) 147.54,56.13 147.63,56.13 147.73,56.03 v5(147.73,55.91) ; v6(181.9,36.47) 183.33,35.04 183.33,32.12 188.93,26.53 188.93,21.8 188.8,21.68 188.8,20.32 v4(189.1,20.02)
  BOTTOM w0.081: v5(147.73,55.91) 147.8,55.98 147.8,56.18 147.88,56.26 147.88,56.67 UC1.BN35
HDA_SDOUT: length 5.2
  BOTTOM w0.081: v1(150.25,60.31) 149.9,60.67 RC51.2 149.32,60.67 148.96,60.31 148.85,60.31 RC49.2 RC50.2 148.37,59.72 148.44,59.65 148.44,58.69 147.79,58.05 147.79,57.92 UC1.BN36
HDA_SDOUT_R: length 117
  TOP w0.081: JIO1.13 195.8,13.75 196.86,14.81 196.86,28.14 v2(196.7,28.31)
  IN1 w0.064: v4(195.12,29.99) 195.64,29.99 196.7,28.93 v2(196.7,28.31)
  IN2 w0.066: v4(195.12,29.99) 193.37,29.99 193.11,29.73 190.16,29.73 187.37,32.52 187.37,33.52 186.5,34.39 186.5,35.36 183.43,38.43 183.43,57.26 177.77,62.92 161.46,62.92 161.46,62.92 158.4,62.92 158.31,63.02 138.22,63.02 138.09,63.15 137.46,63.15 137.08,62.76 v4(137.05,62.76)
  IN3 w0.064: v4(137.05,62.76) 137.28,62.53 v5(137.28,62.5)
  BOTTOM w0.081: RC49.1 149.3,61.14 CC78.1 149.3,62.08 148.3,63.08 137.96,63.08 137.41,62.53 137.3,62.53 v5(137.28,62.5)
HDA_SYNC: length 4.4
  BOTTOM w0.081: UC1.BN34 147.22,56.68 147.22,58.17 146.9,58.49 146.9,59.55 146.42,60.03 RC47.2
HDA_SYNC_R: length 112
  IN1 w0.064: v4(189.35,20.49) 189.7,20.14 189.7,17.25 190.61,16.33 192.27,16.33 194.16,14.44 195.12,14.44 195.42,14.75 v2(195.49,14.75)
  IN2 w0.066: v4(138.78,60.72) 139.11,61.05 149.97,61.05 150.28,60.74 175.08,60.74 175.24,60.9 176.06,60.9 176.1,60.86 176.57,60.86 176.7,60.73 176.81,60.73 178.29,59.25 178.29,58.96 181.35,55.89 181.35,55.81 181.27,55.72 181.18,55.72 178.77,58.13 178.69,58.13 178.6,58.04 178.6,57.96 181.38,55.18 181.38,52.95 181.37,52.94 181.37,37.64 v6(181.91,37.1)
  IN3 w0.064: v6(181.91,37.1) 183.79,35.22 183.79,32.24 189.47,26.57 189.47,22.08 188.99,21.6 188.99,20.85 v4(189.35,20.49) ; v4(138.78,60.72) 138.47,60.72 v5(138.34,60.85)
  BOTTOM w0.081: v5(138.34,60.85) 138.97,60.85 139.2,61.08 145.6,61.08 146.09,60.59 146.67,60.59 146.77,60.48 RC47.1 147.17,60.29 CC77.1
HDMI_CEC: length 27.1
  TOP w0.081: v1(29.25,39.27) RM6.2 CV930.2 v2(28.47,38.19)
  IN1 w0.064: v2(28.47,38.19) v4(27.76,38.19)
  IN3 w0.064: v4(27.76,38.19) 26.36,38.19 26.04,37.87 26.04,37.32 24.91,36.18 23.24,36.18 22.28,37.14 14.36,37.14 13.42,38.08 12.64,38.08 12.05,38.67 12.05,44.26 JHDMI1.13
HDMI_CEC_R: length 1.2
  TOP w0.081: RM6.1 27.98,39.4 UM1.1
HDMI_HPD: length 16.7
  TOP w0.081: v2(19.89,43.4) 18.83,43.4 v1(18.76,43.33)
  IN1 w0.064: v2(19.89,43.4) v4(20.24,43.4)
  IN3 w0.064: JHDMI1.19 11.51,48.2 13.13,48.2 13.5,47.82 13.5,46.76 16.18,44.08 16.18,42.92 16.59,42.51 19.46,42.51 20.24,43.29 v4(20.24,43.4) 21.04,43.4 v5(21.06,43.39)
  BOTTOM w0.081: v5(21.06,43.39) RM5.1 CV599.2 RM17.2
HDMI_RESERVED: length 2.5
  TOP w0.135: JHDMI1.14 v1(14.14,45.5) 14.41,45.23 CV600.2
HOST_DEBUG_TX: length 38.8
  TOP w0.081: v2(47.2,33.58) 47.27,33.51 RE51.2 47.67,33.5 RE529.2 ; v2(35.76,8.8) 35.88,8.69 35.88,7.8 35.79,7.71 35.79,6.31 35.85,6.25 JDEG1.8 ; v2(47.42,28.78) 47.27,28.93 46.8,28.93 46.48,29.24 UE1.B42
  IN1 w0.064: v4(36.94,8.92) 35.87,8.92 v2(35.76,8.8) ; v4(46.89,28.52) 47.29,28.52 47.42,28.65 v2(47.42,28.78) 47.42,29.61 47.13,29.9 47.13,30.51 46.75,30.89 46.75,31.43 47.13,31.82 47.13,33.51 v2(47.2,33.58)
  IN3 w0.064: v4(36.94,8.92) 36.92,8.94 36.92,10.38 38.59,12.05 38.59,13 39.27,13.68 40.13,13.68 42.06,15.61 42.06,16.94 42.29,17.17 42.9,17.17 43.69,17.96 43.69,18.79 44.06,19.17 44.06,21.27 43.63,21.7 43.63,22.33 44.28,22.99 44.28,26.71 45.17,27.6 45.71,27.6 46.63,28.52 v4(46.89,28.52)
HRESET_PD: length 2
  BOTTOM w0.081: v1(20.15,36.41) 20.06,36.32 RPD88.1 19.35,36.02 19.22,35.89 UPD1.44
HW_ACAV_IN: length 322.7
  TOP w0.081: DV1.1 131.24,65.19 133.46,62.97 v2(134.34,62.97) ; v2(38.23,16.44) 37.95,16.72 DZ12.1 36.49,16.72 v2(36.33,16.89) ; v2(39.33,22.13) 39.34,22.14 CE32.2 39.91,22.68 UE1.A61 ; v2(95.66,25.68) 95.01,25.04 95.01,24.11 91.97,21.07 v1(91.97,20.73) 91.97,20.47 89.16,17.65 89.16,14.76 88.45,14.05 88.45,14 87.5,13.06 87.5,12.31 86.95,11.76 86.95,4.88 86.51,4.44 81.92,4.44 v2(80.99,5.37)
  IN1 w0.064: v2(39.33,22.13) 39.2,21.99 39.2,21.43 38.84,21.07 36.99,21.07 36.59,20.67 36.59,19.26 35.89,18.56 35.89,17.79 36.33,17.36 v2(36.33,16.89) ; v2(80.99,5.37) 80.85,5.23 54.78,5.23 53.33,6.68 52.55,6.68 50.72,8.51 49.96,8.51 48.76,9.71 48.13,9.71 48.07,9.65 48.07,9.64 47.66,9.23 47.19,9.23 47.1,9.32 47.1,9.32 45.94,10.49 44.61,10.49 43.96,11.14 42.81,11.14 41.7,12.25 41,12.25 40.27,12.97 40.27,13.15 38.03,15.4 38.03,16.24 v2(38.23,16.44) ; v2(95.66,25.68) 95.69,25.65 95.81,25.65 96.42,26.26 99.33,26.26 103.88,30.81 103.88,30.82 104.04,30.97 104.04,32.43 104.1,32.49 104.95,33.34 104.95,33.57 105.5,34.13 105.5,34.95 v4(105.37,35.08) ; v4(132.88,61.74) 133.95,61.74 134.34,62.13 v2(134.34,62.97)
  IN2 w0.066: v4(132.88,61.74) 132.83,61.69 131.76,61.69 131.63,61.56 129.67,61.56 129.48,61.74 129.48,67.76 131.33,69.61 131.33,76.74 135.19,80.6 148.31,80.6 150.41,78.5 165.42,78.5 166.47,79.54 166.77,79.54 168.53,77.79 184.19,77.79 184.85,78.44 186.16,78.44 187.26,79.54 187.9,79.54 188.36,79.09 188.62,79.09 189.26,78.45 189.95,78.45 v4(190.09,78.59) ; v4(200.46,46.94) 200.46,46.72 201.81,45.37 204.06,45.37 205.9,43.54 205.9,42.72 206.26,42.35 206.26,41.51 206.67,41.1 206.67,39.38 205.04,37.75 204.38,37.75 204.11,37.49 v4(204.1,37.49) ; v4(132.96,58.16) 132.62,57.81 129.65,57.81 128.22,56.38 128.22,56.38 128.17,56.33 128.17,54.54 128.17,54.54 128.17,54.15 127.53,53.51 126.64,53.51 126.07,54.07 117.02,54.07 110.96,48.02 110.96,46.61 105.63,41.28 105.63,39.69 105.37,39.43 v4(105.37,35.08)
  IN3 w0.064: v4(132.88,61.74) 133.15,61.47 133.15,58.61 v4(132.96,58.16) ; v4(190.09,78.59) 191.02,77.66 191.02,70.64 190.08,69.7 190.08,67.91 193.4,64.59 193.4,63.01 194.46,61.95 196.74,61.95 196.91,61.78 196.92,61.78 197.58,61.12 197.58,61.12 198.3,60.39 198.3,57.58 199.21,56.67 199.21,56.3 201.42,54.1 201.42,52.89 200.06,51.53 200.06,47.69 200.46,47.3 v4(200.46,46.94) ; v5(189.87,21.24) 189.87,24.21 195.37,29.71 195.81,29.71 197.6,31.5 198.16,31.5 198.43,31.77 198.43,32.74 199.34,33.66 199.34,34.72 200.96,36.35 202.65,36.35 202.97,36.67 203.28,36.67 v4(204.1,37.49)
  BOTTOM w0.081: PRB41.2 189.88,21.23 v5(189.87,21.24)
I2C1_PD_L_CLK: length 27.4
  IN1 w0.064: v4(19.06,28.17) 19.46,28.57 20.48,28.57 21.2,27.85 v2(21.2,27.45) 22.2,26.44 24.8,26.44 25.88,25.36 26.82,25.36 27.35,24.84 27.35,17.86 27.91,17.29 27.91,11.95 28.4,11.47 v2(28.4,10.65)
  IN3 w0.064: v5(18.79,27.43) 18.79,27.89 v4(19.06,28.17)
  BOTTOM w0.081: v5(18.79,27.43) 18.79,27.22 RPD163.1 19.06,27.12 19.06,27.53 19.22,27.68 UPD1.27
I2C1_PD_L_DAT: length 31.8
  IN1 w0.064: v4(20.13,29.34) 20.44,29.34 22.98,26.79 24.89,26.79 24.95,26.73 24.96,26.73 26.01,25.68 26.95,25.68 27.21,25.42 27.71,24.93 27.71,21.12 27.71,20.49 v2(27.71,19.88) 27.71,19.45 28.35,18.81 28.35,11.96 28.9,11.42 v2(28.9,10.65)
  IN3 w0.064: v5(18,27.03) 18.04,26.99 19.84,26.99 19.96,27.1 20.8,27.1 21.3,27.6 21.3,28.44 20.4,29.34 v4(20.13,29.34)
  BOTTOM w0.081: UPD1.28 18.82,27.96 18.31,27.45 RPD164.1 v5(18,27.03)
I2C1_PD_L_INT#: length 1.2
  BOTTOM w0.081: RPD17.1 17.13,28.89 17.33,29.1 UPD1.29
I2C2_PD_L_CLK: length 30.2
  IN1 w0.064: v2(29.4,10.65) 29.4,11.36 28.67,12.09 v2(28.67,18.1) 28.67,18.94 28.02,19.59 28.02,20.36 28.02,20.99 28.02,25.16 27.19,26 26.14,26 25.09,27.05 25.09,27.05 24.99,27.14 23.08,27.14 19.8,30.42 v4(19.72,30.42)
  IN3 w0.064: v4(19.72,30.42) 19.53,30.42 19.2,30.09 17.54,30.09 v5(17.14,30.49)
  BOTTOM w0.081: v5(17.14,30.49) 17.01,30.49 RPD21.1 16.89,30.14 17.28,30.14 17.43,30.3 UPD1.32
I2C2_PD_L_DAT: length 32.8
  IN1 w0.064: v2(29.9,10.65) 29.9,11.31 29.01,12.21 29.01,19.12 28.34,19.78 28.34,20.13 28.34,20.86 28.34,20.86 28.34,25.3 28.11,25.53 27.32,26.32 26.27,26.32 25.23,27.36 25.22,27.36 25.12,27.46 23.24,27.46 21.81,28.89 v2(21.81,29.13) 20.83,30.11 v4(20.83,31.36)
  IN3 w0.064: v4(20.83,31.36) 20.78,31.3 20.07,31.3 19.82,31.55 18.34,31.55 17.77,30.98 17.05,30.98 16.81,30.75 v5(16.8,30.75)
  BOTTOM w0.081: UPD1.33 17.45,30.7 17.17,30.98 17.02,30.98 16.94,31.05 16.63,31.05 RPD22.1 16.52,30.75 v5(16.8,30.75)
I2C2_PD_L_INT#: length 1.7
  BOTTOM w0.081: RPD112.1 16.82,31.48 17.1,31.2 17.32,31.2 17.42,31.1 UPD1.34
I2C_0_SCL: length 171.5
  TOP w0.081: v2(69.23,34.51) v1(70.84,36.12) 72.22,37.51 72.22,39.93 v6(71.74,40.42) ; v2(42.34,53.03) 41.94,52.63 41.77,52.63 R87.2
  IN1 w0.064: v2(69.23,34.51) 68.85,34.88 57.12,34.88 56.24,35.77 49.24,35.77 47.3,37.71 45.73,37.71 44.28,39.15 44.28,41.56 43.34,42.5 43.34,51.81 42.96,52.2 42.96,52.64 42.56,53.03 v2(42.34,53.03) 42.34,53.26 42.18,53.42 42.18,53.58 42.13,53.63 42.13,54.08 41.97,54.24 41.97,54.85 41.78,55.04 41.78,56.93 41.97,57.12 41.97,59.37 41.43,59.9 41.43,60.54 41.95,61.05 41.95,62.13 41.46,62.62 41.46,64.37 40.9,64.92 38.82,64.92 38.15,65.59 38,65.59 37.76,65.83 37.6,65.83 v4(37.36,66.07)
  IN3 w0.064: v5(135.61,41.96) 135.59,41.97 133.54,41.97 133.07,41.5 130.3,41.5 129.64,40.85 127.9,40.85 126.54,39.49 124.25,39.49 123.68,40.06 121.14,40.06 120.69,39.61 120.16,39.61 114.43,33.88 113.25,33.88 110.87,31.49 105.26,31.49 104.66,32.09 101.42,32.09 100.46,33.06 83.96,33.06 78.19,38.83 78.19,40.13 77.27,41.05 75.21,41.05 74.75,41.51 73.96,41.51 73.56,41.11 72.29,41.11 71.74,40.57 v6(71.74,40.42) ; v5(15.05,73.2) 16.14,74.29 20.13,74.29 20.92,73.5 20.96,73.5 21.21,73.24 22.79,73.24 23.28,72.75 28.92,72.75 29.09,72.93 29.5,72.93 31.27,71.16 31.27,70.85 31.54,70.58 32.98,70.58 33.62,69.93 v5(33.62,69.81) ; v5(37.6,65.61) 37.36,65.85 v4(37.36,66.07)
  BOTTOM w0.081: v5(33.62,69.81) ED12.5 ED12.6 33.62,65.88 34.41,65.1 37.09,65.1 v5(37.6,65.61)
I2C_0_SDA: length 164.7
  TOP w0.081: R86.2 41.68,53.05 42.06,53.43 42.53,53.43 42.61,53.35 v2(42.63,53.35) ; v2(69.15,35.11) 69.2,35.11 70.86,36.77 v1(70.86,38.83) 70.86,39.88 v6(71.19,40.21)
  IN1 w0.064: v4(37.89,66.17) 38.93,65.13 40.97,65.13 41.68,64.41 41.68,62.66 42.14,62.21 42.14,60.97 41.63,60.46 41.63,60.03 42.16,59.5 42.16,57.04 41.97,56.85 41.97,55.12 42.16,54.93 42.16,54.32 42.32,54.16 42.32,53.71 42.37,53.66 42.37,53.62 v2(42.63,53.35) 42.63,53.23 43.15,52.72 43.15,52.36 43.54,51.97 43.54,42.58 44.48,41.64 44.48,39.23 45.81,37.9 47.38,37.9 48.6,36.68 50.71,36.68 51.43,35.96 56.32,35.96 57.13,35.14 69.12,35.14 v2(69.15,35.11)
  IN3 w0.064: v5(33.12,70.03) 32.77,70.39 31.46,70.39 31.08,70.77 31.08,71.08 29.43,72.73 29.17,72.73 29,72.56 23.2,72.56 22.71,73.05 21,73.05 v5(20.85,73.2) ; v5(136.26,41.96) 136.24,41.98 136.07,41.98 135.73,41.64 133.52,41.64 133.13,41.25 130.33,41.25 129.75,40.66 127.98,40.66 126.62,39.3 124.17,39.3 123.68,39.78 121.14,39.78 120.77,39.41 120.24,39.41 114.51,33.69 113.33,33.69 110.95,31.3 105.18,31.3 104.62,31.87 101.29,31.87 100.29,32.86 83.84,32.86 78,38.7 78,40.05 77.19,40.86 74.88,40.86 74.69,40.67 72.73,40.67 72.07,40.01 71.38,40.01 v6(71.19,40.21) ; v4(37.89,66.17) 37.89,65.73 37.89,65.73 37.89,65.49 37.89,65.49 37.89,65.38 v5(38.11,65.15)
  BOTTOM w0.081: v5(33.12,70.03) ED12.4 ED12.7 33.12,66.09 34.35,64.86 37.82,64.86 v5(38.11,65.15)

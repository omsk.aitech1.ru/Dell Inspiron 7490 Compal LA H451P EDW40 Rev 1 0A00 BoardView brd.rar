# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2C_1_SCL: length 66.1
  TOP w0.081: R37.2 114.92,8.9 114.53,8.51 Q10.1 114.77,7.95 114.77,7.08 114.47,6.77 112.66,6.77 111.49,6.77 110.93,7.32 110.93,8.27 111.43,8.77 111.91,8.77 112.83,9.69 112.83,12.04 112.6,12.28 112.6,13.3 114.17,14.87 114.17,15.34 115.06,16.22 115.32,16.22 116.68,17.58 116.68,23.53 v1(117.5,24.35) 118.27,25.11 118.27,36.12 v2(117.16,37.23)
  IN1 w0.064: v4(116.42,37.25) 116.45,37.23 v2(117.16,37.23)
  IN3 w0.064: v5(137.91,42.09) 137.38,42.61 133.6,42.61 132.88,41.89 132.82,41.89 132.82,41.88 130.14,41.88 129.61,41.36 127.95,41.36 127.51,41.05 127.4,40.98 127.4,40.98 126.29,39.87 124.4,39.87 123.83,40.44 120.99,40.44 120.53,39.99 119.97,39.99 119.22,39.24 117.87,37.89 117.2,37.89 116.56,37.25 v4(116.42,37.25)
  BOTTOM w0.081: UC1.CJ12 137.91,42.61 v5(137.91,42.09)
I2C_1_SCL_R: length 36
  TOP w0.081: v2(111.4,5.08) 111.11,4.79 110.28,4.79 109.99,5.08 109.99,6.23 109.18,7.05 109.18,7.5 109.48,7.8 ED10.3 109.84,7.8 111.68,5.97 111.68,4.71 112.02,4.36 v1(112.31,4.36) 114.3,4.36 114.85,4.91 C6908.1 114.85,5.72 114.53,6.04 Q10.6 114.99,6.76 115.09,6.76 115.26,6.94 R33.1 R43.2
  IN1 w0.064: v2(111.4,5.08) 112.14,5.81 114.89,5.81 115.01,5.93 115.14,5.93 117.17,7.96 119.02,7.96 121.31,10.25 121.31,10.82 121.31,10.82 121.31,11.05 121.31,11.06 121.31,11.49 121.48,11.66 122.37,11.66 123.18,10.84 126.16,10.84 v4(126.77,11.45)
  IN3 w0.064: v5(127.39,11.34) 127.29,11.45 v4(126.77,11.45)
I2C_1_SDA: length 62.5
  TOP w0.081: v2(116.82,37.6) 116.82,36.56 118.05,35.33 118.05,25.43 116.25,23.63 v1(116.25,22.19) 116.25,17.46 115.23,16.44 114.98,16.44 113.96,15.42 113.96,14.96 112.39,13.38 112.39,12.19 112.63,11.95 112.63,9.78 111.82,8.98 111.35,8.98 110.72,8.35 110.72,7.23 112.51,5.45 R36.2 113.33,5.83 113.23,5.93 Q10.4
  IN1 w0.064: v2(116.82,37.6) 116.9,37.52 v4(117.52,37.52)
  IN3 w0.064: v4(117.52,37.52) 117.77,37.52 119.41,39.16 119.41,39.16 120.05,39.8 120.61,39.8 121.06,40.25 123.76,40.25 124.32,39.68 126.46,39.68 127.82,41.04 129.57,41.04 130.22,41.69 132.99,41.69 133.68,42.38 137.19,42.38 v5(137.4,42.17)
  BOTTOM w0.081: UC1.CK12 137.24,42.34 v5(137.4,42.17)
I2C_1_SDA_R: length 25.9
  TOP w0.081: v2(113.4,7.12) 113.4,7.12 111.85,7.12 111.68,7.29 ED10.2 112.02,8.15 113.18,8.15 Q10.3 113.23,9.36 v1(113.29,9.42) 113.33,9.46 115.23,9.46 115.33,9.55 C6907.1 R45.2 115.53,8.98 R32.1
  IN1 w0.064: v2(113.41,7.12) 113.41,6.6 113.69,6.31 115.22,6.31 117.06,8.15 118.9,8.15 120.62,9.88 120.62,11.22 121.3,11.9 122.51,11.9 122.69,11.72 122.7,11.72 122.76,11.66 125.73,11.66 v4(125.94,11.45)
  IN3 w0.064: v4(125.94,11.45) 126.23,11.45 126.4,11.62 126.4,11.72 v5(126.4,11.72)
I2C_ADDR: length 3.4
  TOP w0.081: RM50.2 20.73,35.8 20.73,37.16 21.71,38.14 UM1.45
I2CB_SCL: length 6.1
  BOTTOM w0.081: RV208.1 99.12,72.38 99.12,70.12 99.99,69.26 99.99,69 98.94,67.95 UV1.C9
I2CB_SDA: length 1.5
  TOP w0.081: RV207.1 99.76,68.27 v6(100.08,67.95)
  BOTTOM w0.081: UV1.C8 v6(100.08,67.95)
I2CC_SCL: length 3.8
  BOTTOM w0.081: RV205.1 98.44,71.78 98.44,69.94 97.81,69.31 UV1.A9
I2CC_SDA: length 4.6
  BOTTOM w0.081: UV1.B9 98.37,69.57 98.74,69.94 98.74,72.12 RV206.1
I2CS_SCL: length 16.6
  TOP w0.081: RV203.1 99.89,67.23 100.06,67.06 v6(100.06,66.79)
  IN3 w0.064: v5(110.44,74.28) 110.02,74.28 107.78,72.05 107.78,71.15 105.53,68.89 102.42,68.89 101.47,67.95 100.71,67.95 100.06,67.29 v6(100.06,66.79)
  BOTTOM w0.081: UV1.D9 v6(100.06,66.79) ; QV2.4 110.43,74.29 v5(110.44,74.28)
I2CS_SDA: length 16.1
  TOP w0.081: RV204.1 99.74,67.74 100.09,67.39 v6(100.7,67.39)
  IN3 w0.064: v6(100.7,67.39) 101.55,67.39 102.39,68.23 104.61,68.23 104.81,68.04 105.45,68.04 108.31,70.89 108.55,70.89 108.98,71.33 109.3,71.33 110.27,72.3 v5(111.74,72.3)
  BOTTOM w0.081: v5(111.74,72.3) 111.73,72.31 QV2.1 ; UV1.D8 v6(100.7,67.39)
I_ADP: length 4.5
  TOP w0.081: v2(46.62,18.15) 46.87,18.15 47.03,17.99 47.03,17.33 RE46.1 ; UE1.B12 v2(47.48,20.03)
  IN1 w0.064: v2(47.48,20.03) 47.48,18.45 47.18,18.15 v2(46.62,18.15)
I_ADP_R: length 215.9
  TOP w0.081: v2(47.05,16.62) 47.02,16.58 47.02,16.46 46.93,16.36 RE46.2
  IN1 w0.064: v4(48.86,16.82) 47.39,16.82 47.19,16.63 47.07,16.63 v2(47.05,16.62) ; v4(198.57,29.97) 198.57,29.86 199.31,29.11 199.31,25.35 202.12,22.55 202.25,22.55 208.47,16.33 208.47,11.09 208.47,10.93 208.47,10.93 208.47,10.77 208.47,8.9 208.47,8.9 208.47,5.68 207.26,4.47 195.61,4.47 195.37,4.22 164.73,4.22 158.9,10.05 149.1,10.05 144.9,14.24 144.9,14.27 144.9,14.43 144.9,14.43 144.9,15.3 144.62,15.58 144.53,15.58 144.53,15.58 144.23,15.58 143.93,15.29 133.58,15.29 133.14,14.84 129.56,14.84 128.63,15.77 127.4,15.77 125.57,13.95 120.22,13.95 118.12,11.85 118.12,10.62 117.56,10.06 116.16,10.06 115.41,9.31 115.15,9.31 115.15,9.31 112.24,9.31 110.02,7.09 108.86,7.09 108.68,6.92 100.26,6.92 100.16,6.82 100.15,6.82 99.94,6.6 99.75,6.6 99.74,6.6 98.99,6.6 98.99,6.6 98.82,6.6 97.64,5.42 81.78,5.42 81.34,5.87 80.29,5.87 80.03,5.62 55.11,5.62 53.56,7.16 52.61,7.16 50.85,8.92 50.11,8.92 48.94,10.09 47.74,10.09 v4(47.52,9.87)
  IN3 w0.064: v5(198.57,29.49) v4(198.57,29.97) ; v4(48.86,16.82) 48.56,16.52 48.56,15.33 48.29,15.07 48.29,14.47 47.91,14.09 47.91,13.83 47.75,13.67 47.75,12.64 46.95,11.84 46.95,9.93 46.7,9.68 46.7,9.39 46.85,9.23 47.13,9.23 47.52,9.63 v4(47.52,9.87)
I_BATT: length 4.1
  TOP w0.081: RE47.1 46.12,16.94 46.26,17.07 46.26,18.01 46.11,18.15 CE31.1 46.26,18.53 47,18.53 47.23,18.76 UE1.A11
I_BATT_R: length 212.6
  TOP w0.081: RE47.2 v2(45.95,16.42)
  IN1 w0.064: v4(45.41,10.92) 45.78,10.92 47.18,9.51 47.67,9.51 47.88,9.72 47.88,9.73 48.06,9.9 48.86,9.9 50.03,8.73 50.77,8.73 52.56,6.95 53.46,6.95 54.99,5.42 80.11,5.42 80.37,5.68 81.26,5.68 81.7,5.23 97.72,5.23 98.9,6.41 99.07,6.41 99.07,6.41 99.82,6.41 99.82,6.41 100.02,6.41 100.23,6.63 100.24,6.63 100.34,6.73 108.76,6.73 108.94,6.9 110.1,6.9 112.32,9.12 115.23,9.12 115.23,9.12 115.49,9.12 116.24,9.87 117.64,9.87 118.31,10.54 118.31,11.77 120.28,13.74 125.63,13.74 127.48,15.58 128.55,15.58 129.48,14.65 133.22,14.65 133.66,15.1 143.97,15.1 144.71,14.35 144.71,14.16 149.02,9.86 158.82,9.86 164.65,4.03 195.48,4.03 195.73,4.28 207.33,4.28 208.66,5.6 208.66,8.82 208.66,10.85 208.66,11.01 208.66,11.17 208.66,16.41 202.33,22.74 202.2,22.74 199.61,25.33 199.61,29.41 v4(199.13,29.88) ; v4(46.61,16.1) 46.59,16.08 46.29,16.08 v2(45.95,16.42)
  IN3 w0.064: v4(45.41,10.92) 45.18,11.15 45.18,11.9 46.44,13.17 46.44,14.21 46.63,14.4 46.63,16.04 46.61,16.07 v4(46.61,16.1) ; v5(199.13,29.42) v4(199.13,29.88)
I_SYS: length 96.9
  TOP w0.081: v2(161.49,11.61) 161.49,11.32 161.82,10.99 v1(161.82,10) 161.82,8.73 162.19,8.36 162.19,5.16 163.05,4.3 169.97,4.3 v2(170.21,4.54)
  IN1 w0.064: v4(198.26,28.18) 199.12,27.32 199.12,25.27 202.04,22.36 202.17,22.36 208.28,16.25 208.28,11.01 208.28,10.85 208.28,10.69 208.28,8.98 208.28,5.76 207.18,4.66 195.54,4.66 195.35,4.47 170.59,4.47 170.52,4.54 v2(170.21,4.54) ; v2(161.49,11.61) 160.44,12.66 153.61,12.66 150.96,15.31 150.96,15.72 151.09,15.85 v4(153.38,15.85)
  IN3 w0.064: v5(198.26,27.74) v4(198.26,28.18) ; v4(153.38,15.85) 153.66,15.85 v5(153.74,15.93)
  BOTTOM w0.089: PRZ17.2 153.79,15.99 v5(153.74,15.93)
IA_B+: length 41
  IN1 w0.254: v4(148.38,17.46) 148.46,17.38 149.67,17.38 150.44,16.61 150.64,16.61 150.64,16.61 153.58,16.61 154.62,15.58 154.62,13.89 155.22,13.29 160.76,13.29 v2(162.79,11.25) 164.59,9.46 165.45,9.46 166.1,8.81 171.17,8.81 171.67,8.3 180.26,8.3 181.79,9.83 v2(181.98,9.83)
  IN3 w0.254: v5(148.7,17.57) 148.59,17.46 v4(148.38,17.46)
  BOTTOM w0.254: PRZ55.1 149.42,16.51 148.7,17.23 v5(148.7,17.57)
  vias: v3(180.11,11.2) v6(174.94,10.48) v6(174.94,9.9) v6(175.53,10.48) v6(175.53,9.9) v6(176.11,10.48) v6(176.11,9.9) v6(183.13,10.06) v6(183.13,9.42)
ILMT_1.05V: length 4.1
  IN3 w0.254: v5(126.14,22.97) 125.46,22.97 v5(124.52,23.91)
  BOTTOM w0.254: PUH01.18 126.75,22.33 126.14,22.95 v5(126.14,22.97) ; v5(124.52,23.91) 124.52,23.98 125.01,24.48 PRH02.1
IMONA_CPU: length 5.2
  BOTTOM w0.081: v1(156.24,30.08) 156.25,30.06 PRZ30.2
  BOTTOM w0.203: PUZ01.21 157.25,26.52 156.94,26.84 156.94,28.46 157.03,28.55 PCZ04.2 156.9,29.1 PRZ30.2
IMONB_CPU: length 2.4
  BOTTOM w0.203: PCZ05.2 PRZ31.2 157.47,26.93 157.66,26.74 PUZ01.22
IMONC_CPU: length 3
  BOTTOM w0.203: PUZ01.23 158.05,26.32 158.41,26.67 158.92,26.67 159.12,26.87 PRZ32.2 PCZ06.2
IMVP_VR_EN: length 116.4
  TOP w0.081: U10.1 127.8,15.28 127.71,15.2 125.24,15.2 125.01,14.97 R241.1 124.7,14.71 124.49,14.5 v1(124.49,13.24) v2(124.49,12.68) ; RE532.2 37.83,23.42 36.75,22.34 v2(36.75,21.44)
  IN1 w0.064: v2(124.49,12.68) 124.37,12.68 124.32,12.73 120.47,12.73 119.24,11.49 119.24,10.25 117.97,8.98 116.67,8.98 115.83,8.14 113.05,8.14 110.91,6 109.27,6 109.15,5.88 100.75,5.88 100.37,5.49 99.45,5.49 99.01,5.04 53.29,5.04 v4(52.74,5.59) ; v4(39.03,8.16) 38.82,8.16 37.73,9.25 37.42,9.25 36.22,10.45 36.22,15.92 36.02,16.12 36.02,17.17 35.62,17.56 35.62,18.61 36.4,19.38 36.4,21.09 v2(36.75,21.44)
  IN2 w0.066: v4(39.03,8.16) 39.03,7.26 39.12,7.17 42.36,7.17 43.03,7.84 46.08,7.84 47.37,6.56 51.78,6.56 v4(52.74,5.59)
IMVP_VR_ON: length 6.7
  TOP w0.081: v2(39.32,23.07) 39.29,23.07 39.16,23.2 38.98,23.2 RE532.1 ; v2(42.05,23.19) 42.36,22.88 42.36,21.85 41.98,21.47 UE1.B1
  IN1 w0.064: v2(39.32,23.07) 39.36,23.03 40.51,23.03 40.75,23.27 41.97,23.27 v2(42.05,23.19)
IMVP_VR_ON_EN: length 44.5
  TOP w0.081: U7.2 129.68,13.37 129.55,13.24 128.35,13.24 128.13,13.02 v2(127.98,13.02) 127.98,13.2 127.14,14.03 127.14,14.33 126.57,14.9 125.79,14.9 R241.2 R242.1 125.97,14.15 126.02,14.2 U10.4 126.5,13.75 v1(125.92,13.17)
  IN1 w0.064: v2(127.98,13.02) 133.35,13.02 133.63,13.3 133.92,13.3 134.22,13.6 135.98,13.6 136.25,13.87 v4(136.31,13.87)
  IN2 w0.066: v4(136.31,13.87) 136.42,13.87 137.33,14.77 141.89,14.77 142.11,14.55 142.73,13.93 153.66,13.93 154.48,14.75 155.98,14.75 156.18,14.55 156.18,14.04 156.46,13.76 157.29,13.76 159.86,16.33 160.09,16.33 v4(160.12,16.36)
  IN3 w0.064: v5(160.18,16.69) 160.18,16.42 v4(160.12,16.36)
IMVP_VR_PG: length 82.2
  TOP w0.081: v6(129.16,46.19) 130.79,44.56 130.79,43.36 132.82,41.33 132.82,36.61 134.91,34.51 135.66,34.51 140.23,29.94 140.23,20.36 140.64,19.94 150.95,19.94 155.02,15.87 v1(156.24,15.87) v2(159.52,15.87)
  IN1 w0.064: v4(160.14,15.82) 160.08,15.82 160.03,15.87 v2(159.52,15.87)
  IN2 w0.066: v4(163.31,20.44) 162.3,19.44 162.3,18.01 162.83,17.49 163.58,17.49 163.74,17.33 163.74,16.67 163.48,16.41 160.7,16.41 160.14,15.85 v4(160.14,15.82)
  IN3 w0.064: v5(163.29,20.78) 163.31,20.77 v4(163.31,20.44)
  BOTTOM w0.081: v6(129.16,46.19) 129.01,46.19 128.94,46.26 127.15,46.26 125.97,47.44 125.97,48.02 122.83,51.16 122.45,51.16 122.18,51.42 122.18,53.23 122.5,53.55 122.5,54.03 UC10.1 122.76,53.52 122.85,53.43 123.52,53.43 RC433.2 123.46,53.72 123.3,53.72 123.19,53.83 123.19,54.59 122.91,54.88 122.06,54.88 121.61,55.34 121.27,55.34 121.06,55.13 121.06,54.52 120.9,54.36 RC390.1
  BOTTOM w0.089: PRZ10.2 163.28,20.77 v5(163.29,20.78)
INPUT3VSEL: length 2
  TOP w0.081: RC104.1 146.05,51.47 v2(146.07,51.49) 146.07,51.54 146.25,51.72 RC103.1
  IN1 w0.064: v2(146.07,51.49) 146.06,51.49 146,51.42 145.79,51.42 145.64,51.57 145.64,51.68 v4(145.67,51.71)
  IN3 w0.064: v4(145.67,51.71) 146.01,52.05 v5(146.01,52.07)
INT_TP#: length 20.3
  TOP w0.081: v1(120.04,6.96) 119.77,6.96 119.5,7.23 ; Q8.3 119.21,8.01 119.83,8.01 R42.2 119.85,7.57 119.5,7.23 ; 119.5,7.23 v2(119.49,7.23)
  IN1 w0.064: v2(119.49,7.23) 120.41,7.23 120.48,7.31 v4(121.56,7.31)
  IN3 w0.064: v4(121.56,7.31) v5(121.03,7.31)
  BOTTOM w0.081: JTP1.4 129.55,12.05 129.15,12.45 128.04,12.45 126.83,13.65 123.7,13.65 122.47,12.43 122.47,10.67 122.25,10.44 121.63,10.44 120.87,9.68 120.87,7.47 v5(121.03,7.31)
INTRUDER#: length 5.2
  BOTTOM w0.081: UC1.BR35 145.94,57.31 145.94,58.1 145.81,58.23 145.81,58.33 144.94,59.2 144.66,59.2 144.37,59.48 143.55,59.48 143.12,59.92 RC87.2
INV_PWR_SRC_R: length 3.1
  TOP w0.254: U711.8 40.48,76.26 40.29,76.45 39.36,76.45 38.96,76.86 38.96,77 R4931.1
IREF_CPU: length 3.4
  BOTTOM w0.203: PUZ01.24 158.45,26.04 158.75,26.34 159.49,26.34 159.67,26.51 160.22,26.51 160.78,27.07 PRZ20.2
ISEN1: length 23.8
  TOP w0.203: PUV01.16 40.91,65.65 41.56,66.3 41.56,67.3 41.76,67.5 PRV39.1 42.1,67.87 42.31,68.08 v2(42.33,68.08)
  IN1 w0.203: v4(43.1,67.18) 42.65,67.64 42.65,67.76 v2(42.33,68.08)
  IN3 w0.203: v4(43.1,67.18) 43.39,66.9 47.82,66.9 50.09,69.17 50.09,74.56 50.73,75.21 52.3,75.21 53.65,76.56 54.13,76.56 v5(54.56,76.14)
ISEN2: length 17.3
  TOP w0.203: PUV01.15 42.01,64.46 42.17,64.61 42.17,66.2 42.1,66.26 v2(42.1,66.74)
  IN1 w0.203: v4(43.25,65.61) 42.12,66.74 v2(42.1,66.74)
  IN3 w0.203: v5(54.35,68.68) 54.35,68.35 53.2,67.2 49.7,67.2 47.81,65.31 43.55,65.31 v4(43.25,65.61)
  BOTTOM w0.203: PRV31.1 54.36,68.67 v5(54.35,68.68)
ISH_ACC1_INT#: length 176.6
  TOP w0.081: RC550.1 141.78,56.64 142.18,57.04 v1(142.49,57.04) 142.86,57.04 v2(142.94,56.96)
  TOP w0.305: US2.12 v2(26,76.32)
  IN1 w0.064: v2(26,76.32) 25.8,76.11 25.16,76.11 24.99,75.94 v4(24.99,74.18) ; v2(142.94,56.96) 143.23,56.67 v4(143.37,56.67)
  IN2 w0.066: v4(143.37,56.67) 143.33,56.67 143.2,56.81 141.71,56.81 141.36,56.45 140.69,56.45 139.94,57.21 139.27,57.21 138.63,57.85 137.2,57.85 137.12,57.77 134.67,57.77 131.6,54.7 131.6,52.15 129.45,50 128.49,50 128.07,50.41 125.62,50.41 125.05,49.85 125.05,47.15 122.54,44.64 122.54,43.99 120.91,42.36 120.26,42.36 118.33,40.43 118.33,36.72 115.38,33.77 112.67,33.77 112.18,33.28 110.77,33.28 109.34,31.85 101.17,31.85 100.59,32.43 79.17,32.43 79.15,32.41 78.09,32.41 77.54,32.96 77.54,35.13 77.41,35.26 75.93,36.74 71.26,36.74 69.2,38.8 67.6,38.8 65.14,41.26 65.14,42.44 61.43,46.15 61.32,46.15 61.03,46.45 53.22,46.45 51.82,47.84 50.84,47.84 50.63,48.05 50.63,48.77 50.8,48.94 50.8,49.5 50.3,50 50.3,50.7 49.28,51.71 49.28,53.32 47.94,54.66 47.82,54.77 47.82,59.41 47.2,60.03 47.2,63.02 46.83,63.38 46.83,65.85 44.1,68.58 44.1,71.97 40.1,75.97 31.85,75.97 v4(30.35,74.48) 29.54,73.66 26.55,73.66 25.95,74.27 25.07,74.27 v4(24.99,74.18)
  IN3 w0.064: v5(30.17,72.93) 30.17,74.29 v4(30.35,74.48) ; v4(143.37,56.67) v5(143.71,57.01)
  BOTTOM w0.081: JEDP1.27 30.35,72.74 v5(30.17,72.93)
ISH_ALS_INT#: length 179.5
  TOP w0.081: v2(142.14,58.26) 142.14,58.18 141.45,57.5 RC518.1
  IN1 w0.064: v4(19.35,70.23) v2(19.35,69.84) ; v4(142.56,58) 142.4,58 v2(142.14,58.26)
  IN2 w0.066: v4(19.35,70.23) 19.35,70.49 20.03,71.16 20.03,73.22 22.02,75.21 25.55,75.21 25.62,75.27 29.69,75.27 31.21,76.8 40.09,76.8 44.68,72.21 44.68,68.82 47.3,66.21 47.3,66.21 47.41,66.09 47.41,63.62 47.78,63.26 47.78,60.27 48.4,59.65 48.4,55.01 50.57,52.85 50.57,52.11 50.4,51.94 50.4,51.41 50.89,50.92 51.07,50.92 51.48,50.52 51.48,49.64 53.78,47.33 61.51,47.33 68.36,40.49 69.05,40.49 71.15,38.39 74.76,38.39 75.12,38.02 76.9,38.02 81.41,33.51 92.19,33.51 93.1,34.43 99.5,34.43 100.6,33.32 100.96,33.32 101.54,32.74 105.32,32.74 105.78,33.2 105.98,33.2 106.81,34.03 106.81,34.19 107.21,34.59 107.21,34.76 107.45,35 107.62,35 107.75,35.13 107.75,35.94 109.76,37.94 109.91,37.94 110.08,38.11 112.63,38.11 113.07,37.67 115.86,37.67 117.09,38.9 117.09,40.46 119.89,43.26 120.54,43.26 121.64,44.36 121.64,45.01 123.72,47.09 123.72,50.9 125.27,52.45 125.27,52.82 125.49,53.04 126.17,53.04 126.42,52.8 127.84,52.8 128.44,52.19 130.81,52.19 131.01,52.39 131.01,54.94 135.63,59.55 138.71,59.55 138.95,59.79 140.04,59.79 140.28,59.55 141.8,59.55 142.56,58.79 v4(142.56,58)
  IN3 w0.064: v5(142.5,57.66) 142.5,57.94 v4(142.56,58) ; v5(20.85,70) 19.59,70 v4(19.35,70.23)
ISH_I2C_0_SCL: length 167.6
  TOP w0.081: RC208.1 138.58,48.63 139.03,48.19 v2(139.03,48.1) 139.03,47.49 v3(139.2,47.31)
  TOP w0.305: US2.1 v2(26.88,75.02)
  IN1 w0.064: v4(36.27,74.5) 35.55,73.78 35.55,73.18 v2(35.52,73.15) ; v4(26.88,75.64) v2(26.88,75.02) ; v4(114.64,41.52) 114.54,41.43 113.9,41.43 113.71,41.24 112.42,41.24 110.29,43.37 105.33,43.37 99.35,37.39 99.35,37.19 97.39,35.24 97.39,34.73 96.37,33.71 90.83,33.71 90.7,33.59 89.99,33.59 89.69,33.28 87.52,33.28 86.68,34.13 84.11,34.13 80.84,37.4 80.84,39.09 80.57,39.35 79.19,39.35 78.6,38.76 72.1,38.76 71.62,39.24 65.27,39.24 64.48,40.03 59.44,40.03 59.12,40.35 55.76,40.35 55.61,40.2 53.16,40.2 52.31,41.04 52.31,42.96 51.14,44.13 51.14,46.73 52.09,47.68 52.09,49.02 53.04,49.97 53.04,50.53 53.05,50.54 53.05,53.48 54.25,54.68 54.25,57.16 53.03,58.38 53.03,59.3 51.32,61.01 51.32,63.09 49.83,64.58 49.83,66.78 48.9,67.72 48.81,67.72 48.8,67.72 47.75,67.72 47.38,68.09 45.54,68.09 43.19,70.45 43.19,72.07 43.19,72.07 43.19,72.12 41.29,74.02 37.74,74.02 37.25,73.53 v4(37.25,73.51) ; v2(139.03,48.1) 138.91,48.1 138.72,48.29 v4(138.72,48.3)
  IN3 w0.064: v4(26.88,75.64) 27.67,74.85 27.92,74.85 29.19,76.12 29.19,76.13 29.41,76.34 29.41,76.34 29.48,76.41 34.35,76.41 v4(36.27,74.5) v4(37.25,73.51) 37.25,72.99 v5(37.15,72.89) ; v4(114.64,41.52) 114.72,41.44 115.73,41.44 115.96,41.67 115.96,43.53 117.64,45.21 119.08,45.21 119.44,45.58 122.42,45.58 123.22,46.38 128.33,46.38 128.97,47.02 132.96,47.02 133.8,47.85 135.98,47.85 136.51,47.33 136.51,47.33 136.57,47.27 137.34,47.27 137.4,47.33 137.4,47.33 137.66,47.59 138.14,47.59 138.37,47.82 v5(138.54,47.82) 138.72,48 v4(138.72,48.3)
  BOTTOM w0.081: JEDP1.10 v5(37.15,72.89)
ISH_I2C_0_SCL_R: length 7.8
  TOP w0.081: v2(34.14,73.33) 34.14,73.64 33.33,74.45 v3(33.13,74.45)
  IN1 w0.064: v2(34.14,73.33) 34.26,73.2 34.71,73.2 34.98,73.47 v4(35.15,73.47) 35.15,72.95 35.52,72.58 v2(35.52,72.57)
  IN3 w0.064: v5(34.35,74.06) 34.81,74.06 35.15,73.71 v4(35.15,73.47)
  BOTTOM w0.081: JEDP1.21 32.75,73.08 33.05,73.37 33.67,73.37 v5(34.35,74.06)
ISH_I2C_0_SDA: length 161.7
  TOP w0.081: v3(139.27,48.96) 139.27,49.04 v2(139,49.3) 139,49.85 RC207.1
  TOP w0.305: US2.4 v2(28.38,75.01)
  IN1 w0.064: v4(28.92,74.89) 28.8,75.01 v2(28.38,75.01) 29.35,75.98 v4(29.56,75.98) ; v4(36.74,73.37) 36.74,73.19 36.87,73.05 37.62,73.05 38.19,72.48 38.82,72.48 40.73,70.57 42.34,70.57 46.07,66.84 46.79,66.84 50.41,63.22 50.41,60.89 51.91,59.39 51.91,56.55 50.39,55.03 50.39,53.56 48.7,51.87 48.7,50.62 48.6,50.51 48.6,47.82 49.61,46.81 49.61,45.01 51.55,43.07 51.55,41.26 53,39.82 59.11,39.82 59.28,39.65 62.72,39.65 63.46,38.91 71.69,38.91 72.14,38.45 75.71,38.45 75.76,38.41 79.21,38.41 79.81,37.81 80.13,37.81 84.01,33.94 86.6,33.94 87.44,33.09 89.77,33.09 90.07,33.4 90.78,33.4 90.91,33.52 96.46,33.52 97.59,34.65 97.59,35.17 99.54,37.11 99.54,37.31 105.41,43.18 110.03,43.18 112.27,40.94 112.78,40.94 v4(113.18,40.54) ; v2(139,49.3) v4(138.65,49.3)
  IN3 w0.064: v5(36.75,72.88) 36.75,73.17 36.74,73.19 v4(36.74,73.37) 36.57,73.54 36.57,73.65 34.24,75.98 v4(29.56,75.98) ; v4(28.92,74.89) 29.48,74.33 v5(29.48,74.31) ; v4(138.65,49.3) 138.51,49.16 137.72,49.16 137.24,48.68 v5(137.24,48.43) 137.07,48.27 133.97,48.27 133.35,48.27 132.7,47.62 132.69,47.62 132.66,47.59 127.47,47.59 127.37,47.48 126.95,47.48 126.6,47.13 126.36,47.13 126.33,47.16 124.45,47.16 124.25,46.95 122.99,46.95 122.18,46.15 119.73,46.15 119.08,46.8 118.11,46.8 116.87,45.56 116.87,45.25 116.42,44.8 116.26,44.8 116.17,44.8 115.36,43.98 115.36,43.76 113.83,42.23 113.83,41.7 113.21,41.07 113.21,40.92 113.18,40.9 v4(113.18,40.54)
  BOTTOM w0.081: v5(29.48,74.31) 29.48,73.44 29.85,73.07 29.85,72.78 29.95,72.68 JEDP1.28 ; v5(137.24,48.43) UC1.CK22 ; JEDP1.11 v5(36.75,72.88)
ISH_I2C_1_SCL: length 154.1
  IN1 w0.064: v2(70.28,74.87) 70.26,74.85 70.26,72.48 70.57,72.16 71.15,72.16 71.84,72.86 72.16,72.86 72.34,72.69 72.34,72.31 71.84,71.81 71.84,64.64 70.59,63.38 68.83,63.38 67.07,61.62 56.6,61.62 56.1,61.11 56.1,55.14 55.64,54.68 54.52,54.68 53.37,53.53 53.37,50.59 53.23,50.45 53.23,49.89 52.28,48.94 52.28,47.6 51.33,46.65 51.33,44.21 52.5,43.04 52.5,41.12 53.24,40.39 55.53,40.39 55.68,40.54 59.2,40.54 59.52,40.22 64.56,40.22 65.35,39.43 72.06,39.43 72.54,38.95 77.63,38.95 78.79,40.11 80.73,40.11 81.81,39.03 81.81,36.74 84.23,34.32 86.76,34.32 87.6,33.47 89.61,33.47 89.92,33.78 90.62,33.78 90.75,33.9 96.28,33.9 97.19,34.81 97.19,35.3 99.16,37.27 99.16,37.47 105.25,43.56 110.48,43.56 112.61,41.43 113.63,41.43 113.86,41.65 113.86,41.65 114.31,42.1 114.81,42.1 v4(115.03,41.88)
  IN3 w0.064: v5(137.89,48.86) 137.89,48.73 137.28,48.13 133.92,48.13 133.48,48.13 132.74,47.4 127.55,47.4 127.45,47.29 127.03,47.29 126.62,46.89 124.45,46.89 124.33,46.76 123.06,46.76 122.26,45.96 119.29,45.96 118.92,45.59 117.49,45.59 115.03,43.14 v4(115.03,41.88)
ISH_I2C_1_SDA: length 151.9
  IN1 w0.064: v4(115.54,42.08) 114.97,42.65 112.15,42.65 110.8,44 105.29,44 105.29,44 105.15,44 98.77,37.63 98.77,37.43 96.32,34.97 96.32,34.75 95.67,34.09 90.67,34.09 90.54,33.97 89.84,33.97 89.54,33.67 87.68,33.67 86.84,34.51 84.48,34.51 82.19,36.8 82.19,39.02 80.9,40.31 78.54,40.31 77.37,39.14 75.02,39.14 74.25,39.92 73.76,39.92 73.47,39.62 65.43,39.62 64.64,40.41 59.59,40.41 59.28,40.73 55.59,40.73 55.43,40.58 53.31,40.58 52.69,41.2 52.69,43.12 51.52,44.29 51.52,45.9 52.47,46.85 52.47,48.86 53.42,49.81 53.42,50.37 53.62,50.57 53.62,53.51 54.6,54.49 55.72,54.49 56.29,55.06 56.29,60.99 56.73,61.43 67.14,61.43 68.91,63.19 70.67,63.19 72.03,64.56 72.03,71.73 72.54,72.24 72.54,72.8 72.29,73.05 70.87,73.05 v2(70.77,72.95)
  IN3 w0.064: v4(115.54,42.08) 115.54,42.42 115.43,42.52 115.43,43.27 117.56,45.4 119,45.4 119.36,45.77 122.34,45.77 123.14,46.57 128.25,46.57 128.89,47.21 132.89,47.21 132.99,47.31 133.06,47.31 133.74,47.99 133.86,47.99 136.04,47.99 136.57,47.47 136.57,47.47 136.63,47.41 137.28,47.41 137.63,47.76 137.63,48.24 137.82,48.43 137.82,48.44 138,48.62 138,48.62 138.02,48.64 138.02,48.65 138.24,48.86 v5(138.54,48.86)
ISH_P_SENSOR_INT#: length 194.8
  TOP w0.081: RC516.1 141.59,51.84 141.88,51.55 v1(143.08,51.55) 143.47,51.95 v2(143.47,51.97)
  IN1 w0.064: v2(143.47,51.97) 143.47,52.12 143.5,52.15 v4(143.5,52.54)
  IN2 w0.066: v4(29.61,71.99) 29.71,71.9 31.36,71.9 32.62,70.64 35.08,70.64 35.08,70.64 36.09,70.64 36.62,71.17 38.27,71.17 38.39,71.04 38.64,71.04 39.88,69.8 39.88,68.87 41.06,67.69 41.06,64.93 42.03,63.95 42.03,62.2 41.95,62.12 41.95,61.15 39.71,58.91 39.71,56.67 39.01,55.97 39.01,50.68 39.68,50.02 42.24,50.02 46.69,45.58 46.69,43.88 47.33,43.24 52.46,43.24 52.69,43.01 55.65,43.01 55.78,43.14 56.67,43.14 58.99,40.82 58.99,40.35 62.34,37 63.38,37 65.25,35.13 65.25,35.13 72.17,28.21 76.2,28.21 81.9,22.51 89.02,22.51 89.02,22.51 89.37,22.51 90.21,21.67 93.24,21.67 94.23,22.66 112.47,22.66 114.48,24.67 116.11,24.67 116.82,25.38 116.82,28.8 119.23,31.21 119.23,31.82 121.56,34.15 123.14,34.15 125.51,36.51 125.51,39.68 127.92,42.08 129.07,42.08 133.97,46.99 134.16,46.99 135.9,48.73 136.76,48.73 136.76,48.73 136.8,48.73 137.31,49.24 137.31,49.6 137.87,50.16 138.1,50.16 138.66,50.73 139.12,50.73 139.35,50.96 139.7,50.96 140.17,50.48 140.41,50.48 141.19,51.26 141.19,51.74 141.63,52.19 141.63,53.07 142.01,53.44 143.75,53.44 144.04,53.16 144.04,52.69 143.89,52.54 v4(143.5,52.54)
  IN3 w0.064: v5(15.05,70.8) 15.86,71.61 19.68,71.61 20.01,71.28 21.86,71.28 22.95,72.37 29.23,72.37 v4(29.61,71.99) ; v5(143.71,56.36) 143.46,56.11 143.46,54.08 142.98,53.6 142.98,52.87 143.31,52.54 v4(143.5,52.54)
JTAG_CLK: length 25.5
  TOP w0.081: v2(33.42,6.76) 33.42,6.55 33.85,6.12 JDEG1.4
  IN1 w0.064: v2(33.42,6.76) 33.42,10.64 35.2,12.43 35.2,13.74 35.08,13.87 35.08,21.67 36.78,23.37 38.62,23.37 39.1,23.85 39.1,24.44 40.27,25.61 41.21,25.61 v2(41.38,25.43)
JTAG_RST#: length 6.3
  TOP w0.081: RE527.1 45.47,33.59 RE526.2 44.63,33.59 44.44,33.4 CLEC1.1 43.91,32.92 43.97,32.86 43.97,32.05 44.13,31.89 CE505.1 44.42,31.79 44.42,31.57 44.62,31.37 44.96,31.37 45.36,30.97 45.97,30.97 46.23,30.7 UE1.A40
JTAG_TDI: length 26.9
  TOP w0.081: RE90.1 39.55,26.72 v2(39.89,26.38) ; v2(32.66,6.25) 32.85,6.06 JDEG1.2
  IN1 w0.064: v2(32.66,6.25) 32.66,10.99 34.52,12.85 34.52,13.62 34.51,13.63 34.51,22.15 35.57,23.21 35.98,23.49 36.39,23.9 36.66,24.31 38.34,25.99 38.76,25.99 39.15,26.38 v2(39.89,26.38) 40.35,26.38 40.8,25.93 v2(41.38,25.93)
JTAG_TDO: length 26.3
  TOP w0.081: UE1.A55 40.38,25.68 40.06,25.36 v2(39.46,25.36)
  IN1 w0.064: v2(34.35,5.49) 34,5.14 33.17,5.14 33.05,5.27 33.05,6.35 32.88,6.52 32.88,10.91 34.71,12.74 34.71,13.7 34.7,13.71 34.7,21.83 37.81,24.94 39.04,24.94 v2(39.46,25.36)
JTAG_TMS: length 24.4
  TOP w0.081: v2(38.42,24.62) 38.66,24.37 39.11,24.37 39.28,24.55 39.28,24.6 RE91.1 39.81,24.79 40.21,25.18 UE1.A56
  IN1 w0.064: v2(38.42,24.62) 37.75,24.62 34.89,21.75 34.89,13.79 34.9,13.78 34.9,12.49 33.11,10.69 33.11,6.63 33.35,6.39 v2(33.35,5.49)
KB_BL_CTRL#: length 6.8
  TOP w0.081: v6(33.98,10.55) 33.98,9.95 34.86,9.07 C105.1 34.6,8.31 Q7.1
  BOTTOM w0.081: v1(34.51,11.01) 34.45,11.01 v6(33.98,10.55) 35.29,9.24 JKBBL1.4
KB_DET#: length 114.2
  TOP w0.081: v2(103.91,18.25) 103.85,18.32 v1(103.4,18.32) ; RC110.1 137.45,50.33 v2(137.53,50.41)
  IN1 w0.064: v4(60.03,18.38) 60.25,18.17 61.51,18.17 61.55,18.12 62,18.12 63.41,16.71 65.32,16.71 66.72,15.3 67.64,15.3 68.09,14.85 75.69,14.85 76.67,13.87 84.03,13.87 84.17,13.74 85.16,13.74 85.17,13.76 87.03,13.76 87.05,13.74 87.35,13.74 87.6,13.99 88.68,13.99 88.93,13.74 89.02,13.74 89.04,13.73 90.39,13.73 90.74,14.08 90.74,15.32 92.88,17.46 97.75,17.46 98.1,17.82 103.48,17.82 v2(103.91,18.25) 104.42,18.76 104.42,19.14 107.62,22.34 107.83,22.34 110.99,22.34 111.09,22.44 111.09,24.99 112.49,26.39 v4(112.49,27.33) ; v4(137.05,50.41) 137.07,50.38 137.5,50.38 v2(137.53,50.41)
  IN2 w0.066: v4(112.49,27.33) 112.64,27.48 113.35,27.48 120.98,35.12 121.79,35.12 123.32,36.64 123.38,36.64 123.66,36.92 123.66,38.92 127.63,42.89 128.78,42.89 133.37,47.48 133.37,47.78 133.75,48.16 134.42,48.16 135.67,49.41 136.01,49.41 136.39,49.8 136.84,49.8 137.05,50.01 v4(137.05,50.41)
  IN3 w0.064: v4(60.03,18.38) 59.94,18.28 59.94,16.2 60.6,15.53 60.6,11.18 v5(60.5,11.07) ; v4(137.05,50.41) 137.24,50.6 v5(137.24,50.94)
  BOTTOM w0.081: v5(60.5,11.07) 60.88,11.07 61.25,10.7 61.25,10.01 61.06,9.82 C104.2 60.57,9.62 59.46,9.62 58.45,8.61 JKB1.30
KB_LED_BL_DET: length 133
  TOP w0.081: R38.1 R40.1 37.19,8.32 37.78,8.32 v6(37.86,8.23) 37.86,8.75 v1(37.85,8.77)
  IN1 w0.064: v4(72.77,21.9) 68.59,21.9 66.75,23.74 61.94,23.74 61.4,24.28 59.33,24.28 58.25,23.2 57.91,23.2 57.15,22.44 56.71,22.44 v4(56.59,22.32)
  IN2 w0.066: v4(136.19,47.11) 135.66,47.11 134.77,46.22 134.77,45.66 134.03,44.91 134.03,44.75 134.03,44.11 133.73,43.81 133.67,43.81 133.26,43.4 131.75,43.4 129.47,41.12 128.31,41.12 126.48,39.29 126.48,35.97 121.03,30.52 121.03,30.48 119.89,29.34 119.89,27.09 119.56,26.77 119.16,26.77 118.36,25.97 118.36,25.36 114.67,21.66 97.48,21.66 96.39,20.57 92.01,20.57 91.43,19.99 90.63,19.99 88.68,21.93 81.15,21.93 79.85,23.23 75.61,23.23 75.17,22.79 73.76,22.79 72.86,21.9 v4(72.77,21.9)
  IN3 w0.064: v5(136.72,46.93) 136.42,46.93 136.24,47.11 v4(136.19,47.11) ; v6(37.86,8.23) 37.86,8.04 38.6,7.3 42.44,7.3 43.61,8.47 45.11,8.47 45.43,8.79 45.93,8.79 46.1,8.62 48.93,8.62 49.22,8.92 50.35,8.92 50.94,9.51 50.94,11.85 50.25,12.54 50.25,13.3 51.14,14.19 51.14,14.81 53.6,17.27 53.6,17.79 53.93,18.11 54.18,18.11 54.4,18.33 54.4,19.45 56.59,21.64 v4(56.59,22.32)
  BOTTOM w0.081: UC1.CM18 136.58,46.71 136.72,46.84 v5(136.72,46.93)
KB_LED_DET_C: length 3.1
  TOP w0.081: R38.2 36.25,9.52 36.35,9.62 36.5,9.62 36.52,9.64 36.84,9.64 37.12,9.93 v6(37.31,9.93)
  BOTTOM w0.081: v1(37.24,10.7) 37.24,10.01 v6(37.31,9.93) 37.7,9.54 JKBBL1.2
KB_LED_PWM: length 36.6
  TOP w0.081: UE1.B29 49.58,26.43 49.47,26.55 49.2,26.55 v2(49.14,26.61) ; v2(35.78,9.22) 35.76,9.22 35.53,8.99 35.24,8.99 34.52,9.71 34.52,10.97 34.43,11.06 v1(33.38,11.06) 32.03,9.71 Q7.2
  IN1 w0.064: v4(47.65,27.69) 47.65,27.24 48.06,26.82 48.89,26.82 49.1,26.61 v2(49.14,26.61) ; v2(35.78,9.22) 35.94,9.39 v4(35.94,9.58)
  IN2 w0.066: v4(38.51,10.65) 38.51,10.08 37.79,9.37 36.16,9.37 v4(35.94,9.58)
  IN3 w0.064: v4(38.51,10.65) 38.51,10.92 39.36,11.77 40.32,11.77 40.89,12.35 41.49,12.35 42.13,12.99 42.13,13.49 42.89,14.25 42.89,15.82 43.15,16.08 43.15,16.32 43.27,16.44 43.27,16.72 43.91,17.36 44.88,17.36 46.31,18.79 46.31,19.34 45.58,20.07 45.58,23.73 46.16,24.3 46.16,24.53 47.43,25.81 47.43,27.47 v4(47.65,27.69)
KSI0: length 34.8
  TOP w0.081: UE1.B32 50.23,27.93 49.98,28.18 v2(49.93,28.18)
  IN1 w0.064: v2(57.42,29.62) 57.42,29.43 56.59,28.6 56.2,28.6 v4(56.06,28.47) 55.23,28.47 55.23,28.46 54.93,28.46 54.93,28.47 v2(54.36,28.47) 54.25,28.35 52.42,28.35 52.03,27.96 50.88,27.96 50.86,27.93 50.23,27.93 49.98,28.18 v2(49.93,28.18)
  IN2 w0.066: v4(64.85,7.44) 64.85,8.98 64.08,9.75 64.08,10.98 61.57,13.5 61.57,13.91 56.96,18.51 56.96,22.49 56.6,22.86 56.6,23.82 56.95,24.17 56.95,27.58 v4(56.06,28.47)
  IN3 w0.064: v5(64.85,8.14) v4(64.85,7.44)
KSI1: length 31
  TOP w0.081: RE67.2 52.67,27.02 52.24,27.45 51.93,27.45 51.66,27.18 UE1.A29 ; v1(55.84,28.8) 55.84,28.32 55.93,28.23 v2(55.93,27.95)
  IN1 w0.064: v2(55.93,27.95) 55.8,28.08 v4(55.34,28.08) 55.34,27.86 55.15,27.68 53.66,27.68 52.99,27 52.79,27 v2(52.78,27.01)
  IN2 w0.066: v4(55.34,28.08) 55.4,28.08 55.78,27.7 55.78,24.73 56.22,24.29 56.22,22.9 56.04,22.72 56.04,21.8 56.58,21.26 56.58,18.35 61.18,13.75 61.18,13.34 63.46,11.06 v4(63.46,7.55)
  IN3 w0.064: v5(63.25,8.14) 63.25,7.75 v4(63.46,7.55)
KSI2: length 30.7
  TOP w0.081: v2(54.87,27.98) 54.65,27.77 RE68.2 ; UE1.B31 50.36,27.43 50,27.79 v2(49.89,27.79)
  IN1 w0.064: v2(49.89,27.79) 50,27.79 50.24,27.55 51.19,27.55 51.29,27.66 52.28,27.66 52.29,27.66 52.66,27.29 52.97,27.29 53.71,28.03 54.53,28.03 v4(54.53,28.04) 54.57,28.04 54.62,27.98 v2(54.87,27.98)
  IN2 w0.066: v6(61.89,11.32) 61.89,12.09 60.8,13.18 60.8,13.59 56.19,18.19 56.19,21.03 55.65,21.57 55.65,23.35 55.22,23.79 55.22,25.36 55.21,25.36 55.21,27.24 54.53,27.92 v4(54.53,28.04)
  BOTTOM w0.081: v6(61.89,11.32) v1(61.89,9.83) 61.89,9.16 61.65,8.92 JKB1.26
KSI3: length 33
  TOP w0.081: UE1.B34 51,28.93 51.58,29.52 52.24,29.52 52.37,29.38 RE69.2 52.78,29.59 v2(52.46,29.9) 52.46,30.32 v1(52.36,30.42)
  IN1 w0.064: v4(55.08,28.83) 54.87,29.03 54.82,29.03 54.42,29.43 52.86,29.43 52.46,29.82 v2(52.46,29.9)
  IN2 w0.066: v4(55.08,28.83) 55.19,28.83 56.68,27.33 56.68,24.18 56.41,23.9 56.41,22.65 56.23,22.48 56.23,21.88 56.77,21.34 56.77,18.43 61.37,13.83 61.37,13.42 63.84,10.95 63.84,9.19 64.05,8.98 v4(64.05,7.44)
  IN3 w0.064: v5(64.05,8.14) v4(64.05,7.44)
KSI4: length 35
  TOP w0.081: UE1.B35 50.45,30 50.45,30.92 50.74,31.21 50.74,31.65 RE73.2 51.05,31.6 v2(51.05,31.39)
  IN1 w0.064: v4(54.25,29.88) 54.25,30.2 54.37,30.31 54.37,32.06 53.69,32.73 52.39,32.73 51.75,32.09 51.4,32.09 51.05,31.75 v2(51.05,31.39)
  IN2 w0.066: v6(61.38,11.82) 61.38,12.32 60.6,13.1 60.6,13.51 56,18.11 56,20.95 55.46,21.49 55.46,22.29 54.74,23.01 54.74,23.54 55.02,23.82 55.02,24.86 54.92,24.96 54.92,27.06 54.11,27.87 54.11,28.45 54.25,28.58 54.25,29.36 54.25,29.36 v4(54.25,29.88)
  BOTTOM w0.081: JKB1.27 60.85,8.64 61.49,9.28 61.49,11.71 v6(61.38,11.82)
KSI5: length 36.5
  TOP w0.081: UE1.A33 49.73,30.83 50.07,31.17 50.07,31.59 RE72.2 50.43,31.61 v2(50.43,31.37) ; v3(62.3,10.17) v6(62.3,10.76)
  IN1 w0.064: v4(50.11,30.87) 50.25,31.02 50.25,31.19 v2(50.43,31.37)
  IN2 w0.066: v6(62.3,10.76) 62.3,11.95 60.99,13.26 60.99,13.67 56.39,18.27 56.39,21.11 55.84,21.65 55.84,23.43 55.41,23.87 55.41,24.94 55.51,25.05 55.51,27.37 54.96,27.92 54.96,28.28 54.61,28.63 54.61,28.89 54.96,29.24 55.6,29.24 56.3,29.94 56.3,30.33 56.09,30.53 52.66,30.53 52.44,30.76 50.93,30.76 50.63,31.06 50.3,31.06 v4(50.11,30.87)
  BOTTOM w0.081: JKB1.25 62.45,9.04 62.3,9.19 v6(62.3,10.76)
KSI6: length 28.2
  TOP w0.081: v2(52.13,29.19) 52.27,29.19 52.46,29 52.58,29 RE71.2 52.67,28.69 52.44,28.69 52.31,28.82 52.02,28.82 51.89,28.68 UE1.A32
  IN1 w0.064: v4(53.84,28.92) 53.57,29.19 v2(52.13,29.19)
  IN2 w0.066: v6(60.61,9.15) 60.61,11.62 60.29,11.93 60.29,13.55 55.81,18.03 55.81,20.5 55.26,21.05 55.26,21.69 54.94,22.01 54.94,22.54 54.54,22.93 54.54,23.68 54.83,23.97 54.83,24.78 54.73,24.88 54.73,26.98 53.84,27.87 v4(53.84,28.92)
  BOTTOM w0.081: JKB1.28 60.05,8.59 v6(60.61,9.15)
KSI7: length 30.5
  TOP w0.081: v1(55.16,30.37) 54.69,30.37 54.49,30.17 54.49,29.61 54.37,29.49 v2(54.37,29.05)
  IN1 w0.064: v2(54.37,29.05) 54.37,28.91 54.02,28.56 53.99,28.56 53.99,28.56 53.56,28.56 v4(53.32,28.8) 53.31,28.81 51.66,28.81 51.36,28.5 50.65,28.5 v2(50.58,28.43)
  IN2 w0.066: v6(59.76,9.08) 59.98,9.29 59.98,13.59 55.61,17.95 55.61,20.17 54.05,21.73 54.05,22.24 54.14,22.33 54.14,22.82 54.02,22.94 54.02,24.27 54.54,24.79 54.54,26.9 53.65,27.79 53.65,28.47 v4(53.32,28.8)
  BOTTOM w0.081: JKB1.29 59.25,8.56 v6(59.76,9.08)
KSO00: length 48.7
  TOP w0.081: v2(52.17,28.51) 52.24,28.43 52.69,28.43 52.78,28.35 RE74.2 52.23,28.21 52.2,28.18 UE1.A31 ; v1(54.7,31.98) 54.7,31.87 v2(53.64,30.81)
  IN1 w0.064: v4(53.48,32.35) 53.48,30.98 v2(53.64,30.81) 53.64,30.46 53.56,30.37 52.53,30.37 51.27,29.11 50.59,29.11 50.28,28.79 50.28,28.23 50.37,28.15 50.76,28.15 50.8,28.18 50.94,28.18 50.98,28.15 51.69,28.15 51.98,28.43 52.09,28.43 v2(52.17,28.51)
  IN2 w0.066: v4(72.05,7.44) 71.69,7.08 71.03,7.08 70.88,7.23 70.88,8.56 61.25,18.19 61.25,19.56 61.25,19.75 60.14,20.85 60.14,21.56 58.83,22.88 58.83,23.28 58.68,23.43 58.68,30.26 56.81,32.13 53.7,32.13 v4(53.48,32.35)
  IN3 w0.064: v5(72.05,8.14) v4(72.05,7.44)
KSO01: length 55.6
  TOP w0.081: v2(39.93,27.63) 39.56,27.63 39.47,27.54 RE75.2
  IN1 w0.064: v2(39.93,27.63) 40.53,27.03 40.62,27.03 41.22,26.43 v2(41.38,26.43) 41.89,25.93 v4(42.11,25.93) ; v4(70.45,7.44) 70.49,7.47 v2(70.49,8.23)
  IN2 w0.066: v4(70.45,7.44) 70.45,8.71 61.06,18.11 61.06,19.67 59.89,20.83 59.89,21.54 58.53,22.9 58.53,23.3 58.49,23.35 58.49,30.18 56.73,31.94 53.33,31.94 52.78,32.49 52.78,32.77 51.57,33.98 50.13,33.98 47.71,31.56 45.89,31.56 v4(45.53,31.19)
  IN3 w0.064: v4(45.53,31.19) 45.18,30.85 45.18,28.68 43.01,26.5 42.68,26.5 v4(42.11,25.93) ; v5(70.45,8.14) v4(70.45,7.44)
KSO02: length 51.6
  TOP w0.081: v2(45.93,33.81) 45.93,34.38 RE76.2 46.04,35.3 v1(46.3,35.3)
  IN1 w0.064: v2(45.48,29.53) 45.48,29.72 45.58,29.82 46.3,29.82 46.39,29.91 46.39,30.64 46.47,30.72 46.47,31.75 v4(46.77,32.05) 46.68,32.14 46.68,33.57 46.44,33.81 v2(45.93,33.81)
  IN2 w0.066: v4(46.77,32.05) 47.75,33.04 48.91,33.04 50.05,34.18 51.98,34.18 53.16,33 53.61,33 54.25,32.35 56.87,32.35 58.87,30.34 58.87,23.51 59.08,23.3 59.52,23.3 60.34,22.48 60.34,20.93 61.45,19.82 61.45,18.27 71.25,8.46 v4(71.25,7.44)
  IN3 w0.064: v5(71.25,8.14) v4(71.25,7.44)
KSO03: length 50.5
  TOP w0.081: UE1.A42 45.23,30.79 44.87,31.15 44.53,31.15 44.17,31.51 43.97,31.51 RE77.2
  IN1 w0.064: v4(44.23,31.78) 43.71,31.78 43.62,31.87 v2(43.62,31.88) ; v2(69.19,6.61) 69.65,7.07 v4(69.65,7.44)
  IN2 w0.066: v4(69.65,7.44) 69.65,9.24 65.15,13.74 64.1,13.74 62.99,14.85 62.99,15.47 60.86,17.59 60.86,18.67 59.43,20.1 59.43,20.65 59.59,20.81 59.59,21.57 58.33,22.83 58.33,23.23 58.3,23.27 58.3,30.1 56.66,31.74 53.26,31.74 52.56,32.44 52.56,32.67 51.44,33.79 50.47,33.79 47.44,30.75 45.05,30.75 44.23,31.57 v4(44.23,31.78)
  IN3 w0.064: v5(69.65,8.14) v4(69.65,7.44)
KSO04: length 39.2
  TOP w0.081: v2(51.45,31.74) 51.63,31.74 51.96,32.07 51.96,33.23 v1(52.02,33.29)
  IN1 w0.064: v4(51.77,31.4) 51.77,31.42 v2(51.45,31.74) 51.4,31.69 51.4,31.08 49.85,29.53 v2(49.48,29.53)
  IN2 w0.066: v4(51.77,31.4) 52.45,31.4 52.88,30.97 56.34,30.97 57.46,29.85 57.46,24.14 56.99,23.66 56.99,23.02 57.35,22.65 57.35,18.67 61.95,14.07 61.95,13.66 65.99,9.63 65.99,7.6 v4(66.18,7.41)
  IN3 w0.064: v4(66.18,7.41) 66.18,7.87 v5(66.45,8.14)
KSO05: length 43
  TOP w0.081: v2(49.96,32.9) 49.96,33 50.38,33.43 RE79.2 50.38,33.77 51.6,34.99 v1(52.08,34.99)
  IN1 w0.064: v2(48.98,29.53) 48.98,29.75 49.35,30.11 49.35,32.3 v2(49.96,32.9) 50.27,32.59 v4(50.27,32.2)
  IN2 w0.066: v4(50.27,32.2) 50.47,32 50.47,31.61 51.1,30.97 52.6,30.97 52.8,30.77 56.26,30.77 57.27,29.77 57.27,24.22 56.79,23.74 56.79,22.94 57.16,22.57 57.16,18.59 61.76,13.99 61.76,13.58 65.65,9.69 v4(65.65,7.44)
  IN3 w0.064: v5(65.65,8.14) v4(65.65,7.44)
KSO06: length 43.6
  TOP w0.081: v2(49.04,31.78) 49.04,31.36 48.73,31.05 UE1.A35
  IN1 w0.064: v4(48.98,30.99) 48.98,31.52 49.04,31.58 v2(49.04,31.78) ; v4(68.05,7.44) 68.05,7.12 v2(67.54,6.61)
  IN2 w0.066: v4(48.98,30.99) 48.98,31.72 49.83,32.57 50.48,32.57 50.55,32.5 51.64,32.5 51.77,32.38 52.02,32.38 53.04,31.35 56.5,31.35 57.91,29.94 57.91,23.11 57.93,23.09 57.93,18.99 59.73,17.19 60.71,17.19 62.53,15.37 62.53,13.9 63.47,12.97 65.38,12.97 68.05,10.29 v4(68.05,7.44)
  IN3 w0.064: v5(68.05,8.14) v4(68.05,7.44)
KSO07: length 40.4
  TOP w0.081: v2(49.65,31.78) 49.65,31.39 49.23,30.98 UE1.A34
  IN1 w0.064: v2(65.89,6.61) 66.42,6.61 v4(67.25,7.44) ; v2(49.65,31.78) 50.51,31.78 v4(50.87,32.14)
  IN2 w0.066: v4(50.87,32.14) 51.52,32.14 51.75,31.91 52.22,31.91 52.96,31.16 56.42,31.16 57.66,29.93 57.66,24.06 57.18,23.58 57.18,23.1 57.54,22.73 57.54,18.82 60.44,15.92 61.31,15.92 62.15,15.09 62.15,13.74 67.12,8.77 67.12,7.58 v4(67.25,7.44)
  IN3 w0.064: v5(67.25,8.14) v4(67.25,7.44)
KSO08: length 54.9
  TOP w0.081: v2(45.45,28.8) 45.45,28.96 44.98,29.42 UE1.B45
  IN1 w0.064: v2(68.83,8.23) 68.83,7.46 v4(68.85,7.44) ; v2(45.45,28.8) 45.49,28.85 45.49,29.01 45.17,29.33 45.17,30.29 45.29,30.4 45.29,30.71 44.6,31.4 44.6,31.99 44.46,32.14 43.97,32.14 v4(43.79,32.32) 43.76,32.32 43.62,32.47 43.62,33.21 43.09,33.73 v2(42.97,33.73)
  IN2 w0.066: v4(43.79,32.32) 43.79,32.27 43.87,32.19 43.87,31.32 44.63,30.56 47.52,30.56 50.39,33.43 51.47,33.43 52.31,32.59 52.31,32.36 53.12,31.54 56.58,31.54 58.1,30.02 58.1,23.19 58.14,23.15 58.14,22.75 58.76,22.13 58.76,21.12 59.24,20.64 59.24,20.02 60.67,18.59 60.67,17.51 62.76,15.42 62.76,14.8 64.02,13.55 65.07,13.55 68.85,9.77 68.85,7.45 v4(68.85,7.44)
  IN3 w0.064: v5(68.85,8.14) v4(68.85,7.44)
KSO09: length 62.6
  TOP w0.081: UE1.A43 44.73,30.68 44.47,30.94 44.44,30.94 44.11,31.27 43.91,31.27 43.66,31.52 43.36,31.52 43.18,31.69 43.18,31.78 RE18.2 43.02,31.92 v2(43,31.9)
  IN1 w0.064: v4(76.85,8.33) 76.74,8.22 v2(76.44,8.22) ; v2(43,31.9) 43.06,31.84 43.06,31.71 43.22,31.56 v4(43.22,31.28)
  IN2 w0.066: v4(76.85,8.33) 76.85,8.42 75.68,9.59 71.58,9.59 67.4,13.77 67.4,14.62 67.06,14.95 66.16,14.95 62.77,18.34 62.77,19.86 61.35,21.28 61.35,23.89 59.89,25.35 59.89,30.73 55.23,35.39 50.18,35.39 49,34.21 42.86,34.21 42.51,33.86 42.33,33.86 41.25,32.78 41.25,31.92 42.17,30.99 42.93,30.99 v4(43.22,31.28)
  IN3 w0.064: v5(76.85,7.49) v4(76.85,8.33)
  BOTTOM w0.089: JKB1.7 v5(76.85,7.49)
KSO10: length 64.8
  TOP w0.081: v2(45.07,28.89) 45.06,28.87 44.57,28.87 44.48,28.96 UE1.B46
  IN1 w0.064: v4(42.31,34.23) 42.32,34.21 v2(42.32,33.57) 42.47,33.43 43.13,33.43 43.36,33.19 43.36,32.18 43.33,32.15 43.33,31.71 43.71,31.33 44.11,31.33 44.98,30.46 44.98,28.98 v2(45.07,28.89) ; v2(79.36,7.69) 79.2,7.53 v4(78.45,7.53)
  IN2 w0.066: v4(42.31,34.23) 42.48,34.41 48.92,34.41 50.14,35.63 55.28,35.63 60.14,30.77 60.14,25.83 61.54,24.42 61.54,21.36 62.97,19.94 62.97,18.42 66.24,15.15 67.16,15.15 67.59,14.72 67.59,14.7 67.59,14.69 67.59,13.85 71.66,9.78 76.9,9.78 78.45,8.23 v4(78.45,7.53)
  IN3 w0.064: v5(78.45,8.14) v4(78.45,7.53)
KSO11: length 50.6
  IN1 w0.064: v2(45.27,17.22) 46.56,18.51 47.18,18.51 47.26,18.59 47.26,19.46 46.48,20.23 v2(46.48,20.33) 46.46,20.31 46.09,20.31 45.8,20.02 45.8,19.51 v4(45.68,19.39) ; v2(77.88,6.78) 77.67,6.99 v4(77.67,7.53)
  IN2 w0.066: v4(45.68,19.39) 46.01,19.39 46.63,18.77 47.3,18.77 47.93,18.13 49.36,18.13 49.73,18.51 52.14,18.51 52.31,18.68 53.02,18.68 53.23,18.46 53.23,17.97 55.45,15.75 57,15.75 58.98,13.77 58.98,9.65 58.79,9.46 58.79,7.73 60.52,6 76.67,6 77.67,7 v4(77.67,7.53)
  IN3 w0.064: v4(77.67,7.53) 77.65,7.55 v5(77.65,8.14)
KSO12: length 61.6
  TOP w0.081: UE1.B47 43.98,28.78 44.25,28.52 v2(45.16,28.52) ; v2(41.94,32.92) 41.83,33.02 41.83,33.31 41.76,33.38 RE84.2
  IN1 w0.064: v4(72.85,7.44) 72.73,7.44 71.89,6.61 v2(70.84,6.61) ; v2(45.16,28.52) 44.97,28.52 44.79,28.7 44.79,30.38 44.51,30.67 42.82,30.67 42.12,31.36 42.12,31.51 42,31.64 v4(42,32.25) 41.94,32.31 v2(41.94,32.92)
  IN2 w0.066: v4(72.85,7.44) 72.85,8.41 72.38,8.89 71.37,8.89 62.07,18.19 62.07,19.74 60.77,21.05 60.77,23.3 59.65,24.41 59.56,24.41 59.07,24.91 59.07,30.46 56.98,32.55 54.73,32.55 52.91,34.37 49.97,34.37 48.92,33.32 45.25,33.32 44.62,32.69 43.64,32.69 43.16,32.21 42.04,32.21 v4(42,32.25)
  IN3 w0.064: v5(72.85,8.14) v4(72.85,7.44)
KSO13: length 60.1
  TOP w0.081: v2(42.46,32.07) 42.46,31.8 42.71,31.56 43.01,31.56 43.27,31.3 43.57,31.3 43.82,31.05 43.91,31.05 44.23,30.73 UE1.A44
  IN1 w0.064: v2(75.79,6.61) 75.79,6.68 75,7.48 v4(74.99,7.48) ; v4(42.62,31.41) 42.46,31.57 v2(42.46,32.07)
  IN2 w0.066: v4(74.99,7.48) 74.99,8.21 73.83,9.37 71.53,9.37 67.14,13.76 67.14,14.49 66.89,14.74 66.86,14.74 66.85,14.76 66.08,14.76 62.46,18.38 62.46,19.9 61.16,21.2 61.16,23.45 60.79,23.82 59.7,24.91 59.7,30.65 59.69,30.65 59.69,30.66 55.2,35.15 50.21,35.15 49.08,34.02 42.94,34.02 42.59,33.67 42.41,33.67 41.44,32.7 41.44,32 42.03,31.41 v4(42.62,31.41)
  IN3 w0.064: v5(75.25,8.14) 75.25,7.74 v4(74.99,7.48)
KSO14: length 45.5
  TOP w0.081: UE1.A9 46.23,19.36 v2(46.24,19.36) ; RE88.2 51.97,17.95 52.34,17.58 53.43,17.58 v2(53.51,17.66) 53.7,17.85 v1(53.91,17.85)
  IN1 w0.064: v4(54.08,17.74) 54,17.66 v2(53.51,17.66) ; v4(46.26,19.9) 46.26,19.82 46.24,19.8 v2(46.24,19.36)
  IN2 w0.066: v4(76.27,7.53) 76.27,6.62 76.01,6.36 60.91,6.36 58.98,8.29 58.98,9.38 59.32,9.72 59.32,13.71 56.94,16.08 55.74,16.08 v4(54.08,17.74) 54.01,17.81 53.92,17.81 53.48,18.25 53.48,18.49 53.1,18.87 52.23,18.87 52.06,18.7 49.65,18.7 49.28,18.33 48.01,18.33 47.37,18.98 46.72,18.98 46.26,19.44 v4(46.26,19.9)
  IN3 w0.064: v4(76.27,7.53) 76.27,7.93 v5(76.05,8.14)
KSO15: length 37
  TOP w0.081: v2(52.78,27.58) 52.54,27.58 52.44,27.68 UE1.A30
  IN1 w0.064: v2(74.14,6.61) 74.45,6.92 v4(74.45,7.44) ; v4(52.64,27.98) 52.86,27.76 52.86,27.67 v2(52.78,27.58)
  IN2 w0.066: v4(74.45,7.44) 74.09,7.08 72.52,7.08 72.43,7.16 72.43,8.4 72.15,8.69 71.3,8.69 61.88,18.11 61.88,19.66 60.57,20.97 60.57,22.52 59.44,23.66 v4(59.24,23.66)
  IN3 w0.064: v5(74.45,8.14) v4(74.45,7.44) ; v4(52.64,27.98) 52.66,27.96 52.66,27.46 53.2,26.92 55.68,26.92 58.94,23.66 v4(59.24,23.66)
KSO16: length 62.8
  TOP w0.081: RE89.2 40.53,29.84 v2(40.53,29.84) UE1.A49
  IN1 w0.064: v2(40.53,29.84) 40.53,29.91 40.73,30.11 40.73,30.79 v4(40.78,30.84) ; v2(72.49,6.61) 72.82,6.61 v4(73.65,7.44)
  IN2 w0.066: v4(73.65,7.44) 73.65,8.81 73.35,9.11 71.42,9.11 62.7,17.83 62.7,17.83 62.27,18.27 62.27,19.82 60.96,21.13 60.96,23.38 59.5,24.84 59.5,30.58 55.24,34.84 50.17,34.84 49.02,33.69 42.95,33.69 42.73,33.47 42.49,33.47 41.64,32.62 41.64,32.08 41.95,31.77 43.35,31.77 43.68,31.44 43.68,30.93 43.55,30.8 41.69,30.8 41.53,30.96 40.91,30.96 v4(40.78,30.84)
  IN3 w0.064: v5(73.65,8.14) v4(73.65,7.44)
LANWAKE#: length 3.9
  TOP w0.081: v2(144.46,55.62) v1(145.04,56.19) 145.24,56.39 145.24,57.91 145.1,58.05 RC93.2
  IN1 w0.064: v4(144.72,55.36) 144.64,55.36 144.46,55.54 v2(144.46,55.62)
  IN3 w0.064: v4(144.72,55.36) 145.06,55.36 v5(145.1,55.32)
LCD_CBL_DET#: length 190.8
  TOP w0.081: v2(88.04,14.86) 88.04,22.51 v1(87.97,22.57) 87.97,23.61 88.55,24.19 88.55,25.44 v2(88.55,25.44) ; v2(25.44,74.84) 25.32,74.84 25.08,75.07 25.08,75.46 R90.2
  IN1 w0.064: v2(88.04,14.86) 88.37,14.53 88.95,14.53 89.56,15.14 90,15.14 90.32,14.82 v4(90.32,14.31) ; v2(88.55,25.44) 88.55,25.58 85.39,28.74 79.82,28.74 78.43,30.14 78.43,33.23 v4(78.56,33.36) ; v4(25.78,74.91) 25.71,74.84 v2(25.44,74.84)
  IN2 w0.066: v4(90.32,14.31) 90.64,14.63 92.44,14.63 92.88,15.07 111.33,15.07 111.77,14.63 118.2,14.63 118.24,14.68 118.54,14.68 121.91,18.05 122.64,18.05 122.96,18.05 124.51,19.6 124.51,21.43 126.22,23.14 128.24,23.14 128.46,22.93 129.48,22.93 129.63,23.08 129.63,25.26 131.77,27.41 135.23,27.41 136.06,28.23 136.06,29.78 135.93,29.91 135.93,35.37 134.51,36.79 134.51,39.69 135.33,40.51 135.33,41.58 136.09,42.34 137.6,42.34 138.03,41.91 139.63,41.91 140.15,42.43 v4(140.15,42.95) ; v4(25.78,74.91) 25.85,74.84 25.93,74.84 26.02,74.74 28.31,74.74 28.73,74.32 v4(28.8,74.32) 28.99,74.51 29.43,74.51 31.39,76.47 40.15,76.47 44.49,72.13 44.49,68.74 47.1,66.13 47.1,66.13 47.22,66.01 47.22,63.54 47.58,63.18 47.58,60.19 48.21,59.57 48.21,54.93 49.67,53.48 49.67,51.87 50.68,50.86 50.68,50.16 53.76,47.08 61.5,47.08 68.28,40.3 68.97,40.3 71.07,38.19 74.28,38.19 74.84,37.64 76.94,37.64 78.43,36.14 78.43,33.5 v4(78.56,33.36)
  IN3 w0.064: v5(28.6,73.26) 28.6,74.12 v4(28.8,74.32) ; v4(140.15,42.95) 140.15,42.95 v5(139.84,42.63)
  BOTTOM w0.081: v5(28.6,73.26) 28.6,72.8 28.35,72.55 JEDP1.32
LCD_TST: length 72
  TOP w0.081: v2(52.04,26.04) 52.04,26.02 51.7,25.68 UE1.A26
  IN1 w0.064: v2(52.04,26.04) 52.04,26.11 51.5,26.65 49.74,26.65 v4(49.5,26.89) ; v4(39.28,33.93) 39.28,34.41 40.32,35.45 v2(40.53,35.45) 40.99,35.45 41.78,36.24 41.78,37.26 40.35,38.69 40.35,44.03 38.42,45.97 38.42,49.59 38.58,49.76 38.58,50.61 38.95,50.98 38.95,52.74 39.36,53.14 39.36,55.71 40.09,56.45 40.09,57.22 39.99,57.32 39.99,58.67 39.49,59.17 39.49,61.14 38.29,62.34 38.29,63.39 37.54,64.13 37.39,64.13 36.24,65.29 36.24,66.72 36.04,66.92 35.74,66.92 35.57,67.08 35.57,68.04 35.81,68.27 35.81,70.06 35.36,70.51 34.66,70.51 33.74,71.42 33.74,71.96 33.42,72.29 32.93,72.29 32.52,72.7 32.51,72.7 31.3,72.7 30.93,73.07 30.93,73.86 31.49,74.41 v4(31.59,74.41)
  IN3 w0.064: v5(30.6,72.94) 30.6,73.51 31.5,74.41 v4(31.59,74.41) ; v4(39.28,33.93) 40.14,33.07 41.07,33.07 41.24,33.24 43.98,33.24 44.21,33.47 46.28,33.47 46.66,33.1 46.66,32.45 46.32,32.11 46.32,31.48 49.5,28.3 v4(49.5,26.89)
  BOTTOM w0.081: v5(30.6,72.94) 30.6,72.77 30.75,72.61 JEDP1.26
LCD_VCC_TEST_EN: length 58.5
  IN1 w0.064: v4(42.86,19.11) 42.86,19.17 43.08,19.39 v2(43.23,19.39) ; v4(32.6,21.81) 32.6,22.49 30.74,24.35 30.74,26.98 30.74,27.18 32.66,29.11 32.91,29.11 33.41,29.11 33.41,29.11 33.54,29.11 34.84,30.4 34.84,31.76 35.31,32.23 35.31,33.57 34.83,34.06 34.83,34.45 35.21,34.83 35.21,35.71 35.54,36.03 35.54,36.05 35.54,36.05 35.54,37.42 36.71,38.59 36.71,40.54 37.24,41.06 37.24,43.6 35.91,44.93 35.91,50.63 36.08,50.8 36.08,51.62 35.97,51.73 35.97,53.49 36.19,53.71 36.19,53.8 36.28,53.89 36.28,55.19 36.66,55.58 36.66,57.29 36,57.95 v4(35.71,57.95)
  IN2 w0.066: v4(32.6,21.81) 32.95,21.46 34.22,21.46 36.33,19.34 36.59,19.34 37.2,18.73 42.48,18.73 v4(42.86,19.11)
  IN3 w0.064: v5(36,58.14) 35.9,58.14 v4(35.71,57.95)
  BOTTOM w0.081: v5(36,58.14) 36,58.16 36.75,58.91 D4.3
LCDVDD_EN: length 22.2
  TOP w0.081: v2(45.2,53.96) 45.2,52.7 v1(44.98,52.48)
  IN1 w0.064: v4(45.62,54.59) 45.57,54.54 45.57,54.32 v2(45.2,53.96)
  IN2 w0.066: v4(35.86,62.03) 35.24,61.41 35.24,59.87 34.9,59.53 34.9,58.52 34.51,58.13 34.51,57.08 34.96,56.63 34.96,55.54 v4(35.09,55.41)
  IN3 w0.064: v4(35.86,62.03) 35.62,62.03 v5(35.45,62.2) ; v4(35.09,55.41) 35.24,55.26 36.62,55.26 36.78,55.42 37.04,55.42 37.31,55.69 39.73,55.69 40.39,55.03 41.44,55.03 41.79,54.68 43.48,54.68 43.68,54.48 43.68,54.15 43.85,53.99 44.6,53.99 45.2,54.59 v4(45.62,54.59)
LCDVDD_MONITOR: length 1.6
  TOP w0.081: QV21.2 29.48,75.44 29.22,75.18 29.22,74.53 RV630.2
LCDVDD_MONITOR_R: length 6.9
  TOP w0.081: QV18.3 33.24,71.99 33.76,72.51 33.76,73.73 33.55,73.93 32.98,73.93 32.58,74.32 32.58,74.36 32.15,74.79 30.07,74.79 RV630.1
LDO_+1.35VGPU: length 1.5
  TOP w0.081: v1(64.14,52.83) 64.16,52.83 PCW22.1
LG1_CHG: length 18.6
  IN3 w0.762: 190.89,6.16 191.62,6.89 193.86,6.89 195.22,8.25 195.22,16.13 197.58,18.49 197.58,20.35
  BOTTOM w0.203: v5(197.71,21.53) 197.71,21.53 PUB01.9 v5(197.71,21.89)
  vias: v5(190.21,6.44) v5(190.21,6.06)
LG2_CHG: length 15.5
  IN3 w0.762: 198.69,22.59 198.69,21.18 200.04,19.83 200.04,17.78 201.24,16.59 208.19,16.59 208.63,17.03 208.63,17.95
  vias: v5(198.57,22.87) v5(199.01,22.87) v6(209.38,18.95) v6(209.38,18.32)
LID_CL_SIO#: length 14.1
  TOP w0.081: UE1.A36 48.23,30.87 48.43,31.07 RE28.2 48.06,31.78 48.03,31.75 v2(47.66,31.75) ; v3(42.23,35.38) 41.4,35.38 40.71,34.69 v2(40.71,33.96)
  IN1 w0.064: v2(47.66,31.75) 47.66,32.14 v4(47.99,32.48) ; v4(41.04,34.01) 40.76,34.01 v2(40.71,33.96)
  IN3 w0.064: v4(41.04,34.01) 41.16,34.13 41.41,34.13 41.51,34.03 41.61,34.03 41.77,33.87 43.67,33.87 44.04,34.24 46.32,34.24 47.99,32.57 v4(47.99,32.48)
LID_CLOSE#: length 2.8
  IN1 w0.064: v4(3.89,73.57) 3.89,73.65 v2(4.19,73.95)
  IN3 w0.064: v5(3.89,74.13) v4(3.89,73.57)
  BOTTOM w0.081: v5(3.89,74.13) CE34.1 R25.2 3.9,75.3 RE161.1
LID_POWER_ON#: length 37.8
  TOP w0.081: v2(62.31,24.44) 62.95,25.08 63.21,25.08 63.82,25.69 v1(63.82,30.18) 63.82,32.26 63.69,32.39 Q19.1 ; RE31.1 39.87,20.94 v2(39.96,21.03) 39.96,21.42 40.22,21.68 UE1.A63
  IN1 w0.064: v2(62.31,24.44) 62.27,24.44 62.17,24.54 58.93,24.54 58.17,23.77 57.26,23.77 55.92,22.44 55.84,22.44 55.56,22.16 55,22.16 54.78,21.94 54.45,21.94 54.24,21.73 53.61,21.73 53.34,21.46 52.87,21.46 52.84,21.5 52.05,21.5 51.93,21.38 50.84,21.38 50.36,21.85 50.23,21.85 49.42,22.66 49.19,22.66 48.79,23.05 v4(48.79,23.43) ; v2(39.96,21.03) 39.96,21.42 v4(39.92,21.45)
  IN2 w0.066: v4(48.79,23.43) 48.79,23.54 48.3,24.03 44.03,24.03 41.45,21.45 v4(39.92,21.45)
LID_POWER_ON#_G: length 4.7
  TOP w0.081: v1(61.9,33.23) 63.04,32.09 Q19.2 63.04,30.28 RE98.2 62.96,30.2 U34.5
LX1_CHG: length 6.6
  IN3 w0.762: 199.01,18.98 199,18.96 199,16.98 200.12,15.86 200.12,14.66
  BOTTOM w0.081: v1(200.25,18.66) 200.25,17.35 PRB17.1
  vias: v5(199.05,19.73) v5(199.35,19.5) v5(200.88,14.59) v5(200.88,14.24)
LX2_CHG: length 5.3
  IN3 w0.762: 206.55,21.87 201.29,21.87
  vias: v5(200.44,22.16) v5(200.42,21.84) v5(206.72,21.17) v5(206.72,20.66)
LX_1.2V: length 1.7
  TOP w0.081: v3(192.66,67.26) 194.4,67.26
  vias: v2(195.91,68.41) v2(195.91,68.03) v2(195.91,67.65) v2(196.29,68.41) v2(196.29,68.03) v2(196.29,67.65) v2(198.2,68.95) v2(198.2,68.57) v2(198.2,68.19) v2(198.2,67.81) v2(198.2,67.42) v2(198.2,67.04) v2(198.59,68.95) v2(198.59,68.57) v2(198.59,68.19) v2(198.59,67.81) v2(198.59,67.42) v2(198.59,67.04) v4(196.68,68.67) v4(196.68,68.16) v4(196.68,67.65) v4(196.68,67.15) v4(197.19,68.67) v4(197.19,68.16) v4(197.19,67.65) v4(197.19,67.15) v4(197.7,68.67) v4(197.7,68.16) v4(197.7,67.65) v4(197.7,67.15) v5(195.78,70.15) v5(195.78,69.85) v5(195.78,69.54) v5(195.78,69.24) v5(196.08,70.15) v5(196.08,69.85) v5(196.08,69.54) v5(196.08,69.24) v5(196.42,70.17) v5(196.8,70.17) v5(197.13,70.58) v5(197.13,70.19) v5(197.23,69.85) v5(197.23,69.48) v5(197.51,70.58) v5(197.51,70.19) v5(197.53,69.86) v5(197.53,69.48)

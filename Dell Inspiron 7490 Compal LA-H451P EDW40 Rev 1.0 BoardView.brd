# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
X_FRB5014A_4P
  rect 0.991x0.991 smd: 1(0,0) 2(1.65,0) 3(1.65,1.25) 4(0,1.25)
Y_8Y24000011_4P
  rect 0.889x0.787 smd: 1(0,0) 2(1.4,0) 3(1.4,1.1) 4(0,1.1)
Y_8Y25000004_4P
  rect 0.889x0.787 smd: 1(0,0) 2(1.4,0) 3(1.4,1.1) 4(0,1.1)
Y_8Y27000002_4P
  rect 0.889x0.787 smd: 1(0,0) 2(1.4,0) 3(1.4,1.1) 4(0,1.1)
Y_9H03280012_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_XRCGB24M000F2P51R0_4P
  rect 0.762x0.711 smd: 1(0,0) 2(1.35,0) 3(1.35,1) 4(0,1)

## Nets
0.6V_DDR_VTT_ON: PRM17.1 RC19.2 RC523.2 UC2.4
1.0V_VCCST_EN: CZ3.1 DZ5.2 RZ1418.2 UZ1.5
1.0VS_DGPU_EN: PRF02.2 PRF03.1 QV145.2 UV10.4
1.0VS_DGPU_EN#: QV145.5 QV145.6 RV2007.2
1.0VS_DGPU_EN_U: CV196.2 DV5.2 RV103.2 UV10.1
1.2V_DDR_OT: PRM19.2 PUM01.11
1.2V_VDDQ_EN: CZ225.1 DZ7.2 PRM22.1 RZ9.2
1.2V_VTT_PWRGD: PRM26.1 PUM01.12 RE509.2
1.05V_PRIM_PG: PRH07.1 PUH01.16 RE507.2
1.8V_PRIM_PG: PR1802.1 PR1814.2 PU1801.5 RE165.2
1.35V_PWR_EN: PRW19.2 QV152.2 UV23.4
1.35V_PWR_EN#: QV152.5 QV152.6 RV5008.2
3V3_1.2V: PCM20.1 PRM27.1 PUM01.3
3V3_5V: PC513.1 PR501.2 PU501.3
+0.6V_DDR_VTT: CD100.1 CD101.1 CD102.1 CD103.1 CD104.1 CD105.1 CD106.1 CD107.1 CD108.1 CD109.1 CD110.1 CD111.1 PJPM3.2 RD29.2 RD30.2 RD31.2 RD32.2 RD33.2 RD34.2 RD35.2 RD36.2 RD37.2 RD38.2 RD39.2 RD40.2 RD41.2 RD42.2 RD43.2 RD44.2 RD45.2 RD46.2 RD47.2 RD48.2 RD49.2 RD50.2 RD51.2 RD52.2 RD53.2 RD54.2 RD55.2 RD56.2 RD57.2 RD58.2 RD59.2 RD60.2 RD61.2 RD62.2 RD63.2 RD64.2 RD65.2 RD66.2 RD67.2 RD68.2 RD69.2 RD70.2 RD71.2 RD72.2 RD73.2 RD74.2 RD75.2 RD76.2 RD77.2 RD78.2 RD79.2 RD80.2 RD81.2 RD82.2 RD83.2 RD84.2 RD85.2 RD86.2 RD87.2 RD88.2 RD89.2 RD90.2
+0.6VSP: PCM21.1 PCM25.1 PJPM3.1 PUM01.5 PUM01.8
+0.9V_TBT_LC: CT333.1 CT369.1 UT1.J8
+0.9V_TBT_LVR_OUT: CT329.1 CT330.1 CT331.1 CT332.1 CT367.1 CT368.1 UT1.H6 UT1.H8
+0.9V_TBT_PCIE: CT337.1 CT338.1 CT339.1 CT340.1 CT341.1 CT370.1 CT371.1 UT1.J18 UT1.L18 UT1.L19 UT1.M16 UT1.M18 UT1.M19
+0.9V_TBT_SVR: CT305.1 CT306.1 CT307.1 CT308.1 CT309.1 CT310.1 CT311.1 CT316.2 CT317.2 CT318.2 CT319.2 CT320.2 CT321.2 CT322.2 CT334.1 CT335.1 CT336.1 CT363.1 CT364.1 CT365.1 CT366.1 LT10.2 UT1.E8 UT1.H9 UT1.H11 UT1.H12 UT1.H13 UT1.H15 UT1.H16 UT1.J13 UT1.L11 UT1.L13 UT1.M8 UT1.M11 UT1.M13 UT1.N6 UT1.N8 UT1.N11 UT1.N13 UT1.R8 UT1.R11 UT1.R13 UT1.R16 UT1.T8 UT1.T9 UT1.T11 UT1.T12 UT1.T13 UT1.T15 UT1.T16
+1.0VGAP: PCF04.1 PCF05.1 PCF06.1 PCF07.1 PCF08.1 PJPF02.1 PRF05.1 PUF01.9 PUF01.10
+1.0VS_DGPU: CV2.1 CV9.1 CV199.1 CV202.1 CV204.1 CV205.1 CV222.1 CV393.1 CV767.1 CV768.1 CV931.1 PJPF02.2 RV2006.1 UV1.AA22 UV1.AB23 UV1.AC24 UV1.AD25 UV1.AE26 UV1.AE27
+1.0VS_DGPU_PGOOD: PRF04.2 PUF01.3 UV23.1
+1.2V_DDR: CC1.2 CC34.1 CC35.1 CC36.1 CC37.1 CC38.1 CC39.1 CC40.1 CC41.1 CC42.1 CC43.1 CC44.1 CC45.1 CC46.1 CC47.1 CC76.2 CC81.1 CC82.1 CC83.1 CC84.1 CC112.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD11.1 CD13.1 CD14.1 CD15.1 CD16.1 CD17.1 CD18.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD24.1 CD25.1 CD26.1 CD43.1 CD46.1 CD49.1 CD50.1 CD51.1 CD53.1 CD54.1 CD55.1 CD56.1 CD57.1 CD58.1 CD63.1 CD65.1 CD66.1 CD67.1 CD68.1 CD69.1 CD70.1 CD71.1 CD73.1 CD74.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 CD83.1 CD84.1 CD85.1 CD86.1 CD87.1 CD88.1 CD90.1 CD91.1 CD114.1 CD115.1 CD116.1 CD117.1 CD118.1 CD122.1 CD123.1 CD124.1 CD131.1 CD132.1 CD133.1 CD137.1 CD138.1 CD139.1 CD144.1 CD145.1 CD146.1 CD147.1 CZ38.1 PJPM4.2 RC576.1 RD10.1 RD21.1 RD28.1 RZ11.1 UC1.AD36 UC1.AH32 UC1.AH36 UC1.AM36 UC1.AN32 UC1.AW32 UC1.AY36 UC1.BE32 UC1.BH36 UC1.R32 UC1.Y36 UC2.5 UD41.A8 UD41.A9 UD41.A11 UD41.C12 UD41.D4 UD41.D5 UD41.D6 UD41.E8 UD41.E12 UD41.F2 UD41.G2 UD41.G5 UD41.G12 UD41.H3 UD41.H5 UD41.H6 UD41.H8 UD41.H9 UD41.H11 UD41.H12 UD41.J5 UD41.J6 UD41.J9 UD41.J10 UD41.K5 UD41.K6 UD41.K8 UD41.K11 UD41.K12 UD41.L2 UD41.L5 UD41.L12 UD41.M2 UD41.N8 UD41.N12 UD41.P4 UD41.P5 UD41.P6 UD41.R12 UD41.U8 UD41.U9 UD41.U11 UD42.A8 UD42.A9 UD42.A11 UD42.C12 UD42.D4 UD42.D5 UD42.D6 UD42.E8 UD42.E12 UD42.F2 UD42.G2 UD42.G5 UD42.G12 UD42.H3 UD42.H5 UD42.H6 UD42.H8 UD42.H9 UD42.H11 UD42.H12 UD42.J5 UD42.J6 UD42.J9 UD42.J10 UD42.K5 UD42.K6 UD42.K8 UD42.K11 UD42.K12 UD42.L2 UD42.L5 UD42.L12 UD42.M2 UD42.N8 UD42.N12 UD42.P4 UD42.P5 UD42.P6 UD42.R12 UD42.U8 UD42.U9 UD42.U11 UD43.A8 UD43.A9 UD43.A11 UD43.C12 UD43.D4 UD43.D5 UD43.D6 UD43.E8 UD43.E12 UD43.F2 UD43.G2 UD43.G5 UD43.G12 UD43.H3 UD43.H5 UD43.H6 UD43.H8 UD43.H9 UD43.H11 UD43.H12 UD43.J5 UD43.J6 UD43.J9 UD43.J10 UD43.K5 UD43.K6 UD43.K8 UD43.K11 UD43.K12 UD43.L2 UD43.L5 UD43.L12 UD43.M2 UD43.N8 UD43.N12 UD43.P4 UD43.P5 UD43.P6 UD43.R12 UD43.U8 UD43.U9 UD43.U11 UD44.A8 UD44.A9 UD44.A11 UD44.C12 UD44.D4 UD44.D5 UD44.D6 UD44.E8 UD44.E12 UD44.F2 UD44.G2 UD44.G5 UD44.G12 UD44.H3 UD44.H5 UD44.H6 UD44.H8 UD44.H9 UD44.H11 UD44.H12 UD44.J5 UD44.J6 UD44.J9 UD44.J10 UD44.K5 UD44.K6 UD44.K8 UD44.K11 UD44.K12 UD44.L2 UD44.L5 UD44.L12 UD44.M2 UD44.N8 UD44.N12 UD44.P4 UD44.P5 UD44.P6 UD44.R12 UD44.U8 UD44.U9 UD44.U11 UZ7.1 UZ7.2 UZ7.7
+1.2V_DDRP: PCM23.1 PCM24.1 PCM29.1 PCM31.1 PCM32.1 PJPM4.1 PLM13.2 PRM25.1 PUM01.6
+1.2V_DTH: CM10.1 CM25.1 CM31.1 CM41.1 LM2.1 LM3.1 LM4.1 LM5.1 RM1.1
+1.2V_DTH_OUT: CM48.1 CM50.1 RM1.2 RM39.1 UM2.2 UM2.3
+1.05V_MPHYPLL: CC53.1 CC54.1 CC86.1 CC103.1 LC3.2 UC1.BV2
+1.05V_PRIM: CC48.1 CC49.1 CC55.1 CC62.1 CC85.1 CC102.1 CZ2.1 CZ9.1 LC3.1 PJPH01.2 RC130.1 RC251.1 RE538.2 UC1.BP14 UC1.BP20 UC1.BP22 UC1.BR12 UC1.BR14 UC1.BR15 UC1.BR20 UC1.BT12 UC1.BT18 UC1.BT19 UC1.BT22 UC1.BU12 UC1.BU14 UC1.BU15 UC1.BU18 UC1.BU19 UC1.BU22 UC1.BV12 UC1.BV14 UC1.BV15 UC1.BV16 UC1.BV18 UC1.BV19 UC1.BV20 UC1.BV22 UC1.BW12 UC1.BW14 UC1.BW16 UC1.BW18 UC1.BW19 UC1.BW20 UC1.BW22 UC1.BY12 UC1.BY14 UC1.BY16 UC1.BY20 UC1.CA12 UC1.CA14 UC1.CA16 UC1.CA18 UC1.CA19 UC1.CA20 UC1.CB12 UC1.CB14 UC1.CB15 UC1.CC12 UZ1.1 UZ1.2 UZ1.6 UZ1.7 UZ2.1 UZ2.2 UZ2.7
+1.05V_PRIMP: PCH05.1 PCH06.1 PCH07.1 PCH08.1 PCH12.1 PCH17.1 PCH20.1 PCH21.1 PCH22.1 PJPH01.1 PLH01.2 PRH05.1
+1.05V_VCCDSW: CC59.1 UC1.BT24
+1.05V_XDP: CC107.1 CC108.1 JXDP1.43 JXDP1.44 RC251.2 RC538.1
+1.05V_XTAL: CC56.1 CC57.1 CC101.1 RC130.2 UC1.CP5
+1.8V_PRIM: C61.1 CC61.1 CC64.1 CM49.1 CV786.1 CV787.1 CZ223.1 JIO1.3 PJP1800.2 PJPF01.1 PRV36.1 PRV37.1 PRV49.1 PRV50.1 PRZ15.1 PRZ54.1 R26.1 RC52.1 RC53.1 RC122.1 RC162.1 RC200.1 RC215.1 RC217.1 RC219.1 RC221.1 RC223.1 RC225.1 RC226.1 RE7.1 RV162.1 U19.1 U19.2 UC1.CC15 UC1.CC18 UC1.CC19 UC1.CD15 UC1.CD16 UC1.CD18 UC1.CD19 UC1.CP17 UC1.CP23 UM2.7 UM2.8 UZ8.1 UZ8.2
+1.8V_PRIM_UV2: CV323.1 CV755.2 RV162.2 UV2.1 UV2.2 UV2.6 UV2.7
+1.8V_PRIMP: PC1805.1 PC1806.1 PC1807.1 PC1808.1 PC1811.2 PC1818.1 PC1819.1 PJP1800.1 PL1801.2 PR1806.1
+1.8VALW_1.0V: PCF02.1 PJPF01.2 PUF01.1 PUF01.2
+1.8VALW_EC: CE13.1 RE7.2 UE1.B19
+1.8VS: C62.1 CS43.1 CS44.1 Q28.2 Q28.5 QN7.2 QN7.5 R6906.2 RN3.1 RN92.1 RS4.1 RS5.1 RS6.1 RS7.1
+1.8VS_DGPU_AON: CV212.1 CV213.1 CV214.1 CV325.1 CV397.1 CV756.1 CV757.1 CV778.1 CV779.1 CV789.1 RV51.1 RV61.1 RV68.1 RV69.2 RV72.2 RV77.2 RV80.1 RV81.1 RV84.1 RV90.2 RV91.2 RV92.2 RV93.2 RV203.2 RV204.2 RV205.2 RV206.2 RV207.2 RV208.2 RV382.1 RV384.1 RV389.1 RV398.1 RV4991.2 RV4998.1 RV5005.1 UV1.G10 UV1.G12 UV2.8 UV2.9 UV10.5 UV12.5 UV23.5 UV26.5
+1.8VS_DGPU_AON_UV26: QV150.6 RV4998.2 UV26.2
+1.8VS_DGPU_MAIN: CV211.1 CV216.1 CV219.1 CV220.1 CV324.1 CV776.1 CV777.1 CV788.1 CV935.1 LV7.2 LV10.1 RV4970.2 RV4976.2 RV5001.2 RV5003.1 UV1.G8 UV1.G9 UV2.13 UV2.14
+1.8VS_R: R6906.1 U19.7 U19.8
+1.8VS_SX9324: RS4.2 U16.A2
+1.8VU: CD1.1 CD2.1 CD3.1 CD9.1 CD10.1 CD12.1 CD41.1 CD42.1 CD44.1 CD45.1 CD47.1 CD48.1 CD61.1 CD119.1 CD120.1 CD121.1 CD125.1 CD126.1 CD127.1 CD128.1 CD129.1 CD130.1 CD134.1 CD135.1 CD136.1 CD140.1 CD141.1 CD142.1 CD143.1 CZ227.1 CZ228.1 CZ239.1 RZ28.2 UD41.A3 UD41.A4 UD41.A5 UD41.A6 UD41.A10 UD41.U3 UD41.U4 UD41.U5 UD41.U6 UD41.U10 UD42.A3 UD42.A4 UD42.A5 UD42.A6 UD42.A10 UD42.U3 UD42.U4 UD42.U5 UD42.U6 UD42.U10 UD43.A3 UD43.A4 UD43.A5 UD43.A6 UD43.A10 UD43.U3 UD43.U4 UD43.U5 UD43.U6 UD43.U10 UD44.A3 UD44.A4 UD44.A5 UD44.A6 UD44.A10 UD44.U3 UD44.U4 UD44.U5 UD44.U6 UD44.U10
+1.8VU_OUT: RZ28.1 UZ8.7 UZ8.8
+1.35VGPUP: PCW23.1 PCW27.1 PCW28.1 PCW29.1 PCW30.1 PCW31.1 PCW36.1 PCW37.1 PCW38.1 PJPW4.1 PLW12.2 PRW13.1 PRW21.1
+1.35VGS_PGOOD: PRW18.2 PUW01.9 UV11.2 UV25.1
+1.35VS_VRAM: CV38.1 CV44.1 CV45.1 CV217.1 CV218.1 CV221.1 CV399.1 CV400.1 CV401.1 CV402.1 CV403.1 CV404.1 CV405.1 CV406.1 CV601.2 CV602.2 CV603.2 CV604.2 CV605.2 CV606.2 CV607.2 CV608.2 CV609.1 CV610.1 CV611.1 CV612.1 CV613.1 CV614.1 CV615.1 CV616.1 CV617.1 CV618.1 CV701.2 CV702.2 CV703.2 CV704.2 CV705.2 CV706.2 CV707.2 CV708.2 CV709.1 CV710.1 CV711.1 CV712.1 CV713.1 CV714.1 CV715.1 CV716.1 CV717.1 CV718.1 CV759.1 CV760.1 CV761.1 CV762.1 CV763.1 CV764.1 CV765.1 CV766.1 CV772.1 CV773.1 CV932.1 CV934.1 PJPW4.2 RV41.2 RV125.1 RV2439.2 RV2440.2 RV2453.2 RV5007.1 UV1.B26 UV1.C25 UV1.E23 UV1.E26 UV1.F14 UV1.F21 UV1.G13 UV1.G14 UV1.G15 UV1.G16 UV1.G18 UV1.G19 UV1.G20 UV1.G21 UV1.H24 UV1.H26 UV1.J21 UV1.K21 UV1.L22 UV1.L24 UV1.L26 UV1.M21 UV1.N21 UV1.R21 UV1.T21 UV1.V21 UV1.W21 UV6.B1 UV6.B3 UV6.B12 UV6.B14 UV6.C5 UV6.C10 UV6.D1 UV6.D3 UV6.D11 UV6.D12 UV6.D14 UV6.E5 UV6.E10 UV6.F1 UV6.F3 UV6.F12 UV6.F14 UV6.G1 UV6.G2 UV6.G4 UV6.G11 UV6.G13 UV6.G14 UV6.H3 UV6.H12 UV6.K3 UV6.K12 UV6.L1 UV6.L2 UV6.L4 UV6.L11 UV6.L13 UV6.L14 UV6.M1 UV6.M3 UV6.M12 UV6.M14 UV6.N5 UV6.N10 UV6.P1 UV6.P3 UV6.P11 UV6.P12 UV6.P14 UV6.R5 UV6.R10 UV6.T1 UV6.T3 UV6.T12 UV6.T14 UV8.B1 UV8.B3 UV8.B12 UV8.B14 UV8.C5 UV8.C10 UV8.D1 UV8.D3 UV8.D11 UV8.D12 UV8.D14 UV8.E5 UV8.E10 UV8.F1 UV8.F3 UV8.F12 UV8.F14 UV8.G1 UV8.G2 UV8.G4 UV8.G11 UV8.G13 UV8.G14 UV8.H3 UV8.H12 UV8.K3 UV8.K12 UV8.L1 UV8.L2 UV8.L4 UV8.L11 UV8.L13 UV8.L14 UV8.M1 UV8.M3 UV8.M12 UV8.M14 UV8.N5 UV8.N10 UV8.P1 UV8.P3 UV8.P11 UV8.P12 UV8.P14 UV8.R5 UV8.R10 UV8.T1 UV8.T3 UV8.T12 UV8.T14
+3.3V_TBT: LT2.2 RT606.2
+3.3V_TBT_ANA: CT302.1 UT1.E16
+3.3V_TBT_ANA_PCIE: CT301.1 RT554.2 UT1.L16
+3.3V_TBT_ANA_USB2: CT300.1 UT1.H18
+3.3V_TBT_FLASH_R: CT1.1 RT1.2 RT2.2 RT3.2 RT4.2 RT9.1 RT578.1 UT2.8
+3.3V_TBT_LC: CT303.1 RT5.2 RT6.2 RT7.2 RT8.2 RT9.2 UT1.V6
+3.3V_TBT_S0: CT67.1 CT68.1 CT69.1 CT323.1 CT324.1 CT325.1 CT326.1 CT327.1 CT328.1 CT361.1 CT362.1 LT2.1 UT1.E6 UT1.G1 UT1.G2 UT1.H2 UT1.L6
+3.3V_TBT_SX: CT314.1 CT315.1 RT16.2 RT20.2 RT372.2 RT502.2 RT503.2 RT592.2 RT593.2 RT607.1 RT608.2 RT609.2 UT1.F18 UT1.R6
+3.3V_WLAN: CW11.1 CW12.1 CW13.1 CW14.1 CW15.1 CW16.1 CW17.1 CW18.1 RW28.2 WL1.4 WL1.5 WL1.72 WL1.73 WL1.A48 WL1.A49
+3V_DVDD: F6.1 JIO1.6
+3V_FFS: CS32.1 CS33.1 CS48.1 RS13.2 US2.2 US2.9 US2.10
+3V_FPR: C4.2 JFP1.8 Q27.2 R6.1 R256.2
+3V_HDA: CC60.1 CC88.1 LC4.2 RC51.1 UC1.BT20
+3V_OSC: CE510.1 RE552.1 RE553.1 XE1.4
+3V_SPI: CC4.1 JSPI1.8 JSPI1.9 RC561.1 RC562.1 U27.8 UC3.8
+3V_TEMP: C28.1 C6906.1 R53.2 U3.1
+3V_WWAN: CN1.1 CN2.1 CN3.1 CN4.1 CN5.1 CN6.1 CN7.1 CN8.1 CN9.1 CN10.1 CN41.1 CN60.1 CN61.1 CN62.1 CN64.1 CN65.1 CN66.1 CN67.1 CN68.1 CN69.1 CS49.1 CZ234.1 JNGFF1.2 JNGFF1.4 JNGFF1.70 JNGFF1.72 JNGFF1.74 QN4.2 QN4.5 QN8.2 QN8.5 RN7.1 RN67.1 RN74.2 RN95.2 RN197.1 RN198.1 RZ5.2
+3V_WWAN_R: RZ5.1 UZ9.7 UZ9.8
+3VALW: C23.1 C94.1 C1223.1 CIO1.1 CIO2.1 CIO3.1 CIO4.1 CIO5.1 CIO6.1 CIO7.1 CIO8.1 CIO9.1 CM47.2 CR100.1 CZ14.1 CZ19.1 CZ236.1 D9.2 DB3.2 JAPS1.3 JAPS1.7 JIO1.8 PJP302.2 PR5.1 PR41.2 PR101.1 PR1814.1 PRA01.2 PRB27.1 PRG01.2 PRI01.2 PRI03.2 PRI05.2 PRM26.2 PRM27.2 PRV20.1 PRV23.2 PRV26.1 PRV29.2 PRV40.2 PRW17.1 PRW24.2 PRZ02.1 PRZ03.1 PRZ04.1 PRZ19.1 PRZ53.1 Q5.4 R5.1 R89.1 R1014.2 RC561.2 RE5.1 RE18.1 RE19.1 RE21.1 RE23.1 RE28.1 RE58.1 RE66.1 RE67.1 RE68.1 RE69.1 RE70.1 RE71.1 RE72.1 RE73.1 RE74.1 RE75.1 RE76.1 RE77.1 RE78.1 RE79.1 RE80.1 RE81.1 RE82.1 RE83.1 RE84.1 RE85.1 RE86.1 RE87.1 RE88.1 RE89.1 RE177.1 RE526.1 RE545.1 RE551.2 RN84.2 RN89.1 RPD84.1 RT607.2 RZ22.1 U7.5 U10.5 U6903.5 UC5.5 UC9.5 UC18.5 UM4.13 UT14.5 UZ3.6 UZ3.7 UZ4.1 UZ4.2 UZ9.1 UZ9.2 UZ9.4
+3VALW_AP2285: D9.1 U711.6
+3VALW_DSW: CC63.1 RC58.1 RC92.1 RC93.1 RC96.2 RC98.2 RC103.2 RC132.2 UC1.BR24 UC1.BT23
+3VALW_DSW_PG: R1014.1 U711.7
+3VALW_EC: CE1.1 CE2.1 CE5.1 CE6.1 CE7.1 CE8.1 CE9.1 CE21.1 CE100.1 CE101.1 CE504.1 CE506.1 CE507.1 CE508.1 Q30.2 Q30.5 RE1.1 RE3.1 RE5.2 RE8.2 RE9.2 RE12.2 RE48.1 RE49.2 RE50.2 RE51.1 RE90.2 RE91.2 RE92.2 RE93.2 RE100.2 RE101.2 RE155.2 RE478.2 RE479.2 RE511.2 RE516.1 RE524.2 RE542.2 UE1.A8 UE1.A15 UE1.A52 UE1.B4 UE1.B5 UE1.B9 UE1.B11 UE1.B26 UE1.B39 UE1.B48 UE5.5
+3VALW_ESPI1: JESPI1.1 JESPI1.2 RE551.1
+3VALW_PCH: CC65.1 CC87.1 CC118.1 CN57.1 CZ23.1 CZ229.1 F7.1 JAPS1.1 LC4.1 RC31.1 RC33.2 RC34.2 RC35.2 RC36.2 RC37.2 RC38.2 RC44.2 RC46.2 RC57.1 RC62.2 RC65.2 RC69.1 RC70.1 RC110.2 RC112.1 RC113.2 RC115.1 RC117.1 RC118.1 RC132.1 RC188.2 RC189.2 RC190.2 RC191.2 RC196.2 RC197.2 RC198.2 RC199.2 RC211.2 RC230.2 RC395.1 RC533.1 RC537.1 RC562.2 RC565.2 RC566.2 RC568.1 RC569.2 RC570.1 RC571.1 RC572.1 RC575.2 RE473.1 RT391.2 RW28.1 RZ7.2 UC1.BP23 UC1.BV23 UC1.BW23 UC1.CB16 UC1.CB22 UC1.CB23 UC1.CC22 UC1.CC23 UC1.CD22 UC1.CD23 UC1.CP29 UN4.5
+3VALW_PCH_OUT: RZ7.1 UZ4.7 UZ4.8
+3VALWP: PC310.1 PC311.1 PC312.1 PC313.1 PC317.1 PC318.1 PC319.1 PJP302.1 PL301.2 PR304.1 PR306.2 PR307.1 PU301.11
+3VLP: CE33.1 DB4.2 PC308.1 PU301.13 RE30.1 RE97.1 RE99.1 RE161.2 RE552.2 U34.8 UE3.2
+3VS: C16.1 CE22.1 CV206.1 CZ18.1 F5.1 F8.1 F9.1 PRF04.1 PRV43.1 PRW18.1 Q9.2 Q10.2 Q10.5 Q11.2 Q11.5 QC1.2 QC1.5 QV18.4 R30.1 R31.1 R36.1 R37.1 R47.1 R49.1 R50.1 R53.1 R54.1 R55.1 R90.1 R256.1 R6902.1 RC5.1 RC6.1 RC8.2 RC9.2 RC19.1 RC68.1 RC78.1 RC88.1 RC100.1 RC106.1 RC114.1 RC127.2 RC203.1 RC206.1 RC207.2 RC208.2 RC262.1 RC433.1 RC516.2 RC517.1 RC518.2 RC529.2 RC535.2 RC550.2 RC563.2 RC564.1 RE16.2 RE17.2 RE163.1 RE510.2 RM2.2 RS13.1 RT606.1 RV111.1 RV113.1 RV4996.1 RV4997.1 U1.5 UC4.5 UC10.5 UE2.5 UV11.5 UV25.5 UZ3.8 UZ3.9
+3VS_CAM: C50.1 C51.1 C52.1 C6673.1 C6904.1 F5.2 JEDP1.22
+3VS_CR: CR5.1 CR6.1 CR12.2 JREAD1.4 RR161.1 RR162.1 RR163.1 RR164.1 RR165.1 RR166.1
+3VS_CR_R: RR166.2 U6903.1
+3VS_DTH: CM2.1 CM40.1 LM1.1 RM2.1 RM11.1 RM12.1 RM16.2 RM23.2 RM26.2 RM40.1 RM42.1 RM44.1 RM45.1 RM48.1 RM50.1 RM51.1 UM3.8
+3VS_SENSOR: F9.2 JCAM1.6 JEDP1.20
+3VS_SSD: C56.1 C6901.1 CS3.1 CS4.1 CS5.1 CS34.1 CS41.1 CS42.1 JSSD1.2 JSSD1.4 JSSD1.12 JSSD1.14 JSSD1.16 JSSD1.18 JSSD1.70 JSSD1.72 JSSD1.74 R6902.2 RS1.1
+3VS_UN5: CN58.1 RN84.1 RN85.1 UN5.5
+3VS_WWAN_RF: JANT2.1 RN67.2
+5V_KB_BL: C22.1 C106.1 F3.1 JKBBL1.1
+5VALW: C6671.2 CM1.1 CV322.1 CZ1.1 CZ10.1 CZ13.1 CZ21.1 CZ39.1 CZ221.1 PJP501.2 PR4.1 PRF01.1 Q31.3 Q32.3 RPD121.1 RV2007.1 RV2008.1 RV5002.1 RV5006.1 RV5008.1 U19.4 UM2.10 UV2.4 UZ1.4 UZ2.3 UZ3.1 UZ3.2 UZ3.4 UZ4.4 UZ7.3 UZ8.4
+5VALW_L_TBT: CPD7.1 CPD8.1 CPD53.1 RPD121.2 UPD1.1 UPD1.2 UPD1.25
+5VALWP: PC506.1 PC507.1 PC508.1 PC509.1 PC510.1 PC511.1 PC515.2 PC518.1 PC519.1 PC520.1 PJP501.1 PL501.2 PR508.1
+5VS: CZ15.1 CZ226.1 CZ238.1 F3.2 JIO1.5 Q12.3 RE213.1 UV17.1 UZ3.13 UZ3.14
+8.4V_BATT: PC11.1 PC23.1 PL4.1 PL5.1 PL7.1 PL8.1 PQB03.5 PQB12.3 PRB65.1
+8.4V_BATT+: PBATT1.9 PBATT1.10 PBATT1.11 PBATT1.12 PC12.1 PC17.1 PL4.2 PL5.2 PL7.2 PL8.2
+VCC1V8_TBT_L_LDO: CPD6.1 CPD51.1 UPD1.35
+VCC3V3_TBT_L_LDO: CPD1.1 CPD4.1 CPD50.1 JDB2.1 RPD11.1 RPD12.1 RPD13.1 RPD14.1 RPD90.1 RPD92.1 RPD129.2 RPD170.2 RT578.2 UPD1.9 UPD3.8 UPD5.8
+VCC_CORE: PCI100.1 PCI101.1 PCI102.1 PCI103.1 PCI104.1 PCI105.1 PCI106.1 PCI107.1 PCI108.1 PCI109.1 PCI110.1 PCI111.1 PCI112.1 PCI113.1 PCI114.1 PCI115.1 PCI116.1 PCI117.1 PCI118.1 PCI119.1 PCI120.1 PCI121.1 PCI122.1 PCI123.1 PCI124.1 PCI125.1 PCI126.1 PCI127.1 PCI128.1 PCI129.1 PCI130.1 PCI131.1 PCI132.1 PCI133.1 PCI134.1 PCI135.1 PCI136.1 PCI137.1 PCI138.1 PCI139.1 PCI140.1 PCI141.1 PCI142.1 PCI143.1 PCI144.1 PCI145.1 PCI146.1 PCI147.1 PCI148.1 PCI149.1 PCI150.1 PCI151.1 PCI152.1 PCI153.1 PCI154.1 PCI155.1 PCI156.1 PCI157.1 PCI158.1 PCI159.1 PCI160.1 PCI161.1 PCI162.1 PCI163.1 PCI164.1 PCI165.1 PCI166.1 PCI167.1 PCI168.1 PCI169.1 PCI170.1 PCI171.1 PCI172.1 PCI173.1 PCI174.1 PCI175.1 PCI176.1 PCI177.1 PCI178.1 PCI179.1 PCI180.1 PCI181.1 PCI182.1 PCI183.1 PCI184.1 PCI185.1 PCI186.1 PCI187.1 PCI188.1 PCI189.1 PCI190.1 PCI191.1 PCI192.1 PCI193.1 PCI194.1 PCI195.1 PCI196.1 PCI197.1 PCI198.1 PCI199.1 PCI200.1 PCI201.1 PCI202.1 PCI203.1 PCI204.1 PCI205.1 PCI206.1 PCI207.1 PLI01.3 PLI01.4 PLI02.3 PLI02.4 PLI03.3 PLI03.4 RC167.1 UC1.AA9 UC1.AB2 UC1.AB8 UC1.AB9 UC1.AB10 UC1.AC8 UC1.AD9 UC1.AE8 UC1.AE9 UC1.AE10 UC1.AF2 UC1.AF8 UC1.AF10 UC1.AG8 UC1.AG9 UC1.AH9 UC1.AJ8 UC1.AJ10 UC1.AK2 UC1.AK9 UC1.AL8 UC1.AL9 UC1.AL10 UC1.AM8 UC1.AN9 UC1.AN10 UC1.AN24 UC1.AN26 UC1.AN27 UC1.AP2 UC1.AP9 UC1.AP24 UC1.AP26 UC1.AR5 UC1.AR6 UC1.AR7 UC1.AR8 UC1.AR10 UC1.AR25 UC1.AR27 UC1.AT9 UC1.AT24 UC1.AT26 UC1.AU5 UC1.AU6 UC1.AU7 UC1.AU8 UC1.AU9 UC1.AU24 UC1.AU25 UC1.AU26 UC1.AU27 UC1.AV2 UC1.AV5 UC1.AV7 UC1.AV10 UC1.AV27 UC1.AW5 UC1.AW6 UC1.AW7 UC1.AW8 UC1.AW9 UC1.AW10 UC1.AW24 UC1.AW25 UC1.AW26 UC1.AW27 UC1.AY24 UC1.AY26 UC1.BA5 UC1.BA7 UC1.BA8 UC1.BA25 UC1.BA27 UC1.BB2 UC1.BB26 UC1.BC5 UC1.BC6 UC1.BC7 UC1.BC9 UC1.BC10 UC1.BC26 UC1.BC27 UC1.BD5 UC1.BD8 UC1.BD10 UC1.BD25 UC1.BD27 UC1.BE9 UC1.BE24 UC1.BE25 UC1.BE26 UC1.BE27 UC1.BF2 UC1.BF9 UC1.BF24 UC1.BF26 UC1.BG27 UC1.V2 UC1.Y8 UC1.Y10
+VCC_GT: PCG100.1 PCG101.1 PCG102.1 PCG103.1 PCG104.1 PCG105.1 PCG106.1 PCG107.1 PCG108.1 PCG109.1 PCG110.1 PCG111.1 PCG112.1 PCG113.1 PCG114.1 PCG115.1 PCG116.1 PCG117.1 PCG118.1 PCG119.1 PCG120.1 PCG121.1 PCG122.1 PCG123.1 PCG124.1 PCG125.1 PCG126.1 PCG127.1 PCG128.1 PCG129.1 PCG130.1 PCG131.1 PCG132.1 PCG133.1 PCG134.1 PCG135.1 PCG136.1 PCG137.1 PCG138.1 PCG139.1 PCG140.1 PCG141.1 PCG142.1 PCG143.1 PCG144.1 PCG145.1 PCG146.1 PCG147.1 PCG148.1 PCG149.1 PCG150.1 PCG151.1 PCG152.1 PCG153.1 PLG01.2 RC169.1 UC1.A5 UC1.A6 UC1.A8 UC1.A11 UC1.A12 UC1.A14 UC1.A15 UC1.A17 UC1.A18 UC1.A20 UC1.B3 UC1.B4 UC1.B6 UC1.B8 UC1.B11 UC1.B14 UC1.B17 UC1.B20 UC1.C2 UC1.C3 UC1.C6 UC1.C7 UC1.C8 UC1.C11 UC1.C12 UC1.C14 UC1.C15 UC1.C17 UC1.C18 UC1.C20 UC1.D4 UC1.D7 UC1.D11 UC1.D12 UC1.D14 UC1.D15 UC1.D17 UC1.D18 UC1.D20 UC1.E4 UC1.F5 UC1.F6 UC1.F7 UC1.F8 UC1.F11 UC1.F14 UC1.F17 UC1.F20 UC1.G11 UC1.G12 UC1.G14 UC1.G15 UC1.G17 UC1.G18 UC1.G20 UC1.H5 UC1.H6 UC1.H7 UC1.H8 UC1.H11 UC1.H12 UC1.H14 UC1.H15 UC1.H17 UC1.H18 UC1.H20 UC1.J7 UC1.J8 UC1.J11 UC1.J14 UC1.J17 UC1.J20 UC1.K2 UC1.K11 UC1.L7 UC1.L8 UC1.L10 UC1.M9 UC1.N7 UC1.N8 UC1.N9 UC1.N10 UC1.P2 UC1.P8 UC1.R9 UC1.T8 UC1.T9 UC1.T10 UC1.U8 UC1.U10 UC1.V9 UC1.W8 UC1.W9
+VCC_SA: PCA100.1 PCA102.1 PCA103.1 PCA104.1 PCA105.1 PCA106.1 PCA107.1 PCA108.1 PCA109.1 PCA110.1 PCA111.1 PCA112.1 PCA113.1 PCA114.1 PCA115.1 PCA116.1 PCA117.1 PCA118.1 PCA119.1 PLA01.2 RC164.1 UC1.BG8 UC1.BG10 UC1.BH9 UC1.BJ8 UC1.BJ9 UC1.BJ10 UC1.BK8 UC1.BK25 UC1.BK27 UC1.BL8 UC1.BL9 UC1.BL10 UC1.BL24 UC1.BL26 UC1.BM24 UC1.BN25
+VCCIO: CC20.1 CC21.1 CC22.1 CC23.1 CC24.1 CC25.1 CC26.1 CC27.1 CC28.1 CC29.1 CC30.1 CC31.1 CC32.1 CC33.1 CC113.1 CC114.1 CZ232.1 JP3.2 RC4.1 RC536.1 RZ1421.1 UC1.AK24 UC1.AK26 UC1.AL24 UC1.AL25 UC1.AL26 UC1.AL27 UC1.AM25 UC1.AM27 UC1.BH24 UC1.BH25 UC1.BH26 UC1.BH27 UC1.BJ24 UC1.BJ26 UC1.BP16 UC1.BP18
+VCCIO_OUT: CZ12.1 JP3.1 UZ2.6
+VCCLDOSRAM_1P24: RC133.1 UC1.BY23 UC1.BY24 UC1.CA23 UC1.CA24
+VCCPLL_OC: CC17.1 CZ40.1 CZ233.1 RZ11.2 RZ12.2 UC1.BL27 UC1.BM26
+VCCPLL_OC_R: RZ12.1 UZ7.6
+VCCST: CC15.1 CC16.1 CC18.1 CC72.1 CC115.1 CC116.1 CC117.1 CZ230.1 PCZ02.1 PRZ05.1 PRZ21.1 PRZ22.1 PRZ23.1 PRZ24.1 RC2.1 RC134.1 RC136.1 RC554.1 RZ29.2 UC1.BP2 UC1.BP11 UC1.BR11 UC1.BT11
+VCCST_OUT: CZ5.1 RZ29.1 UZ1.8 UZ1.9
+VCCSTG: CC19.1 CZ231.1 RC1.1 RC239.1 RC240.1 RC242.1 RC436.1 RZ30.2 RZ1421.2 UC1.BG1 UC1.BG2 UC1.BG3
+VCCSTG_OUT: CZ8.1 RZ30.1 UZ1.13 UZ1.14
+VIN_3V3_L_TBT: CPD5.1 RPD84.2 UPD1.5
GND: C2.2 C3.2 C4.1 C7.2 C8.2 C9.2 C16.2 C22.2 C26.2 C28.2 C36.2 C41.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C60.2 C61.2 C62.2 C78.2 C94.2 C104.1 C105.2 C106.2 C107.1 C1223.2 C6671.1 C6673.2 C6676.2 C6677.2 C6901.2 C6904.2 C6905.2 C6906.2 C6907.2 C6908.2 CB16.2 CC1.1 CC3.2 CC4.2 CC6.2 CC7.2 CC8.2 CC9.2 CC10.2 CC11.2 CC12.2 CC15.2 CC16.2 CC17.2 CC18.2 CC19.2 CC20.2 CC21.2 CC22.2 CC23.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC51.2 CC52.2 CC53.2 CC54.2 CC55.2 CC56.2 CC57.2 CC58.2 CC59.2 CC60.2 CC61.2 CC62.2 CC63.2 CC64.2 CC65.2 CC72.2 CC73.2 CC74.1 CC75.1 CC76.1 CC77.2 CC78.2 CC79.2 CC80.2 CC81.2 CC82.2 CC83.2 CC84.2 CC85.2 CC86.2 CC87.2 CC88.2 CC101.2 CC102.2 CC103.2 CC104.2 CC105.2 CC106.2 CC107.2 CC108.2 CC109.2 CC110.2 CC111.2 CC112.2 CC113.2 CC114.2 CC115.2 CC116.2 CC117.2 CC118.2 CC119.2 CC120.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CD69.2 CD70.2 CD71.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CD91.2 CD100.2 CD101.2 CD102.2 CD103.2 CD104.2 CD105.2 CD106.2 CD107.2 CD108.2 CD109.2 CD110.2 CD111.2 CD114.2 CD115.2 CD116.2 CD117.2 CD118.2 CD119.2 CD120.2 CD121.2 CD122.2 CD123.2 CD124.2 CD125.2 CD126.2 CD127.2 CD128.2 CD129.2 CD130.2 CD131.2 CD132.2 CD133.2 CD134.2 CD135.2 CD136.2 CD137.2 CD138.2 CD139.2 CD140.2 CD141.2 CD142.2 CD143.2 CD144.2 CD145.2 CD146.2 CD147.2 CE1.2 CE2.2 CE5.2 CE6.2 CE7.2 CE8.2 CE9.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE18.2 CE21.2 CE22.2 CE23.2 CE24.2 CE26.2 CE31.2 CE32.1 CE33.2 CE34.2 CE36.2 CE100.2 CE101.2 CE504.2 CE505.2 CE506.2 CE507.2 CE508.2 CE509.1 CE510.2 CH1.2 CIO1.2 CIO2.2 CIO3.2 CIO4.2 CIO5.2 CIO6.2 CIO7.2 CIO8.2 CIO9.2 CLEC1.2 CLP1.1(TP-1) CLP2.1(TP-1) CLP3.1(TP-1) CLP4.1(TP-1) CLP5.1(TP-1) CLRP2.2 CM1.2 CM2.2 CM3.2 CM4.2 CM5.2 CM6.2 CM10.2 CM11.2 CM12.2 CM13.2 CM14.2 CM25.2 CM26.2 CM27.2 CM28.2 CM29.2 CM30.2 CM31.2 CM32.2 CM33.2 CM34.2 CM35.2 CM36.2 CM37.2 CM38.2 CM40.2 CM41.2 CM42.2 CM43.2 CM44.2 CM45.2 CM46.2 CM47.1 CM48.2 CM49.2 CM51.2 CM52.2 CN1.2 CN2.2 CN3.2 CN4.2 CN5.2 CN6.2 CN7.2 CN8.2 CN9.2 CN10.2 CN18.2 CN41.2 CN57.2 CN58.2 CN59.2 CN60.2 CN61.2 CN62.2 CN64.2 CN65.2 CN66.2 CN67.2 CN68.2 CN69.2 CPD1.2 CPD2.2 CPD3.2 CPD4.2 CPD5.2 CPD6.2 CPD7.2 CPD8.2 CPD40.2 CPD42.2 CPD47.2 CPD49.2 CPD50.2 CPD51.2 CPD52.2 CPD53.2 CPD55.2 CPD56.2 CR5.2 CR6.2 CR12.1 CR100.2 CS2.2 CS3.2 CS4.2 CS5.2 CS6.2 CS32.2 CS33.2 CS34.2 CS35.2 CS36.2 CS37.2 CS38.2 CS39.2 CS41.2 CS42.2 CS43.2 CS44.2 CS47.2 CS48.2 CS49.2 CT1.2 CT20.2 CT21.2 CT67.2 CT68.2 CT69.2 CT99.2 CT100.2 CT101.2 CT102.2 CT189.2 CT190.2 CT300.2 CT301.2 CT302.2 CT303.2 CT305.2 CT306.2 CT307.2 CT308.2 CT309.2 CT310.2 CT311.2 CT314.2 CT315.2 CT316.1 CT317.1 CT318.1 CT319.1 CT320.1 CT321.1 CT322.1 CT323.2 CT324.2 CT325.2 CT326.2 CT327.2 CT328.2 CT329.2 CT330.2 CT331.2 CT332.2 CT333.2 CT334.2 CT335.2 CT336.2 CT337.2 CT338.2 CT339.2 CT340.2 CT341.2 CT343.2 CT344.2 CT346.2 CT350.2 CT351.2 CT352.2 CT361.2 CT362.2 CT363.2 CT364.2 CT365.2 CT366.2 CT367.2 CT368.2 CT369.2 CT370.2 CT371.2 CV2.2 CV3.2 CV4.2 CV5.2 CV9.2 CV10.2 CV31.2 CV34.2 CV38.2 CV44.2 CV45.2 CV51.2 CV52.1 CV53.2 CV55.2 CV60.2 CV75.2 CV76.2 CV77.2 CV158.2 CV159.2 CV196.1 CV197.1 CV198.2 CV199.2 CV200.2 CV201.2 CV202.2 CV203.2 CV204.2 CV205.2 CV206.2 CV207.2 CV209.1 CV210.1 CV211.2 CV212.2 CV213.2 CV214.2 CV216.2 CV217.2 CV218.2 CV219.2 CV220.2 CV221.2 CV222.2 CV322.2 CV323.2 CV324.2 CV325.2 CV326.2 CV327.2 CV390.2 CV391.2 CV392.2 CV393.2 CV394.2 CV395.2 CV396.2 CV397.2 CV398.2 CV399.2 CV400.2 CV401.2 CV402.2 CV403.2 CV404.2 CV405.2 CV406.2 CV597.2 CV598.2 CV599.1 CV600.1 CV601.1 CV602.1 CV603.1 CV604.1 CV605.1 CV606.1 CV607.1 CV608.1 CV609.2 CV610.2 CV611.2 CV612.2 CV613.2 CV614.2 CV615.2 CV616.2 CV617.2 CV618.2 CV633.2 CV651.2 CV701.1 CV702.1 CV703.1 CV704.1 CV705.1 CV706.1 CV707.1 CV708.1 CV709.2 CV710.2 CV711.2 CV712.2 CV713.2 CV714.2 CV715.2 CV716.2 CV717.2 CV718.2 CV741.2 CV754.2 CV755.1 CV756.2 CV757.2 CV759.2 CV760.2 CV761.2 CV762.2 CV763.2 CV764.2 CV765.2 CV766.2 CV767.2 CV768.2 CV769.2 CV770.2 CV771.2 CV772.2 CV773.2 CV774.2 CV775.2 CV776.2 CV777.2 CV778.2 CV779.2 CV780.2 CV781.2 CV782.2 CV783.2 CV784.2 CV785.1 CV786.2 CV787.2 CV788.2 CV789.2 CV930.1 CV931.2 CV932.2 CV933.2 CV934.2 CV935.2 CW11.2 CW12.2 CW13.2 CW14.2 CW15.2 CW16.2 CW17.2 CW18.2 CZ1.2 CZ2.2 CZ3.2 CZ4.2 CZ5.2 CZ6.2 CZ7.2 CZ8.2 CZ9.2 CZ10.2 CZ11.2 CZ12.2 CZ13.2 CZ14.2 CZ15.2 CZ16.2 CZ17.2 CZ18.2 CZ19.2 CZ20.2 CZ21.2 CZ22.2 CZ23.2 CZ38.2 CZ39.2 CZ40.2 CZ218.2 CZ219.2 CZ220.2 CZ221.2 CZ223.2 CZ224.2 CZ225.2 CZ226.2 CZ227.2 CZ228.2 CZ229.2 CZ230.2 CZ231.2 CZ232.2 CZ233.2 CZ234.2 CZ235.2 CZ236.2 CZ237.2 CZ238.2 CZ239.2 DS1.3 DT4.1 DT5.2 DT6.2 DT9.2 DT10.2 DT13.2 DT14.2 DT17.2 DT18.2 DT39.3 DT40.3 EC2.2 ED4.1 ED10.1 ED11.3 ED12.3 EU6.1 H2.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H16.1(TP-1) H18.1(TP-1) H19.1(TP-1) H42.1(TP-1) JANT1.2 JANT1.3 JANT1.4 JANT2.4 JANT2.6 JANT2.7 JANT2.8 JANT2.9 JANT2.10 JANT2.11 JANT2.12 JANT2.13 JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JCAM1.8 JCAM1.11 JCAM1.13 JCAM1.14 JCAM1.15 JCAM1.16 JCAM1.17 JCAM1.18 JDB2.6 JDB2.11 JDB2.12 JDEG1.10 JDEG1.11 JDEG1.12 JEDP1.8 JEDP1.9 JEDP1.12 JEDP1.15 JEDP1.29 JEDP1.35 JEDP1.38 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JEDP1.46 JEDP1.47 JEDP1.48 JEDP1.49 JEDP1.50 JEDP1.51 JEDP1.52 JEDP1.53 JEDP1.54 JEDP1.55 JEDP1.56 JEDP1.57 JEDP1.58 JEDP1.59 JEDP1.60 JEDP1.61 JEDP1.62 JEDP1.63 JEDP1.64 JEDP1.65 JEDP1.66 JEDP1.67 JEDP1.68 JEDP1.69 JEDP1.70 JEDP1.71 JEDP1.72 JEDP1.73 JEDP1.74 JESPI1.9 JESPI1.11 JESPI1.12 JFP1.4 JFP1.9 JFP1.10 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIO1.18 JIO1.21 JIO1.24 JIO1.27 JIO1.29 JIO1.32 JIO1.35 JIO1.38 JIO1.41 JIO1.42 JIO1.43 JIO1.44 JIO1.45 JIO1.46 JIO1.47 JIO1.48 JIO1.49 JIO1.50 JIO1.51 JIO1.52 JIO1.53 JIO1.54 JIO1.55 JIO1.56 JIO1.57 JIO1.58 JIO1.59 JIO1.60 JIO1.61 JIO1.62 JIO1.63 JIO1.64 JIO1.65 JIO1.66 JIO1.67 JIO1.68 JIO2.3 JIO2.4 JIO2.5 JIO2.6 JKB1.1 JKB1.31 JKB1.32 JKBBL1.5 JKBBL1.6 JNGFF1.3 JNGFF1.5 JNGFF1.11 JNGFF1.27 JNGFF1.33 JNGFF1.39 JNGFF1.45 JNGFF1.51 JNGFF1.57 JNGFF1.71 JNGFF1.73 JNGFF1.76 JNGFF1.77 JREAD1.6 JREAD1.10 JREAD1.11 JREAD1.12 JREAD1.13 JRTC1.2 JRTC1.3 JRTC1.4 JSIM1.4 JSIM1.8 JSIM1.9 JSIM1.10 JSIM1.11 JSIM1.12 JSIM1.13 JSIM1.14 JSIM1.15 JSPI1.10 JSPI1.11 JSPI1.12 JSSD1.1 JSSD1.3 JSSD1.9 JSSD1.15 JSSD1.21 JSSD1.27 JSSD1.33 JSSD1.39 JSSD1.45 JSSD1.51 JSSD1.57 JSSD1.71 JSSD1.73 JSSD1.75 JSSD1.76 JSSD1.77 JTP1.5 JTP1.9 JTP1.10 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 JXDP1.61 JXDP1.62 JXDP1.63 LED1.3 PBATT1.1 PBATT1.2 PBATT1.3 PBATT1.4 PBATT1.5 PBATT1.13 PBATT1.14 PC11.2 PC12.2 PC17.2 PC23.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC317.2 PC318.2 PC319.2 PC321.2 PC501.2 PC502.2 PC503.2 PC504.2 PC505.2 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC511.2 PC513.2 PC516.2 PC517.2 PC518.2 PC519.2 PC520.2 PC532.2 PC533.2 PC534.2 PC535.2 PC536.2 PC537.2 PC538.2 PC1801.2 PC1802.2 PC1803.2 PC1804.2 PC1805.2 PC1806.2 PC1807.2 PC1808.2 PC1809.2 PC1812.2 PC1813.2 PC1814.2 PC1815.2 PC1817.2 PC1818.2 PC1819.2 PCA02.2 PCA03.2 PCA04.2 PCA05.2 PCA06.2 PCA08.2 PCA10.2 PCA11.2 PCA12.2 PCA100.2 PCA102.2 PCA103.2 PCA104.2 PCA105.2 PCA106.2 PCA107.2 PCA108.2 PCA109.2 PCA110.2 PCA111.2 PCA112.2 PCA113.2 PCA114.2 PCA115.2 PCA116.2 PCA117.2 PCA118.2 PCA119.2 PCB01.2 PCB02.2 PCB03.2 PCB04.2 PCB05.2 PCB06.2 PCB07.2 PCB10.2 PCB11.2 PCB12.2 PCB13.2 PCB14.2 PCB15.2 PCB16.2 PCB17.2 PCB19.2 PCB20.2 PCB21.2 PCB22.2 PCB23.2 PCB24.2 PCB26.2 PCB27.2 PCB28.2 PCB29.2 PCB31.2 PCB32.2 PCB33.2 PCB34.2 PCB35.2 PCB36.2 PCB37.2 PCB38.2 PCB39.2 PCB40.2 PCB42.2 PCB43.2 PCB45.2 PCB46.2 PCB47.2 PCB48.2 PCB49.2 PCB50.2 PCB51.2 PCF01.2 PCF02.2 PCF03.2 PCF05.2 PCF06.2 PCF07.2 PCF08.2 PCF09.2 PCG02.2 PCG03.2 PCG04.2 PCG05.2 PCG06.2 PCG07.2 PCG09.2 PCG10.2 PCG11.2 PCG20.2 PCG100.2 PCG101.2 PCG102.2 PCG103.2 PCG104.2 PCG105.2 PCG106.2 PCG107.2 PCG108.2 PCG109.2 PCG110.2 PCG111.2 PCG112.2 PCG113.2 PCG114.2 PCG115.2 PCG116.2 PCG117.2 PCG118.2 PCG119.2 PCG120.2 PCG121.2 PCG122.2 PCG123.2 PCG124.2 PCG125.2 PCG126.2 PCG127.2 PCG128.2 PCG129.2 PCG130.2 PCG131.2 PCG132.2 PCG133.2 PCG134.2 PCG135.2 PCG136.2 PCG137.2 PCG138.2 PCG139.2 PCG140.2 PCG141.2 PCG142.2 PCG143.2 PCG144.2 PCG145.2 PCG146.2 PCG147.2 PCG148.2 PCG149.2 PCG150.2 PCG151.2 PCG152.2 PCG153.2 PCH01.2 PCH02.2 PCH03.2 PCH04.2 PCH05.2 PCH06.2 PCH07.2 PCH08.2 PCH09.2 PCH11.2 PCH13.2 PCH14.2 PCH15.2 PCH16.2 PCH17.2 PCH18.2 PCH19.2 PCH20.2 PCH21.2 PCH22.2 PCI01.2 PCI02.2 PCI04.2 PCI05.2 PCI06.2 PCI07.2 PCI08.2 PCI10.2 PCI12.2 PCI13.2 PCI14.2 PCI16.2 PCI17.2 PCI18.2 PCI19.2 PCI20.2 PCI22.2 PCI24.2 PCI25.2 PCI28.2 PCI29.2 PCI30.2 PCI31.2 PCI32.2 PCI34.2 PCI36.2 PCI37.2 PCI38.2 PCI39.2 PCI41.2 PCI42.2 PCI100.2 PCI101.2 PCI102.2 PCI103.2 PCI104.2 PCI105.2 PCI106.2 PCI107.2 PCI108.2 PCI109.2 PCI110.2 PCI111.2 PCI112.2 PCI113.2 PCI114.2 PCI115.2 PCI116.2 PCI117.2 PCI118.2 PCI119.2 PCI120.2 PCI121.2 PCI122.2 PCI123.2 PCI124.2 PCI125.2 PCI126.2 PCI127.2 PCI128.2 PCI129.2 PCI130.2 PCI131.2 PCI132.2 PCI133.2 PCI134.2 PCI135.2 PCI136.2 PCI137.2 PCI138.2 PCI139.2 PCI140.2 PCI141.2 PCI142.2 PCI143.2 PCI144.2 PCI145.2 PCI146.2 PCI147.2 PCI148.2 PCI149.2 PCI150.2 PCI151.2 PCI152.2 PCI153.2 PCI154.2 PCI155.2 PCI156.2 PCI157.2 PCI158.2 PCI159.2 PCI160.2 PCI161.2 PCI162.2 PCI163.2 PCI164.2 PCI165.2 PCI166.2 PCI167.2 PCI168.2 PCI169.2 PCI170.2 PCI171.2 PCI172.2 PCI173.2 PCI174.2 PCI175.2 PCI176.2 PCI177.2 PCI178.2 PCI179.2 PCI180.2 PCI181.2 PCI182.2 PCI183.2 PCI184.2 PCI185.2 PCI186.2 PCI187.2 PCI188.2 PCI189.2 PCI190.2 PCI191.2 PCI192.2 PCI193.2 PCI194.2 PCI195.2 PCI196.2 PCI197.2 PCI198.2 PCI199.2 PCI200.2 PCI201.2 PCI202.2 PCI203.2 PCI204.2 PCI205.2 PCI206.2 PCI207.2 PCM06.2 PCM07.2 PCM17.2 PCM18.2 PCM19.2 PCM20.2 PCM21.2 PCM22.2 PCM23.2 PCM24.2 PCM25.2 PCM26.2 PCM28.2 PCM29.2 PCM30.2 PCM31.2 PCV01.2 PCV02.2 PCV03.2 PCV04.2 PCV8.2 PCV9.2 PCV10.2 PCV11.2 PCV12.2 PCV14.2 PCV15.2 PCV16.2 PCV17.2 PCV18.2 PCV19.2 PCV20.2 PCV21.2 PCV22.2 PCV23.2 PCV24.2 PCV25.2 PCV26.2 PCV27.2 PCV28.2 PCV29.2 PCV30.2 PCV31.2 PCV32.2 PCV33.2 PCV34.2 PCV35.2 PCV37.2 PCV38.2 PCV41.2 PCV42.2 PCV43.2 PCV44.2 PCV45.2 PCV46.2 PCV47.2 PCV48.1 PCV50.2 PCV51.2 PCV52.2 PCV53.2 PCV54.2 PCV55.2 PCV56.2 PCV57.2 PCV58.2 PCV59.2 PCV60.2 PCV61.2 PCV62.2 PCV63.2 PCV64.2 PCV65.2 PCV66.2 PCV67.2 PCV68.2 PCV69.2 PCV70.2 PCV71.2 PCV72.2 PCW12.2 PCW16.1 PCW17.2 PCW19.1 PCW20.2 PCW21.1 PCW22.2 PCW23.2 PCW26.1 PCW27.2 PCW28.2 PCW29.2 PCW30.2 PCW31.2 PCW32.2 PCW33.2 PCW34.2 PCW35.2 PCW36.2 PCW37.2 PCW38.2 PCZ01.1 PCZ02.2 PCZ03.1 PCZ04.1 PCZ05.1 PCZ06.1 PCZ07.2 PCZ08.2 PCZ09.2 PCZ10.2 PCZ11.2 PCZ12.2 PCZ13.2 PD5.1 PD6.1 PDB05.2 PJPDC1.1 PJPDC1.2 PQ2.3 PQ100.1 PQ100.4 PQ1402.3 PQB01.3 PQB01.4 PQB01.5 PQB02.3 PQB02.4 PQB02.5 PQB04.3 PQB13.3 PR2.2 PR104.2 PR105.2 PR303.2 PR308.2 PR502.1 PR503.1 PR505.2 PR509.2 PR525.2 PR1807.2 PR1810.2 PR1815.2 PRB07.2 PRB10.2 PRB20.2 PRB23.2 PRB24.2 PRB26.2 PRB33.2 PRF03.2 PRF06.2 PRH02.2 PRH06.2 PRM15.2 PRM18.2 PRM21.2 PRM23.2 PRV03.1 PRV32.2 PRV38.2 PRV41.2 PRV42.2 PRV45.2 PRW16.2 PRW22.2 PRW23.2 PRZ14.2 PRZ16.1 PRZ18.2 PRZ20.1 PRZ30.1 PRZ31.1 PRZ32.1 PRZ34.2 PRZ56.2 PU301.6 PU301.14 PU301.17 PU501.2 PU501.4 PU501.5 PU501.6 PU501.7 PU1801.2 PU1801.3 PU1801.4 PU1801.9 PUA01.5 PUA01.6 PUA01.7 PUA01.13 PUB01.33 PUF01.6 PUF01.11 PUG01.5 PUG01.6 PUG01.7 PUG01.13 PUH01.3 PUH01.4 PUH01.5 PUH01.8 PUH01.9 PUH01.10 PUH01.12 PUI01.5 PUI01.6 PUI01.7 PUI01.13 PUI02.5 PUI02.6 PUI02.7 PUI02.13 PUI03.5 PUI03.6 PUI03.7 PUI03.13 PUM01.2 PUM01.4 PUV01.11 PUV01.21 PUV02.5 PUV02.6 PUV02.7 PUV02.13 PUV03.5 PUV03.6 PUV03.7 PUV03.13 PUW01.7 PUW01.8 PUW01.18 PUW01.21 PUZ01.49 Q5.1 Q7.3 Q16.1 Q16.4 Q18.3 Q19.3 Q26.3 Q29.1 Q29.4 QE11.3 QN3.3 QV8.1 QV8.4 QV19.3 QV21.3 QV50.3 QV144.1 QV144.4 QV145.1 QV145.4 QV146.1 QV146.4 QV147.1 QV147.4 QV150.1 QV151.1 QV151.4 QV152.1 QV152.4 R17.2 R40.2 R65.2 R75.2 R76.2 R77.2 R242.2 RC10.1 RC11.1 RC12.2 RC13.2 RC15.2 RC16.2 RC17.2 RC18.2 RC20.2 RC54.1 RC55.2 RC56.2 RC60.1 RC61.1 RC64.2 RC71.2 RC72.2 RC73.1 RC74.1 RC75.1 RC83.2 RC86.2 RC94.2 RC104.2 RC105.2 RC107.2 RC108.1 RC119.2 RC120.2 RC123.2 RC124.2 RC125.2 RC158.2 RC165.2 RC168.2 RC170.2 RC187.2 RC201.2 RC205.1 RC213.2 RC216.2 RC218.2 RC220.2 RC222.2 RC224.2 RC227.2 RC228.2 RC244.1 RC258.1 RC381.2 RC405.1 RC406.1 RC407.1 RC408.1 RC409.1 RC410.1 RC411.1 RC412.1 RC413.1 RC414.1 RC415.1 RC416.1 RC417.1 RC418.1 RC419.1 RC420.2 RC504.2 RC513.1 RC514.1 RC546.1 RC547.1 RC548.1 RC553.1 RC567.1 RC573.2 RC574.1 RD1.2 RD2.2 RD3.2 RD4.2 RD5.2 RD6.2 RD7.2 RD8.2 RD12.2 RD13.2 RD23.2 RD24.2 RD26.2 RD27.2 RE2.1 RE4.1 RE22.2 RE26.2 RE32.2 RE45.1 RE57.2 RE98.1 RE527.2 RE529.1 RE541.2 RE544.1 RM7.2 RM13.2 RM14.2 RM15.2 RM17.1 RM27.2 RM28.2 RM34.2 RM38.2 RM41.2 RM43.2 RM46.2 RM47.2 RM49.2 RN88.2 RN91.2 RN97.2 RN193.1 RN196.2 RN199.2 RPD88.2 RPD91.2 RPD100.2 RPD128.2 RPD169.2 RPD181.1 RPD190.2 RPD191.2 RR132.2 RR167.2 RS3.2 RT23.2 RT26.2 RT27.2 RT33.2 RT34.2 RT36.2 RT41.1 RT184.2 RT288.2 RT293.2 RT505.2 RT506.2 RT507.2 RT508.2 RT509.2 RT553.2 RT554.1 RT604.2 RT605.2 RV20.2 RV21.2 RV42.1 RV43.1 RV44.2 RV71.2 RV88.2 RV94.2 RV102.2 RV116.2 RV118.2 RV120.2 RV127.2 RV376.2 RV378.2 RV381.2 RV383.2 RV385.2 RV387.2 RV388.2 RV390.2 RV399.2 RV624.2 RV626.2 RV629.2 RV2437.2 RV2438.2 RV2448.2 RV2451.2 RV4989.2 RZ25.2 RZ36.2 SW1.2 U1.2 U3.5 U7.3 U10.3 U16.A4 U19.5 U19.9 U27.4 U34.1 U34.4 U34.6 U711.5 U6903.2 UC1.A3 UC1.A4 UC1.A32 UC1.A36 UC1.AB3 UC1.AB4 UC1.AB7 UC1.AB27 UC1.AB30 UC1.AB33 UC1.AB36 UC1.AC5 UC1.AC10 UC1.AC27 UC1.AC30 UC1.AD33 UC1.AD35 UC1.AE7 UC1.AE24 UC1.AE25 UC1.AE26 UC1.AE27 UC1.AE30 UC1.AF3 UC1.AF4 UC1.AF7 UC1.AF25 UC1.AF27 UC1.AF30 UC1.AF33 UC1.AF36 UC1.AG5 UC1.AG10 UC1.AG24 UC1.AG26 UC1.AH24 UC1.AH25 UC1.AH27 UC1.AH28 UC1.AH29 UC1.AH30 UC1.AH31 UC1.AH33 UC1.AH35 UC1.AJ7 UC1.AJ25 UC1.AJ28 UC1.AK3 UC1.AK4 UC1.AK33 UC1.AK36 UC1.AL7 UC1.AL28 UC1.AL29 UC1.AL32 UC1.AM5 UC1.AM10 UC1.AM28 UC1.AM33 UC1.AM35 UC1.AN7 UC1.AN8 UC1.AN25 UC1.AN28 UC1.AN29 UC1.AN30 UC1.AN31 UC1.AP3 UC1.AP4 UC1.AP33 UC1.AP36 UC1.AR4 UC1.AR28 UC1.AT4 UC1.AT33 UC1.AT35 UC1.AT36 UC1.AU4 UC1.AU10 UC1.AU28 UC1.AU29 UC1.AU32 UC1.AV3 UC1.AV4 UC1.AV6 UC1.AV8 UC1.AV25 UC1.AV28 UC1.AV33 UC1.AV36 UC1.AW1 UC1.AW3 UC1.AW4 UC1.AW28 UC1.AW29 UC1.AW30 UC1.AW31 UC1.AY4 UC1.AY33 UC1.AY35 UC1.B2 UC1.B5 UC1.B7 UC1.B9 UC1.B12 UC1.B15 UC1.B18 UC1.B21 UC1.B23 UC1.B25 UC1.B27 UC1.B29 UC1.B31 UC1.B34 UC1.B36 UC1.B37 UC1.BA3 UC1.BA4 UC1.BA6 UC1.BA10 UC1.BA28 UC1.BB3 UC1.BB4 UC1.BB33 UC1.BB36 UC1.BC4 UC1.BC8 UC1.BC25 UC1.BC29 UC1.BC32 UC1.BD4 UC1.BD6 UC1.BD7 UC1.BD28 UC1.BD33 UC1.BD35 UC1.BD36 UC1.BE3 UC1.BE4 UC1.BE8 UC1.BE10 UC1.BE28 UC1.BE29 UC1.BE30 UC1.BE31 UC1.BF3 UC1.BF4 UC1.BF33 UC1.BF36 UC1.BG4 UC1.BG25 UC1.BG28 UC1.BH28 UC1.BH29 UC1.BH32 UC1.BH33 UC1.BH35 UC1.BJ7 UC1.BK2 UC1.BK3 UC1.BK4 UC1.BK7 UC1.BK10 UC1.BK28 UC1.BK33 UC1.BL7 UC1.BL25 UC1.BL28 UC1.BL29 UC1.BL30 UC1.BL31 UC1.BL32 UC1.BM9 UC1.BM33 UC1.BM35 UC1.BM36 UC1.BN7 UC1.BN30 UC1.BP3 UC1.BP4 UC1.BP7 UC1.BP12 UC1.BP15 UC1.BP19 UC1.BP25 UC1.BP32 UC1.BP33 UC1.BP36 UC1.BR16 UC1.BR19 UC1.BR22 UC1.BR25 UC1.BT5 UC1.BT14 UC1.BT15 UC1.BT16 UC1.BT25 UC1.BT28 UC1.BT33 UC1.BT35 UC1.BT36 UC1.BU7 UC1.BU11 UC1.BU16 UC1.BU20 UC1.BU23 UC1.BU24 UC1.BU25 UC1.BV3 UC1.BV4 UC1.BV11 UC1.BV31 UC1.BV33 UC1.BW7 UC1.BW11 UC1.BW15 UC1.BW24 UC1.BY5 UC1.BY11 UC1.BY15 UC1.BY18 UC1.BY19 UC1.BY22 UC1.BY25 UC1.BY28 UC1.BY33 UC1.BY35 UC1.BY36 UC1.C1 UC1.C4 UC1.C9 UC1.C21 UC1.C25 UC1.C29 UC1.C33 UC1.C36 UC1.C37 UC1.CA11 UC1.CA15 UC1.CA22 UC1.CA25 UC1.CB2 UC1.CB3 UC1.CB4 UC1.CB7 UC1.CB11 UC1.CB18 UC1.CB19 UC1.CB20 UC1.CB24 UC1.CB25 UC1.CB33 UC1.CC7 UC1.CC11 UC1.CC14 UC1.CC16 UC1.CC20 UC1.CC24 UC1.CC25 UC1.CC28 UC1.CC31 UC1.CD11 UC1.CD12 UC1.CD14 UC1.CD20 UC1.CD24 UC1.CD25 UC1.CE7 UC1.CE33 UC1.CE35 UC1.CE36 UC1.CF2 UC1.CF3 UC1.CF4 UC1.CF11 UC1.CF14 UC1.CF19 UC1.CF23 UC1.CF28 UC1.CG7 UC1.CG33 UC1.CH31 UC1.CJ2 UC1.CJ3 UC1.CJ4 UC1.CJ11 UC1.CJ14 UC1.CJ19 UC1.CJ23 UC1.CJ28 UC1.CJ33 UC1.CJ35 UC1.CJ36 UC1.CK1 UC1.CK4 UC1.CK7 UC1.CK37 UC1.CL2 UC1.CM1 UC1.CM4 UC1.CM5 UC1.CM9 UC1.CM13 UC1.CM17 UC1.CM21 UC1.CM25 UC1.CM29 UC1.CM31 UC1.CM33 UC1.CM37 UC1.CN1 UC1.CN2 UC1.CN5 UC1.CN9 UC1.CN13 UC1.CN17 UC1.CN21 UC1.CN25 UC1.CN29 UC1.CN37 UC1.CP1 UC1.CP2 UC1.CP9 UC1.CP11 UC1.CP13 UC1.CP15 UC1.CP19 UC1.CP21 UC1.CP27 UC1.CP35 UC1.CP37 UC1.CR2 UC1.CR6 UC1.CR34 UC1.CR36 UC1.D1 UC1.D5 UC1.D6 UC1.D8 UC1.D9 UC1.D21 UC1.D25 UC1.E9 UC1.E23 UC1.E27 UC1.E29 UC1.E31 UC1.E33 UC1.E35 UC1.F2 UC1.F3 UC1.F4 UC1.F12 UC1.F15 UC1.F18 UC1.F21 UC1.F24 UC1.F33 UC1.G9 UC1.G21 UC1.G27 UC1.G33 UC1.G35 UC1.G36 UC1.H9 UC1.H21 UC1.H27 UC1.J5 UC1.J6 UC1.J12 UC1.J15 UC1.J18 UC1.J21 UC1.J24 UC1.J33 UC1.J36 UC1.K3 UC1.K4 UC1.K9 UC1.K21 UC1.K22 UC1.K24 UC1.K25 UC1.K27 UC1.K28 UC1.K29 UC1.K30 UC1.K31 UC1.K32 UC1.L6 UC1.L27 UC1.L33 UC1.L35 UC1.L36 UC1.N6 UC1.N25 UC1.N27 UC1.P3 UC1.P4 UC1.P7 UC1.P10 UC1.P33 UC1.P36 UC1.R27 UC1.R28 UC1.R29 UC1.R30 UC1.R31 UC1.T7 UC1.T27 UC1.T30 UC1.T33 UC1.T35 UC1.T36 UC1.U7 UC1.U24 UC1.U26 UC1.V3 UC1.V4 UC1.V26 UC1.V27 UC1.V30 UC1.V33 UC1.V36 UC1.W7 UC1.W10 UC1.W27 UC1.W30 UC1.Y7 UC1.Y26 UC1.Y27 UC1.Y30 UC1.Y33 UC1.Y35 UC2.3 UC3.4 UC3.9 UC4.3 UC5.3 UC9.3 UC10.3 UC18.3 UD41.B2 UD41.B5 UD41.B6 UD41.B12 UD41.C3 UD41.C5 UD41.C6 UD41.D3 UD41.D8 UD41.D12 UD41.E4 UD41.E5 UD41.E6 UD41.F4 UD41.F5 UD41.F6 UD41.F12 UD41.G3 UD41.G4 UD41.G6 UD41.G8 UD41.G9 UD41.H2 UD41.H10 UD41.J4 UD41.J12 UD41.K2 UD41.K10 UD41.L6 UD41.L8 UD41.L9 UD41.M4 UD41.M5 UD41.M6 UD41.M12 UD41.N4 UD41.N5 UD41.N6 UD41.P3 UD41.P8 UD41.P12 UD41.R4 UD41.R5 UD41.R6 UD41.T2 UD41.T3 UD41.T4 UD41.T5 UD41.T6 UD41.T12 UD42.B2 UD42.B5 UD42.B6 UD42.B12 UD42.C3 UD42.C5 UD42.C6 UD42.D3 UD42.D8 UD42.D12 UD42.E4 UD42.E5 UD42.E6 UD42.F4 UD42.F5 UD42.F6 UD42.F12 UD42.G3 UD42.G4 UD42.G6 UD42.G8 UD42.G9 UD42.H2 UD42.H10 UD42.J4 UD42.J12 UD42.K2 UD42.K10 UD42.L6 UD42.L8 UD42.L9 UD42.M4 UD42.M5 UD42.M6 UD42.M12 UD42.N4 UD42.N5 UD42.N6 UD42.P3 UD42.P8 UD42.P12 UD42.R4 UD42.R5 UD42.R6 UD42.T2 UD42.T3 UD42.T4 UD42.T5 UD42.T6 UD42.T12 UD43.B2 UD43.B5 UD43.B6 UD43.B12 UD43.C3 UD43.C5 UD43.C6 UD43.D3 UD43.D8 UD43.D12 UD43.E4 UD43.E5 UD43.E6 UD43.F4 UD43.F5 UD43.F6 UD43.F12 UD43.G3 UD43.G4 UD43.G6 UD43.G8 UD43.G9 UD43.H2 UD43.H10 UD43.J4 UD43.J12 UD43.K2 UD43.K10 UD43.L6 UD43.L8 UD43.L9 UD43.M4 UD43.M5 UD43.M6 UD43.M12 UD43.N4 UD43.N5 UD43.N6 UD43.P3 UD43.P8 UD43.P12 UD43.R4 UD43.R5 UD43.R6 UD43.T2 UD43.T3 UD43.T4 UD43.T5 UD43.T6 UD43.T12 UD44.B2 UD44.B5 UD44.B6 UD44.B12 UD44.C3 UD44.C5 UD44.C6 UD44.D3 UD44.D8 UD44.D12 UD44.E4 UD44.E5 UD44.E6 UD44.F4 UD44.F5 UD44.F6 UD44.F12 UD44.G3 UD44.G4 UD44.G6 UD44.G8 UD44.G9 UD44.H2 UD44.H10 UD44.J4 UD44.J12 UD44.K2 UD44.K10 UD44.L6 UD44.L8 UD44.L9 UD44.M4 UD44.M5 UD44.M6 UD44.M12 UD44.N4 UD44.N5 UD44.N6 UD44.P3 UD44.P8 UD44.P12 UD44.R4 UD44.R5 UD44.R6 UD44.T2 UD44.T3 UD44.T4 UD44.T5 UD44.T6 UD44.T12 UE1.C1 UE2.3 UE3.1 UE5.3 UM1.57 UM2.11 UM3.4 UM3.9 UM4.5 UM4.21 UN4.2 UN5.2 UN5.3 UPD1.20 UPD1.45 UPD1.46 UPD1.47 UPD1.51 UPD1.59 UPD3.4 UPD3.9 UPD5.4 US2.3 US2.5 US2.6 US2.7 US2.8 UT1.A1 UT1.A2 UT1.A4 UT1.A6 UT1.A8 UT1.A10 UT1.A12 UT1.A14 UT1.A16 UT1.A18 UT1.A20 UT1.A22 UT1.A23 UT1.AA22 UT1.AA23 UT1.AB1 UT1.AB2 UT1.AB4 UT1.AB6 UT1.AB8 UT1.AB10 UT1.AB12 UT1.AB14 UT1.AB16 UT1.AB18 UT1.AB20 UT1.AB22 UT1.AC1 UT1.AC2 UT1.AC4 UT1.AC6 UT1.AC8 UT1.AC10 UT1.AC12 UT1.AC14 UT1.AC16 UT1.AC18 UT1.AC20 UT1.AC22 UT1.AC23 UT1.B1 UT1.B2 UT1.B4 UT1.B6 UT1.B8 UT1.B10 UT1.B12 UT1.B14 UT1.B16 UT1.B18 UT1.B20 UT1.B22 UT1.C22 UT1.C23 UT1.D1 UT1.D2 UT1.D4 UT1.D5 UT1.D6 UT1.D8 UT1.D9 UT1.D11 UT1.D12 UT1.D13 UT1.D15 UT1.D16 UT1.D18 UT1.E4 UT1.E9 UT1.E11 UT1.E12 UT1.E13 UT1.E15 UT1.E18 UT1.E22 UT1.E23 UT1.F1 UT1.F2 UT1.F4 UT1.F5 UT1.F6 UT1.F8 UT1.F9 UT1.F11 UT1.F12 UT1.F13 UT1.F15 UT1.F16 UT1.F20 UT1.G22 UT1.G23 UT1.H1 UT1.H20 UT1.J1 UT1.J2 UT1.J12 UT1.J15 UT1.J16 UT1.J19 UT1.J20 UT1.J22 UT1.J23 UT1.L8 UT1.L9 UT1.L12 UT1.L15 UT1.L20 UT1.L22 UT1.L23 UT1.M1 UT1.M2 UT1.M6 UT1.M9 UT1.M12 UT1.M15 UT1.M20 UT1.N9 UT1.N12 UT1.N15 UT1.N18 UT1.N19 UT1.N20 UT1.N22 UT1.N23 UT1.R4 UT1.R9 UT1.R12 UT1.R15 UT1.R18 UT1.R19 UT1.R20 UT1.R22 UT1.R23 UT1.T6 UT1.T18 UT1.T20 UT1.U22 UT1.U23 UT1.V9 UT1.V11 UT1.V12 UT1.V13 UT1.V15 UT1.V16 UT1.V18 UT1.V20 UT1.W8 UT1.W9 UT1.W11 UT1.W12 UT1.W13 UT1.W15 UT1.W22 UT1.W23 UT1.Y5 UT1.Y8 UT1.Y9 UT1.Y11 UT1.Y12 UT1.Y13 UT1.Y15 UT2.4 UT2.9 UT14.3 UV1.A2 UV1.A26 UV1.AA7 UV1.AB7 UV1.AB11 UV1.AB14 UV1.AB17 UV1.AB20 UV1.AB24 UV1.AC2 UV1.AC5 UV1.AC8 UV1.AC22 UV1.AC26 UV1.AD12 UV1.AD13 UV1.AD15 UV1.AD16 UV1.AD18 UV1.AD19 UV1.AD21 UV1.AD22 UV1.AE11 UV1.AE14 UV1.AE17 UV1.AE20 UV1.AF1 UV1.AF5 UV1.AF8 UV1.AF11 UV1.AF14 UV1.AF17 UV1.AF20 UV1.AF23 UV1.AG2 UV1.AG26 UV1.B1 UV1.B5 UV1.B8 UV1.B11 UV1.B14 UV1.B17 UV1.B20 UV1.B23 UV1.B27 UV1.E2 UV1.E5 UV1.E8 UV1.E11 UV1.E14 UV1.E17 UV1.E20 UV1.E22 UV1.E25 UV1.H23 UV1.H25 UV1.K11 UV1.K13 UV1.K15 UV1.K17 UV1.L5 UV1.L10 UV1.L12 UV1.L14 UV1.L16 UV1.L18 UV1.L23 UV1.L25 UV1.M11 UV1.M13 UV1.M15 UV1.M17 UV1.N10 UV1.N12 UV1.N14 UV1.N16 UV1.N18 UV1.P11 UV1.P13 UV1.P15 UV1.P17 UV1.P23 UV1.P26 UV1.R10 UV1.R12 UV1.R14 UV1.R16 UV1.R18 UV1.T11 UV1.T13 UV1.T15 UV1.T17 UV1.U10 UV1.U12 UV1.U14 UV1.U16 UV1.U18 UV1.U23 UV1.U26 UV1.V11 UV1.V13 UV1.V15 UV1.V17 UV1.Y2 UV1.Y5 UV1.Y23 UV1.Y26 UV2.11 UV2.15 UV6.A1 UV6.A3 UV6.A12 UV6.A14 UV6.B5 UV6.B10 UV6.C1 UV6.C3 UV6.C4 UV6.C11 UV6.C12 UV6.C14 UV6.D10 UV6.E1 UV6.E3 UV6.E12 UV6.E14 UV6.F5 UV6.F10 UV6.G5 UV6.G10 UV6.H1 UV6.H2 UV6.H13 UV6.H14 UV6.K1 UV6.K2 UV6.K13 UV6.K14 UV6.L5 UV6.L10 UV6.M5 UV6.M10 UV6.N1 UV6.N3 UV6.N12 UV6.N14 UV6.P10 UV6.R1 UV6.R3 UV6.R4 UV6.R11 UV6.R12 UV6.R14 UV6.T5 UV6.T10 UV6.U1 UV6.U3 UV6.U12 UV6.U14 UV8.A1 UV8.A3 UV8.A12 UV8.A14 UV8.B5 UV8.B10 UV8.C1 UV8.C3 UV8.C4 UV8.C11 UV8.C12 UV8.C14 UV8.D10 UV8.E1 UV8.E3 UV8.E12 UV8.E14 UV8.F5 UV8.F10 UV8.G5 UV8.G10 UV8.H1 UV8.H2 UV8.H13 UV8.H14 UV8.K1 UV8.K2 UV8.K13 UV8.K14 UV8.L5 UV8.L10 UV8.M5 UV8.M10 UV8.N1 UV8.N3 UV8.N12 UV8.N14 UV8.P10 UV8.R1 UV8.R3 UV8.R4 UV8.R11 UV8.R12 UV8.R14 UV8.T5 UV8.T10 UV8.U1 UV8.U3 UV8.U12 UV8.U14 UV10.3 UV11.3 UV12.3 UV17.2 UV23.3 UV25.3 UV26.3 UZ1.11 UZ1.15 UZ2.5 UZ3.11 UZ3.15 UZ4.5 UZ4.9 UZ7.5 UZ8.5 UZ8.9 UZ9.5 UZ9.9 WL1.6 WL1.17 WL1.20 WL1.23 WL1.26 WL1.32 WL1.35 WL1.38 WL1.41 WL1.62 WL1.68 WL1.71 WL1.74 WL1.75 WL1.76 WL1.77 WL1.78 WL1.79 WL1.80 WL1.81 WL1.82 WL1.83 WL1.84 WL1.85 WL1.86 WL1.87 WL1.88 WL1.89 WL1.90 WL1.91 WL1.92 WL1.93 WL1.94 WL1.95 WL1.96 WL1.A07 WL1.A15 WL1.A26 WL1.A31 WL1.A50 WL1.G1 WL1.G2 WL1.G3 WL1.G4 WL1.G5 WL1.G6 WL1.G7 WL1.G8 WL1.G9 WL1.G10 WL1.G11 WL1.G12 XE1.2 YC1.2 YC1.4 YM1.2 YM1.4 YT1.2 YT1.4 YV1.2 YV1.4
GND_SENSE_GPU: PRV42.1 PRV47.2 UV1.F1
VBAT_CHG: PCB45.1 PRB39.2 PUB01.31
VCC33_GPU: PCV48.2 PRV40.1 PUV01.17
VCC_1.05V: PCH13.1 PRH01.1 PRH07.2 PUH01.17
VCC_1.8V: PC1809.1 PR1802.2 PU1801.8
VCC_GPU1: PCV12.1 PRV20.2 PUV02.14
VCC_GPU2: PCV35.1 PRV26.2 PUV03.14
VCC_GT: PCG07.1 PRG01.1 PUG01.14
VCC_GT_SENSE: PRZ41.1 RC169.2 UC1.E3
VCC_IA1: PCI10.1 PRI01.1 PUI01.14
VCC_IA2: PCI22.1 PRI03.1 PUI02.14
VCC_IA3: PCI34.1 PRI05.1 PUI03.14
VCC_SA: PCA08.1 PRA01.1 PUA01.14
VCCDPHY_1P24: CC58.1 RC133.2 UC1.CP25
VCCDSW_EN: DZ2.2 PR1809.2 PRH08.1 RE58.2 RZ4.1 UE1.B25
VCCDSW_EN_UZ4: CZ20.1 RZ4.2 RZ1419.2 UZ4.3
VCCGT_B+: PCG02.1 PCG03.1 PCG04.1 PCG05.1 PCG06.1 PCG20.1 PLG11.2 PLG12.2 PUG01.1 PUG01.8
VCCIO_EN: UC18.4 UZ2.4
VCCSA_B+: PCA02.1 PCA03.1 PCA04.1 PCA05.1 PCA06.1 PLA11.2 PUA01.1 PUA01.8
VCCSENSE: PRZ45.1 RC167.2 UC1.AN6
VCCST_PWRGD: CC119.1 RC99.1 RC554.2 U7.4
VCCST_PWRGD_CPU: RC99.2 UC1.BJ2
VCCSTG_IO_EN: CZ4.1 RZ2.2 RZ10.1 UC9.4 UZ1.3
VCCSTG_IO_EN_UZ7: CZ219.1 RZ10.2 UZ7.4
VDD12_GPU: PCV47.1 PUV01.7
VDD_CHG: PCB28.1 PRB09.2 PRB11.1 PRB13.2 PUB01.18
VDD_SENSE_GPU: PRV33.2 PRV44.2 UV1.F2
VDDP_CHG: PCB29.1 PRB09.1 PUB01.8
VINSEN_GPU: PCV42.1 PRV32.1 PRV34.1 PUV01.12
VSS_GT_SENSE: PRZ40.1 RC170.1 UC1.D2
VSSSENSE: PRZ44.1 RC168.1 UC1.AN5
2.7MM_CAM_DET#: JEDP1.19 RC563.1 UC1.BY31
3MM_CAM_DET#: JEDP1.18 RC564.2 UC1.CR12
+CHARGER_SRC: PCB01.1 PCB02.1 PCB03.1 PCB04.1 PCB05.1 PCB06.1 PCB16.1 PCB17.1 PCB47.1 PCB48.1 PLB11.2 PQB01.2
+DCBAT_LCD: C45.1 C46.1 C47.1 C48.1 C49.1 C6677.1 DV13.2 F4.2 JEDP1.1 JEDP1.2
+DCBAT_LCD_DV13: CV633.1 DV13.1 RV626.1 RV627.1
+DCBAT_LCD_DV13_R: QV18.2 RV627.2
+DCIN_JACK: PJP1.1 PJPDC1.3 PJPDC1.4
+DTH_VDD12: CH1.1 CM11.1 CM12.1 CM13.1 CM14.1 LM2.2 UM1.27 UM1.42
+DTH_VDD33: CM3.1 CM4.1 CM5.1 CM6.1 LM1.2 UM1.26 UM1.49
+DTH_VDDA12: CM26.1 CM27.1 CM28.1 LM3.2 UM1.29
+DTH_VDDRX12: CM32.1 CM33.1 CM34.1 CM35.1 CM36.1 CM37.1 CM38.1 LM4.2 UM1.2 UM1.14
+DTH_VDDTX12: CM42.1 CM43.1 CM44.1 CM45.1 CM46.1 LM5.2 UM1.28 UM1.41
+EC_DEBUG_VCC: JDEG1.1 RE48.2
+FB_PLLAVDD: CV51.1 CV52.2 CV53.1 CV55.1 CV398.1 CV780.1 CV781.1 CV782.1 CV783.1 CV784.1 CV785.2 LV7.1 UV1.F16 UV1.H22 UV1.P22
+FBA_VREFC0: CV158.1 CV159.1 CV741.1 CV754.1 RV125.2 RV127.1 RV200.2 UV6.J14 UV8.J14
+GPU_CORE: CV933.1 PCV14.1 PCV16.1 PCV17.1 PCV18.1 PCV19.1 PCV20.1 PCV21.1 PCV22.1 PCV23.1 PCV24.1 PCV25.1 PCV26.1 PCV27.1 PCV28.1 PCV29.1 PCV30.1 PCV31.1 PCV32.1 PCV33.1 PCV50.1 PCV51.1 PCV52.1 PCV53.1 PCV54.1 PCV55.1 PCV56.1 PCV57.1 PCV58.1 PCV59.1 PCV60.1 PCV61.1 PCV62.1 PCV63.1 PCV64.1 PCV65.1 PCV66.1 PCV67.1 PCV68.1 PCV69.1 PCV70.1 PLV01.2 PLV02.2 PRV33.1 RV2009.1 UV1.G1 UV1.G2 UV1.G3 UV1.G4 UV1.G5 UV1.G6 UV1.G7 UV1.H3 UV1.H4 UV1.H6 UV1.J1 UV1.J2 UV1.J3 UV1.J4 UV1.J5 UV1.J6 UV1.J7 UV1.K1 UV1.K2 UV1.K3 UV1.K4 UV1.K5 UV1.K6 UV1.K7 UV1.K10 UV1.K12 UV1.K14 UV1.K16 UV1.K18 UV1.L3 UV1.L4 UV1.L11 UV1.L13 UV1.L15 UV1.L17 UV1.M1 UV1.M2 UV1.M3 UV1.M4 UV1.M5 UV1.M7 UV1.M10 UV1.M12 UV1.M14 UV1.M16 UV1.M18 UV1.N1 UV1.N2 UV1.N3 UV1.N4 UV1.N5 UV1.N7 UV1.N11 UV1.N13 UV1.N15 UV1.N17 UV1.P3 UV1.P4 UV1.P6 UV1.P10 UV1.P12 UV1.P14 UV1.P16 UV1.P18 UV1.R1 UV1.R2 UV1.R3 UV1.R4 UV1.R5 UV1.R6 UV1.R7 UV1.R11 UV1.R13 UV1.R15 UV1.R17 UV1.T1 UV1.T2 UV1.T3 UV1.T4 UV1.T5 UV1.T6 UV1.T7 UV1.T10 UV1.T12 UV1.T14 UV1.T16 UV1.T18 UV1.U3 UV1.U4 UV1.U6 UV1.U11 UV1.U13 UV1.U15 UV1.U17 UV1.V1 UV1.V2 UV1.V3 UV1.V4 UV1.V10 UV1.V12 UV1.V14 UV1.V16 UV1.V18 UV1.W1 UV1.W2 UV1.W3 UV1.W4
+GPU_PLLVDD: CV31.1 CV34.1 CV60.1 CV394.1 CV395.1 CV396.1 CV771.1 CV774.1 CV775.1 LV10.2 UV1.F11 UV1.L6 UV1.M6 UV1.N6
+IR_B+: F2.2 JEDP1.3
+LCDVDD: F1.1 U1.1
+LCDVDD_LCD: C7.1 C8.1 C9.1 C41.1 C43.1 C44.1 DV14.2 F1.2 JEDP1.5 JEDP1.6 RV623.1
+LCDVDD_LCD_DV14: CV651.1 DV14.1 RV629.1 RV631.1
+LCDVDD_LCD_DV14_R: QV18.5 RV631.2
+MIC_VCC: C36.1 F6.2 F7.2 JEDP1.23
+PEX_IOVDDQ: CV3.1 CV10.1 CV198.1 CV200.1 CV201.1 CV203.1 CV390.1 CV391.1 CV392.1 CV769.1 CV770.1 RV4970.1 UV1.AA10 UV1.AA12 UV1.AA13 UV1.AA16 UV1.AA18 UV1.AA19 UV1.AA20 UV1.AA21 UV1.AB22 UV1.AC23 UV1.AD24 UV1.AE25 UV1.AF26 UV1.AF27
+PEX_PLL_HVDD: CV207.1 RV4976.1 UV1.AA8 UV1.AA9
+PWR_SRC_AC: PDB05.1 PLB11.1 PRB01.4
+RTC_CELL: CB16.1 DB3.1 DB4.1 JIO1.1 Q17.3 RB22.1 RE6.1 RE20.1 RE31.2 RE546.1 RE553.2
+RTC_CELL_VBAT: CE12.1 RE6.2 UE1.A64
+RTC_SOC: C3.1 CC51.1 CC52.1 Q17.1 R63.1 RC77.1 RC82.1 RC87.1 UC1.BR23
+RTC_VCC: JRTC1.1 RB21.1
+RTC_VCC_R: RB21.2 RB22.2
+SDC_IN: CPD40.1 CPD47.1 CPD52.1 CPD55.1 CPD56.1 PDB02.2 PJP1.2 PRB01.1 PRB04.1 PRB05.1 UPD1.11 UPD1.12
+SIM_PWR: CS35.1 CS39.1 JNGFF1.36 JSIM1.1 RS2.1
+TBT_SVR_IND: LT10.1 UT1.K1 UT1.K2 UT1.L1 UT1.L2
+TBT_VBUS_L_PD: CPD42.1 CPD49.1 CT343.1 CT344.1 CT346.1 LT11.2 LT13.2 PR103.1 UPD1.3 UPD1.4 UPD1.13 UPD1.14
+TBTA_VBUS: CT99.1 CT100.1 CT101.1 CT102.1 CT189.1 CT190.1 CT350.1 CT351.1 CT352.1 DT4.2 DT4.3 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 LT11.1 LT13.1
+TP_VDD: C26.1 C107.2 JTP1.8 Q8.2 R39.2 R42.1 R43.1 R45.1 R46.1 R6907.2
+TP_VDD_N: Q5.6 R39.1
+TP_VDD_P: Q5.3 R6907.1
+TS_VDD: C53.1 C54.1 C55.1 C78.1 C6905.1 F8.2 JCAM1.5 R86.1 R87.1 R88.1
+V_DDR_REF_CA: CD113.1 RD25.1 UC1.F36
+V_DDR_REFA_R: CD27.1 RD11.1 UC1.D35 UC1.D37
+V_DDR_REFB_R: CD52.1 RD22.1 UC1.E36
+VCHGR: PCB31.1 PCB32.1 PQB03.1 PQB03.2 PQB03.3 PRB12.4
+VDISPLAY_VCC: CV597.1 CV598.1 JHDMI1.18 RM3.1 RM4.1 UV17.3
+VREFCA: CD60.1 CD64.1 CD81.1 CD82.1 RD25.2 RD27.1 RD28.2 UD41.H4 UD42.H4 UD43.H4 UD44.H4
+VREFDQ_A: CD59.1 CD62.1 RD10.2 RD11.2 RD12.1 UD41.J11 UD42.J11
+VREFDQ_B: CD75.1 CD89.1 RD21.2 RD22.2 RD23.1 UD43.J11 UD44.J11
A4WP_PRESENT: RC61.2 UC1.CF17
A/BMON_CHG: PCB40.1 PRB34.1 PRB35.1 PUB01.29
AC_DIS: PRB43.2 UE1.A7
AC_PRESENT: DV1.2 RC569.1 UC1.BU35
ACAV_IN1: PQB04.1 PRB11.2 PRB20.1 PRB22.2 PRB41.1
ACIN_CHG: PCB26.1 PRB05.2 PRB07.1 PUB01.19
ACOK_CHG: PRB22.1 PUB01.24
ADCIN1_L_PD: RPD91.1 RPD92.2 UPD1.6
ADCIN2_L_PD: RPD90.2 RPD100.1 UPD1.10
ADDR_GPU: PCV45.1 PRV37.2 PRV41.1 PRV46.2 PUV01.6
ADDR_P_CPU: PRZ14.1 PRZ15.2 PUZ01.25
ADJ_1.0V: PCF04.2 PRF05.2 PRF06.1 PUF01.8
ADJ_UM2: CM50.2 RM7.1 RM39.2 UM2.4
ADP_CHG: PRB04.2 PUB01.16
ALERT#: R54.2 U3.6
ALL_SYS_PWRGD: PQ501.2 RE477.1 RE508.2 RE509.1 RE510.1
ALT#_CPU: PRZ12.1 PUZ01.29
ALT#_CPU_R: PRZ12.2 PRZ23.2 PRZ28.1
ALWON: PQB13.2 PR523.1 UE1.B65
AMBER_LED_BAT: Q31.1 R28.2
AMBER_LED_BAT_R: LED1.1 R28.1
ANT1_CS0: CS47.1 JANT1.1 LS4.1
ANT1_CS0_R: LS4.2 RS9.1
ANT_CTL0: JANT2.2 LN9.2
ANT_CTL1: JANT2.3 LN10.2
ANTCTL0: JNGFF1.59 LN9.1
ANTCTL1: JNGFF1.61 LN10.1
AUXDCN: RM48.2 UM1.53
AUXDCP: RM49.1 UM1.54
B+: C6676.1 CV75.1 CV76.1 CV77.1 F2.1 JIO2.1 JIO2.2 PC301.1 PC306.1 PC533.1 PC534.1 PC535.1 PC536.1 PC537.1 PC538.1 PC1814.1 PC1815.1 PCA11.1 PCA12.1 PCB07.1 PCB10.1 PCB11.1 PCB12.1 PCB13.1 PCB14.1 PCB15.1 PCB21.1 PCB22.1 PCB23.1 PCB24.1 PCB46.1 PCB49.1 PCB50.1 PCB51.1 PCG10.1 PCG11.1 PCH15.1 PCH16.1 PCI37.1 PCI38.1 PCM06.1 PCM07.1 PCV71.1 PCV72.1 PCW33.1 PCW34.1 PDB01.2 PL311.1 PL312.1 PL511.1 PL1811.1 PLA11.1 PLG11.1 PLG12.1 PLH11.1 PLI11.1 PLI12.1 PLI13.1 PLM12.1 PLV03.1 PLV04.1 PLW13.1 PQB02.2 PR302.2 PRB12.1 PRB21.2 QV18.1 U711.3 U711.4
B+_1.2V: PCM17.1 PCM18.1 PCM26.1 PLM12.2 PUM01.1
B+_1.05V: PCH01.1 PCH02.1 PCH03.1 PCH04.1 PCH18.1 PCH19.1 PLH11.2 PUH01.2 PUH01.11
B+_1.8V: PC1801.1 PC1802.1 PC1803.1 PC1804.1 PC1817.1 PL1811.2 PU1801.1
B+_3V: PC302.1 PC303.1 PC304.1 PC305.1 PC321.1 PL311.2 PL312.2 PU301.2 PU301.3 PU301.4
B+_5V: PC501.1 PC502.1 PC503.1 PC504.1 PC505.1 PC517.1 PL511.2 PU501.1
B+_+1.35VGPU: PCW16.2 PCW19.2 PCW20.1 PCW21.2 PCW26.2 PCW32.1 PLW13.2 PUW01.2 PUW01.3 PUW01.4 PUW01.5
BA: PQB12.1 PRB65.2 PRB66.1
BA_PWR: PRB39.1 PRB66.2
BAT1_LED#: Q15.1 RE21.2 UE1.A50
BAT1_LED#_R: QZ3.2 QZ21.1
BAT2_LED#: Q15.4 RE23.2 UE1.B54
BATGONE_CHG: PCB34.1 PRB24.1 PRB25.1 PUB01.25
BATT_PRES#: PBATT1.6 PR39.1

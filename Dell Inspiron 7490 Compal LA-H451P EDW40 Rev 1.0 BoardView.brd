# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Nets (continued)
BATT_WHITE_LED_R#: Q3.1 Q15.3 Q32.2
BEEP: JIO1.2 UE1.A6
BGATE_CHG: PCB33.1 PQB03.4 PUB01.32
BIA_PWM_EC: D2.3 UE1.A28
BKLT_CTRL: D2.1 JEDP1.7 R75.1
BKLT_IN_EC: D463.2 RC13.1 UC1.CK11
BL_PWR_MONITOR: QV19.2 RV625.2
BL_PWR_MONITOR_R: QV18.6 RV625.1
BLUETOOTH_EN: RC570.2 RW59.1 UC1.CP14
BLUETOOTH_EN_R: RW59.2 WL1.63
BOARD_ID: CE11.1 RE1.2 RE2.2 UE1.A13
BOOT1_CHG: PRB06.1 PUB01.12
BOOT2_CHG: PCB30.1 PUB01.4
BST_1.2V: PRM20.1 PUM01.10
BST_1.2V_R: PCM27.1 PRM20.2
BST_1.05V: PRH03.1 PUH01.1
BST_1.05V_R: PCH10.1 PRH03.2
BST_1.8V: PR1803.1 PU1801.7
BST_1.8V_R: PC1810.1 PR1803.2
BST_3V: PR301.1 PU301.1
BST_3V_R: PC307.1 PR301.2
BST_5V: PR504.1 PU501.10
BST_5V_R: PC514.1 PR504.2
BST_+1.35VGPU: PRW14.1 PUW01.1
BST_+1.35VGPU_R: PCW18.1 PRW14.2
BST_GPU1: PCV13.1 PUV02.15
BST_GPU2: PCV39.1 PUV03.15
BST_GT: PCG08.1 PUG01.15
BST_IA1: PCI11.1 PUI01.15
BST_IA2: PCI23.1 PUI02.15
BST_IA3: PCI35.1 PUI03.15
BST_SA: PCA09.1 PUA01.15
CAP_LED: JKB1.4 R48.2
CAP_LED#: Q9.3 R47.2 UE1.B53
CAP_LED_Q: Q12.1 R48.1
CAP_LED_R#: Q9.1 Q12.2
CATERR#: TP77.1(TP-1) UC1.AA4
CEXT_U34: CE36.1 RE99.2 U34.7
CFG0: RC548.2 UC1.T4
CFG1: RC405.2 UC1.R4
CFG2: RC406.2 UC1.T3
CFG3: RC407.2 UC1.R3
CFG4: RC408.2 UC1.J4
CFG5: RC409.2 UC1.M4
CFG6: RC410.2 UC1.J3
CFG7: RC411.2 UC1.M3
CFG8: RC412.2 UC1.R2
CFG9: RC413.2 UC1.N2
CFG10: RC414.2 UC1.R1
CFG11: RC415.2 UC1.N1
CFG12: RC416.2 UC1.J2
CFG13: RC417.2 UC1.L2
CFG14: RC418.2 UC1.J1
CFG15: RC419.2 UC1.L1
CFG16: TP100.1(TP-1) UC1.L3
CFG17: TP102.1(TP-1) UC1.L4
CFG18: TP101.1(TP-1) UC1.N3
CFG19: TP103.1(TP-1) UC1.N4
CFG_RCOMP: RC546.2 UC1.AB5
CHG_AMBER_LED_R#: Q15.6 Q31.2 QZ3.3
CLK_CNV_CRX_DTX_N: RW54.2 UC1.CN31
CLK_CNV_CRX_DTX_P: RW53.2 UC1.CP31
CLK_CNV_CRX_R_DTX_N: RW54.1 WL1.A33
CLK_CNV_CRX_R_DTX_P: RW53.1 WL1.A32
CLK_CNV_CTX_DRX_N: RW48.2 UC1.CP34
CLK_CNV_CTX_DRX_P: RW46.2 UC1.CN34
CLK_CNV_CTX_R_DRX_N: RW48.1 WL1.A20
CLK_CNV_CTX_R_DRX_P: RW46.1 WL1.A19
CLK_ITPXDP_N: RC540.2 UC1.AU1
CLK_ITPXDP_N_R: JXDP1.42 RC540.1
CLK_ITPXDP_P: RC539.2 UC1.AU2
CLK_ITPXDP_P_R: JXDP1.40 RC539.1
CLK_PCIE_N2: LN3.4 RN18.1 UC1.BD3
CLK_PCIE_N2_R: JNGFF1.53 LN3.3 RN18.2
CLK_PCIE_N3: UC1.BH3 UT1.T19
CLK_PCIE_N4: JSSD1.53 UC1.BA1
CLK_PCIE_P2: LN3.1 RN17.1 UC1.BC3
CLK_PCIE_P2_R: JNGFF1.55 LN3.2 RN17.2
CLK_PCIE_P3: UC1.BH4 UT1.V19
CLK_PCIE_P4: JSSD1.55 UC1.BA2
CLK_PEG_N0: UC1.AW2 UV1.AD8
CLK_PEG_P0: UC1.AY3 UV1.AE8
CLK_SMB: PBATT1.8 PR42.1
CLK_TP_SIO_I2C_DAT: R32.2 UE1.A48
CLKREQ_CNV#: RC73.2 RW31.1 UC1.CH29
CLKREQ_CNV#_R: RW31.2 WL1.59 WL1.A43
CLKREQ_PCIE#2: QN4.3 RC206.2 RN96.2 UC1.CF30
CLKREQ_PCIE#2_R: JNGFF1.52 QN4.6 RN95.1 RN96.1
CLKREQ_PCIE#3: RC262.2 RT502.1 UC1.CE31 UT1.Y6
CLKREQ_PCIE#4: JSSD1.52 RC88.2 UC1.CE30
CLKREQ_PEG#0: QV3.1 RC78.2 UC1.CF32
CLKREQ_PEG#0_R: QV3.3 RV68.2 UV1.AC6
CLM_5V: PR503.2 PU501.11
CLM_+1.35VGPU: PRW17.2 PRW23.1 PUW01.13
CLR#_U34: RE97.2 U34.3
CMOUT_CHG: PRB27.2 PRB29.2 PUB01.26
CMP_STRAP: RE541.1 UE1.B15
CNV_BRI_CRX_DTX: RW27.2 UC1.CK20
CNV_BRI_CRX_R_DTX: RW27.1 WL1.54 WL1.A39
CNV_BRI_CTX_DRX: RW26.2 UC1.CJ20
CNV_BRI_CTX_R_DRX: RW26.1 WL1.57 WL1.A38
CNV_COEX1: RW11.2 UC1.CH17
CNV_COEX2: RW12.2 UC1.CJ17
CNV_COEX3: RW13.2 UC1.CP20
CNV_CRX_DTX_N0: RW56.2 UC1.CR30
CNV_CRX_DTX_N1: RW58.2 UC1.CM30
CNV_CRX_DTX_P0: RW55.2 UC1.CP30
CNV_CRX_DTX_P1: RW57.2 UC1.CN30
CNV_CRX_R_DTX_N0: RW56.1 WL1.A35
CNV_CRX_R_DTX_N1: RW58.1 WL1.A37
CNV_CRX_R_DTX_P0: RW55.1 WL1.A34
CNV_CRX_R_DTX_P1: RW57.1 WL1.A36
CNV_CTX_DRX_N0: RW49.2 UC1.CN32
CNV_CTX_DRX_N1: RW51.2 UC1.CP33
CNV_CTX_DRX_P0: RW47.2 UC1.CM32
CNV_CTX_DRX_P1: RW50.2 UC1.CN33
CNV_CTX_R_DRX_N0: RW49.1 WL1.A22
CNV_CTX_R_DRX_N1: RW51.1 WL1.A24
CNV_CTX_R_DRX_P0: RW47.1 WL1.A21
CNV_CTX_R_DRX_P1: RW50.1 WL1.A23
CNV_RF_RESET#: RC74.2 RW30.1 UC1.CJ32 WL1.58
CNV_RF_RESET#_R: RW30.2 WL1.A42
CNV_RGI_CRX_DTX: RC122.2 RW25.2 UC1.CH19
CNV_RGI_CRX_R_DTX: RW25.1 WL1.56 WL1.A41
CNV_RGI_CTX_DRX: RC108.2 RC162.2 RW24.2 UC1.CG19
CNV_RGI_CTX_R_DRX: RW24.1 WL1.55 WL1.A40
CNV_WT_RCOMP: RC60.2 UC1.CP32 UC1.CR32
COMP_CHG: PCB39.1 PRB30.1 PUB01.28
CPU_C10_GATE#: RC230.1 UC1.CN27 UC9.2 UC18.1
CPU_DP1_AUXN: CT19.2 UC1.AC7
CPU_DP1_AUXN_C: CT19.1 UT1.P2
CPU_DP1_AUXP: CT18.2 UC1.AC6
CPU_DP1_AUXP_C: CT18.1 UT1.P1
CPU_DP1_CTRL_DATA: RC8.1 UC1.CC9
CPU_DP1_HPD: RC504.1 UC1.CN6 UT1.Y4
CPU_DP1_N0: CT11.2 UC1.AL5
CPU_DP1_N0_C: CT11.1 UT1.B5
CPU_DP1_N1: CT13.2 UC1.AJ5
CPU_DP1_N1_C: CT13.1 UT1.A3
CPU_DP1_N2: CT15.2 UC1.AF6
CPU_DP1_N2_C: CT15.1 UT1.C1
CPU_DP1_N3: CT17.2 UC1.AE5
CPU_DP1_N3_C: CT17.1 UT1.E1
CPU_DP1_P0: CT10.2 UC1.AL6
CPU_DP1_P0_C: CT10.1 UT1.A5
CPU_DP1_P1: CT12.2 UC1.AJ6
CPU_DP1_P1_C: CT12.1 UT1.B3
CPU_DP1_P2: CT14.2 UC1.AF5
CPU_DP1_P2_C: CT14.1 UT1.C2
CPU_DP1_P3: CT16.2 UC1.AE6
CPU_DP1_P3_C: CT16.1 UT1.E2
CPU_DP2_AUXN: CT184.2 UC1.AD4
CPU_DP2_AUXN_C: CT184.1 UT1.N2
CPU_DP2_AUXP: CT178.2 UC1.AD3
CPU_DP2_AUXP_C: CT178.1 UT1.N1
CPU_DP2_CTRL_DATA: RC9.1 UC1.CH3
CPU_DP2_HPD: RC12.1 UC1.CM6 UT1.AA2
CPU_DP2_N0: CT187.2 UC1.AC4
CPU_DP2_N0_C: CT187.1 UT1.AB7
CPU_DP2_N1: CT180.2 UC1.AC1
CPU_DP2_N1_C: CT180.1 UT1.AC9
CPU_DP2_N2: CT179.2 UC1.AE4
CPU_DP2_N2_C: CT179.1 UT1.AB11
CPU_DP2_N3: CT181.2 UC1.AE1
CPU_DP2_N3_C: CT181.1 UT1.AC13
CPU_DP2_P0: CT186.2 UC1.AC3
CPU_DP2_P0_C: CT186.1 UT1.AC7
CPU_DP2_P1: CT183.2 UC1.AC2
CPU_DP2_P1_C: CT183.1 UT1.AB9
CPU_DP2_P2: CT185.2 UC1.AE3
CPU_DP2_P2_C: CT185.1 UT1.AC11
CPU_DP2_P3: CT182.2 UC1.AE2
CPU_DP2_P3_C: CT182.1 UT1.AB13
CPU_POPIRCOMP: RC15.1 UC1.BP27
CPU_SPI_0_CLK: RC21.2 RC187.1 UC1.CH37
CPU_SPI_0_CS#0: JSPI1.5 RC31.2 RC556.1 U27.1 UC1.CG36 UC3.1
CPU_SPI_0_CS#1: JSPI1.1 UC1.CG35
CPU_SPI_0_D0: RC23.2 RC35.1 UC1.CF36
CPU_SPI_0_D1: RC22.2 UC1.CF37
CPU_SPI_0_D2: RC24.2 RC36.1 UC1.CF34
CPU_SPI_0_D3: RC25.2 RC37.1 UC1.CG34
CPU_SPI_CLK: CC73.1 CC111.1 JSPI1.4 RC21.1 RC40.1 RC524.1
CPU_SPI_D0: JSPI1.2 RC23.1 RC42.1 RC525.1
CPU_SPI_D1: JSPI1.3 RC22.1 RC43.1 RC526.1
CPU_SPI_D2: JSPI1.6 RC24.1 RC39.1 RC527.1
CPU_SPI_D3: JSPI1.7 RC25.1 RC41.1 RC528.1
CPU_XDP_PRDY#: TP104.1(TP-1) UC1.W1
CPU_XDP_PREQ#: TP134.1(TP-1) UC1.W2
CPU_XDP_TCK: RC244.2 UC1.P6 UC1.T6
CPU_XDP_TDI: RC240.2 UC1.U5 UC1.U6
CPU_XDP_TDO: RC242.2 UC1.W5 UC1.Y5
CPU_XDP_TMS: RC239.2 UC1.P5 UC1.T5
CPU_XDP_TRST#: TP138.1(TP-1) UC1.AB6 UC1.Y6
CS_CORE1: PRZ52.1 PUI01.12 PUZ01.5
CS_CORE2: PRZ51.1 PUI02.12 PUZ01.4
CS_CORE3: PRZ50.1 PUI03.12 PUZ01.3
CS_GT1: PRZ49.1 PUG01.12 PUZ01.1
CS_SA: PRZ48.1 PUA01.12 PUZ01.48
CSIN_CHG: PCB18.2 PCB20.1 PRB03.2 PUB01.14
CSIP_CHG: PCB18.1 PCB19.1 PRB02.2 PUB01.15
CSN_GPU: PCV44.1 PRV35.2 PRV39.2 PUV01.13
CSON_CHG: PCB41.2 PCB43.1 PRB36.1 PUB01.1
CSOP_CHG: PCB38.1 PCB41.1 PRB32.1 PUB01.2
CSSUMA: PRZ50.2 PRZ51.2 PRZ52.2 PUZ01.18
CSSUMB: PRZ49.2 PUZ01.19
CSSUMC: PRZ48.2 PUZ01.20
CT1_UV2: CV326.1 UV2.12
CT1_UZ1: CZ7.1 UZ1.12
CT1_UZ3: CZ16.1 UZ3.12
CT2_UV2: CV327.1 UV2.10
CT2_UZ1: CZ6.1 UZ1.10
CT2_UZ3: CZ17.1 UZ3.10
CT_U19: C60.1 U19.6
CT_UZ4: CZ22.1 UZ4.6
CT_UZ8: CZ224.1 UZ8.6
DAT_SMB: PBATT1.7 PR37.1
DAT_TP_SIO_I2C_CLK: R33.2 UE1.B51
DBC_PANEL_EN: JEDP1.16 RC106.2 UC1.CE28
DCIN_CHG: PCB27.1 PRB08.2 PUB01.17
DDC_SCL_HDMI: JHDMI1.15 RM3.2 UM1.52
DDC_SDA_HDMI: JHDMI1.16 RM4.2 UM1.51
DDR_A0_ZQ0: RD1.1 UD42.B3
DDR_A0_ZQ1: RD3.1 UD42.B4
DDR_A1_ZQ0: RD2.1 UD41.B3
DDR_A1_ZQ1: RD4.1 UD41.B4
DDR_B0_ZQ0: RD5.1 UD44.B3
DDR_B0_ZQ1: RD7.1 UD44.B4
DDR_B1_ZQ0: RD6.1 UD43.B3
DDR_B1_ZQ1: RD8.1 UD43.B4
DDR_CHA_EN: RC226.2 RC227.1 UC1.CK19
DDR_CHB_EN: RC225.2 RC228.1 UC1.CG17
DDR_M0_CAA_0: RD88.1 UC1.AB35 UD42.R2
DDR_M0_CAA_1: RD77.1 UC1.W36 UD42.P2
DDR_M0_CAA_2: RD63.1 UC1.AA37 UD42.N2
DDR_M0_CAA_3: RD75.1 UC1.AB34 UD42.N3
DDR_M0_CAA_4: RD29.1 UC1.AA36 UD42.M3
DDR_M0_CAA_5: RD31.1 UC1.V34 UD42.F3
DDR_M0_CAA_6: RD33.1 UC1.AA34 UD42.E3
DDR_M0_CAA_7: RD35.1 UC1.W34 UD42.E2
DDR_M0_CAA_8: RD37.1 UC1.V35 UD42.D2
DDR_M0_CAA_9: RD39.1 UC1.W35 UD42.C2
DDR_M0_CAB_0: RD41.1 UC1.AC32 UD41.R2
DDR_M0_CAB_1: RD43.1 UC1.AB32 UD41.P2
DDR_M0_CAB_2: RD45.1 UC1.AC31 UD41.N2
DDR_M0_CAB_3: RD47.1 UC1.Y32 UD41.N3
DDR_M0_CAB_4: RD49.1 UC1.W32 UD41.M3
DDR_M0_CAB_5: RD51.1 UC1.AC34 UD41.F3
DDR_M0_CAB_6: RD53.1 UC1.AB31 UD41.E3
DDR_M0_CAB_7: RD55.1 UC1.Y31 UD41.E2
DDR_M0_CAB_8: RD57.1 UC1.AC36 UD41.D2
DDR_M0_CAB_9: RD59.1 UC1.AC37 UD41.C2
DDR_M0_CKE0: RD65.1 UC1.U36 UD42.K3
DDR_M0_CKE1: RD67.1 UC1.U37 UD42.K4
DDR_M0_CKE2: RD69.1 UC1.U34 UD41.K3
DDR_M0_CKE3: RD80.1 UC1.U35 UD41.K4
DDR_M0_CLK0: RD79.1 UC1.V31 UD42.J3
DDR_M0_CLK1: RD84.1 UC1.T31 UD41.J3
DDR_M0_CLK#0: RD78.1 UC1.V32 UD42.J2
DDR_M0_CLK#1: RD81.1 UC1.T32 UD41.J2
DDR_M0_CS#0: RD61.1 UC1.AE32 UD41.L3 UD42.L3
DDR_M0_CS#1: RD64.1 UC1.AF32 UD41.L4 UD42.L4
DDR_M0_D0: UC1.A26 UD42.F9
DDR_M0_D1: UC1.D26 UD42.D9
DDR_M0_D2: UC1.D28 UD42.E10
DDR_M0_D3: UC1.C28 UD42.E11
DDR_M0_D4: UC1.B26 UD42.E9
DDR_M0_D5: UC1.C26 UD42.F8
DDR_M0_D6: UC1.B28 UD42.F10
DDR_M0_D7: UC1.A28 UD42.F11
DDR_M0_D8: UC1.B30 UD42.C11
DDR_M0_D9: UC1.D30 UD42.B11
DDR_M0_D10: UC1.B33 UD42.C8
DDR_M0_D11: UC1.D32 UD42.B8
DDR_M0_D12: UC1.A30 UD42.C10
DDR_M0_D13: UC1.C30 UD42.B10
DDR_M0_D14: UC1.B32 UD42.B9
DDR_M0_D15: UC1.C32 UD42.C9
DDR_M0_D16: UC1.J22 UD42.N11
DDR_M0_D17: UC1.H25 UD42.M9
DDR_M0_D18: UC1.G22 UD42.M10
DDR_M0_D19: UC1.H22 UD42.M11
DDR_M0_D20: UC1.F25 UD42.M8
DDR_M0_D21: UC1.J25 UD42.P9
DDR_M0_D22: UC1.G25 UD42.N9
DDR_M0_D23: UC1.F22 UD42.N10
DDR_M0_D24: UC1.D22 UD42.R8
DDR_M0_D25: UC1.C22 UD42.T8
DDR_M0_D26: UC1.C24 UD42.R11
DDR_M0_D27: UC1.D24 UD42.T10
DDR_M0_D28: UC1.A22 UD42.T9
DDR_M0_D29: UC1.B22 UD42.R9
DDR_M0_D30: UC1.A24 UD42.T11
DDR_M0_D31: UC1.B24 UD42.R10
DDR_M0_D32: UC1.H37 UD41.D9
DDR_M0_D33: UC1.H34 UD41.F8
DDR_M0_D34: UC1.K34 UD41.F11
DDR_M0_D35: UC1.K35 UD41.F10
DDR_M0_D36: UC1.H36 UD41.F9
DDR_M0_D37: UC1.H35 UD41.E9
DDR_M0_D38: UC1.K36 UD41.E10
DDR_M0_D39: UC1.K37 UD41.E11
DDR_M0_D40: UC1.N36 UD41.B10
DDR_M0_D41: UC1.N34 UD41.C10
DDR_M0_D42: UC1.R37 UD41.B8
DDR_M0_D43: UC1.R34 UD41.B9
DDR_M0_D44: UC1.N37 UD41.B11
DDR_M0_D45: UC1.N35 UD41.C11
DDR_M0_D46: UC1.R36 UD41.C8
DDR_M0_D47: UC1.R35 UD41.C9
DDR_M0_D48: UC1.G31 UD41.R9
DDR_M0_D49: UC1.G32 UD41.T9
DDR_M0_D50: UC1.H29 UD41.R11
DDR_M0_D51: UC1.H28 UD41.R10
DDR_M0_D52: UC1.G28 UD41.R8
DDR_M0_D53: UC1.G29 UD41.T8
DDR_M0_D54: UC1.H31 UD41.T10
DDR_M0_D55: UC1.H32 UD41.T11
DDR_M0_D56: UC1.L31 UD41.N10
DDR_M0_D57: UC1.L32 UD41.M10
DDR_M0_D58: UC1.N29 UD41.M8
DDR_M0_D59: UC1.N28 UD41.N9
DDR_M0_D60: UC1.L28 UD41.N11
DDR_M0_D61: UC1.L29 UD41.M11
DDR_M0_D62: UC1.N31 UD41.M9
DDR_M0_D63: UC1.N32 UD41.P9
DDR_M0_DQS0: UC1.D27 UD42.G10
DDR_M0_DQS1: UC1.C31 UD42.D10
DDR_M0_DQS2: UC1.G24 UD42.L10
DDR_M0_DQS3: UC1.D23 UD42.P10
DDR_M0_DQS4: UC1.J34 UD41.G10
DDR_M0_DQS5: UC1.P35 UD41.D10
DDR_M0_DQS6: UC1.H30 UD41.P10
DDR_M0_DQS7: UC1.N30 UD41.L10
DDR_M0_DQS#0: UC1.C27 UD42.G11
DDR_M0_DQS#1: UC1.D31 UD42.D11
DDR_M0_DQS#2: UC1.H24 UD42.L11
DDR_M0_DQS#3: UC1.C23 UD42.P11
DDR_M0_DQS#4: UC1.J35 UD41.G11
DDR_M0_DQS#5: UC1.P34 UD41.D11
DDR_M0_DQS#6: UC1.G30 UD41.P11
DDR_M0_DQS#7: UC1.L30 UD41.L11
DDR_M0_ODT0: RD73.1 UC1.AE31 UD41.J8 UD42.J8
DDR_M1_CAA_0: RD83.1 UC1.AF35 UD44.R2
DDR_M1_CAA_1: RD85.1 UC1.AB29 UD44.P2
DDR_M1_CAA_2: RD71.1 UC1.AE37 UD44.N2
DDR_M1_CAA_3: RD74.1 UC1.AE36 UD44.N3
DDR_M1_CAA_4: RD30.1 UC1.AC29 UD44.M3
DDR_M1_CAA_5: RD32.1 UC1.W29 UD44.F3
DDR_M1_CAA_6: RD34.1 UC1.AB28 UD44.E3
DDR_M1_CAA_7: RD36.1 UC1.AC28 UD44.E2
DDR_M1_CAA_8: RD38.1 UC1.W28 UD44.D2
DDR_M1_CAA_9: RD40.1 UC1.Y28 UD44.C2
DDR_M1_CAB_0: RD42.1 UC1.AK35 UD43.R2
DDR_M1_CAB_1: RD44.1 UC1.AK34 UD43.P2
DDR_M1_CAB_2: RD46.1 UC1.AJ35 UD43.N2
DDR_M1_CAB_3: RD48.1 UC1.AJ34 UD43.N3
DDR_M1_CAB_4: RD50.1 UC1.AJ37 UD43.M3
DDR_M1_CAB_5: RD52.1 UC1.AF34 UD43.F3
DDR_M1_CAB_6: RD54.1 UC1.AJ36 UD43.E3
DDR_M1_CAB_7: RD56.1 UC1.AG34 UD43.E2
DDR_M1_CAB_8: RD58.1 UC1.AG35 UD43.D2
DDR_M1_CAB_9: RD60.1 UC1.AG36 UD43.C2
DDR_M1_CKE0: RD66.1 UC1.T28 UD44.K3
DDR_M1_CKE1: RD68.1 UC1.T29 UD44.K4
DDR_M1_CKE2: RD70.1 UC1.V28 UD43.K3
DDR_M1_CKE3: RD72.1 UC1.V29 UD43.K4
DDR_M1_CLK0: RD76.1 UC1.AF29 UD44.J3
DDR_M1_CLK1: RD86.1 UC1.AE29 UD43.J3
DDR_M1_CLK#0: RD90.1 UC1.AF28 UD44.J2
DDR_M1_CLK#1: RD82.1 UC1.AE28 UD43.J2
DDR_M1_CS#0: RD62.1 UC1.AL37 UD43.L3 UD44.L3
DDR_M1_CS#1: RD87.1 UC1.AL35 UD43.L4 UD44.L4
DDR_M1_D0: UC1.AN35 UD44.D9
DDR_M1_D1: UC1.AN34 UD44.F8
DDR_M1_D2: UC1.AR35 UD44.E11
DDR_M1_D3: UC1.AR34 UD44.E10
DDR_M1_D4: UC1.AN37 UD44.F9
DDR_M1_D5: UC1.AN36 UD44.E9
DDR_M1_D6: UC1.AR36 UD44.F10
DDR_M1_D7: UC1.AR37 UD44.F11
DDR_M1_D8: UC1.AU35 UD44.B10
DDR_M1_D9: UC1.AU34 UD44.B11
DDR_M1_D10: UC1.AW35 UD44.B8
DDR_M1_D11: UC1.AW34 UD44.C8
DDR_M1_D12: UC1.AU37 UD44.C11
DDR_M1_D13: UC1.AU36 UD44.C10
DDR_M1_D14: UC1.AW36 UD44.C9
DDR_M1_D15: UC1.AW37 UD44.B9
DDR_M1_D16: UC1.AJ29 UD44.R8
DDR_M1_D17: UC1.AJ30 UD44.T8
DDR_M1_D18: UC1.AM32 UD44.T10
DDR_M1_D19: UC1.AM31 UD44.T11
DDR_M1_D20: UC1.AM30 UD44.R11
DDR_M1_D21: UC1.AM29 UD44.R10
DDR_M1_D22: UC1.AJ31 UD44.T9
DDR_M1_D23: UC1.AJ32 UD44.R9
DDR_M1_D24: UC1.AR31 UD44.M10
DDR_M1_D25: UC1.AR32 UD44.N10
DDR_M1_D26: UC1.AV30 UD44.M8
DDR_M1_D27: UC1.AV29 UD44.N9
DDR_M1_D28: UC1.AR30 UD44.M11
DDR_M1_D29: UC1.AR29 UD44.N11
DDR_M1_D30: UC1.AV32 UD44.M9
DDR_M1_D31: UC1.AV31 UD44.P9
DDR_M1_D32: UC1.BA35 UD43.F9
DDR_M1_D33: UC1.BA34 UD43.D9
DDR_M1_D34: UC1.BC35 UD43.E11
DDR_M1_D35: UC1.BC34 UD43.E10
DDR_M1_D36: UC1.BA37 UD43.E9
DDR_M1_D37: UC1.BA36 UD43.F8
DDR_M1_D38: UC1.BC36 UD43.F10
DDR_M1_D39: UC1.BC37 UD43.F11
DDR_M1_D40: UC1.BE35 UD43.B10
DDR_M1_D41: UC1.BE34 UD43.B11
DDR_M1_D42: UC1.BG35 UD43.B8
DDR_M1_D43: UC1.BG34 UD43.C8
DDR_M1_D44: UC1.BE37 UD43.C11
DDR_M1_D45: UC1.BE36 UD43.C10
DDR_M1_D46: UC1.BG36 UD43.C9
DDR_M1_D47: UC1.BG37 UD43.B9
DDR_M1_D48: UC1.BA32 UD43.R9
DDR_M1_D49: UC1.BA31 UD43.T9
DDR_M1_D50: UC1.BD31 UD43.T10
DDR_M1_D51: UC1.BD32 UD43.T11
DDR_M1_D52: UC1.BA30 UD43.T8
DDR_M1_D53: UC1.BA29 UD43.R8
DDR_M1_D54: UC1.BD29 UD43.R10
DDR_M1_D55: UC1.BD30 UD43.R11
DDR_M1_D56: UC1.BG31 UD43.M10
DDR_M1_D57: UC1.BG32 UD43.N10
DDR_M1_D58: UC1.BK32 UD43.M9
DDR_M1_D59: UC1.BK31 UD43.P9
DDR_M1_D60: UC1.BG29 UD43.N11
DDR_M1_D61: UC1.BG30 UD43.M11
DDR_M1_D62: UC1.BK30 UD43.M8
DDR_M1_D63: UC1.BK29 UD43.N9
DDR_M1_DQS0: UC1.AP34 UD44.G10
DDR_M1_DQS1: UC1.AV35 UD44.D10
DDR_M1_DQS2: UC1.AL30 UD44.P10
DDR_M1_DQS3: UC1.AU30 UD44.L10
DDR_M1_DQS4: UC1.BB34 UD43.G10
DDR_M1_DQS5: UC1.BF35 UD43.D10
DDR_M1_DQS6: UC1.BC30 UD43.P10
DDR_M1_DQS7: UC1.BH30 UD43.L10
DDR_M1_DQS#0: UC1.AP35 UD44.G11
DDR_M1_DQS#1: UC1.AV34 UD44.D11
DDR_M1_DQS#2: UC1.AL31 UD44.P11
DDR_M1_DQS#3: UC1.AU31 UD44.L11
DDR_M1_DQS#4: UC1.BB35 UD43.G11
DDR_M1_DQS#5: UC1.BF34 UD43.D11
DDR_M1_DQS#6: UC1.BC31 UD43.P11
DDR_M1_DQS#7: UC1.BH31 UD43.L11
DDR_M1_ODT0: RD89.1 UC1.AL36 UD43.J8 UD44.J8
DDR_VTT_CNTL: RC523.1 UC1.C35 UC2.2
DEBUG_TX: JDEG1.9 RE524.1 RE525.2
DG_GPIO8: RT503.1 RT553.1 UT1.W6
DG_PA_USB2_MXCTL: RT508.1 UT1.R2
DG_PB_USB2_MXCTL: RT509.1 UT1.R1
DGPU_HOLD_RST#: RC107.1 UC1.CR22 UV12.2
DGPU_MAIN_EN: DV4.2 DV5.1 DV11.2 QV144.2 RV90.1 RV103.1 RV105.1 UV1.F9 UV2.3
DGPU_MAIN_EN#: QV144.5 QV144.6 RV5002.2
DGPU_PSI: PRV48.1 RV91.1 UV1.A4
DGPU_PWR_EN: RC114.2 UC1.CM24 UV10.2 UV25.2
DGPU_PWR_EN#_R: QV151.5 QV151.6 RV5006.2
DGPU_PWR_EN_R: QV151.2 UV2.5 UV25.4
DGPU_PWROK: RC68.2 UC1.CJ25 UE1.A24 UV11.4
DGPU_VID: PRV46.1 UV1.C6
DISP_ON: D463.1 D464.1 JEDP1.17 R76.1
DMIC_CLK0: CC80.1 L16.1 R273.2
DMIC_CLK0_L: L16.2 UC1.CP24
DMIC_CLK_CODEC: JIO1.26 R271.2
DMIC_CLK_EDP: ED4.3 JEDP1.14 R271.1 R273.1
DMIC_DATA0: CC79.1 R272.2 UC1.CN24
DMIC_DATA_CODEC: JIO1.25 R270.2
DMIC_DATA_EDP: ED4.2 JEDP1.13 R270.1 R272.1
DRAM_RESET#: RC576.2 UC1.BU31
DTH_CSCL: RM11.2 RM14.1 UM1.48
DTH_CSDA: RM12.2 RM15.1 UM1.47
DTH_PDB: CM51.1 RM5.2 RM16.1 UM1.11
DTH_SPI_CK_OUT: RM27.1 RM30.2 UM1.23
DTH_SPI_CK_OUT_R: RM30.1 UM3.6
DTH_SPI_CS: RM26.1 UM1.21 UM3.1
DTH_SPI_D_IN: UM1.24 UM3.5
DTH_SPI_D_OUT: UM1.22 UM3.2
DTH_SPI_HOLD#: RM23.1 UM3.7
DTH_SPI_WR_PROT: RM28.1 UM1.25 UM3.3
DTH_XTI: CM29.1 UM1.15 YM1.1
DTH_XTO: RM61.1 UM1.16
DTH_XTO_R: CM30.1 RM61.2 YM1.3
EC_D_INHIB: CZ218.1 DZ12.2 QZ21.2 RE513.2 RZ22.2 RZ1413.1
EC_D_INHIBIT: RE513.1 UE1.A5
EC_MUTE#: JIO1.4 RE29.2
EC_RESET#: RE545.2 UE1.B63 UE5.2
EDP_AUXN: C17.1 UC1.AH4
EDP_AUXN_C: C17.2 JEDP1.33
EDP_AUXP: C19.1 UC1.AH3
EDP_AUXP_C: C19.2 JEDP1.34
EDP_BKLT_CTRL: D2.2 UC1.CH11
EDP_COMP: RC4.2 UC1.AM6
EDP_HPD: RE543.1 UE1.A47
EDP_HPD_R: JEDP1.24 R77.1 RE543.2 UC1.CM7
EDP_TXN0: C12.1 UC1.AG4
EDP_TXN0_C: C12.2 JEDP1.37
EDP_TXN1: C14.1 UC1.AG2
EDP_TXN1_C: C14.2 JEDP1.40
EDP_TXP0: C13.1 UC1.AG3
EDP_TXP0_C: C13.2 JEDP1.36
EDP_TXP1: C15.1 UC1.AG1
EDP_TXP1_C: C15.2 JEDP1.39
EDP_VDD_EN: D4.2 UC1.CG11
EMMC_RCOMP: RC64.1 UC1.CK15
EN_0.6V: PCM22.1 PRM17.2 PRM23.1 PUM01.16
EN_1.0V: PCF03.1 PRF02.1 PUF01.5
EN_1.2V: PCM28.1 PRM15.1 PRM22.2 PUM01.15
EN_1.05V_PRIM: PCH14.1 PRH08.2 PUH01.15
EN_1.8V_PRIM: PC1813.1 PR1809.1 PR1810.1 PR1813.1 PU1801.11
EN_3V: PR521.1 PU301.9
EN_5V: JIO1.12 PR522.1 PU501.15
EN_+1.35VGPU: PCW12.1 PRW19.1 PRW22.1 PUW01.11
EN_CPU: PCZ01.2 PRZ05.2 PRZ06.1 PUZ01.37
EN_GPU: PRV03.2 PRV51.2 PUV01.2
EN_R: PC532.1 PQ501.1 PR521.2 PR522.2 PR523.2 PR525.1
EN_VCCIO: CZ11.1 DZ6.2 RZ3.2 UC18.2
ENLDO_3V5V: PR302.1 PR303.1 PU301.8
EQ0: RM40.2 RM41.1 UM1.5
EQ1: RM42.2 RM43.1 UM1.8
ESPI_CLK: CC3.1 JESPI1.10 RC26.1 UE1.B18
ESPI_CLK_R: RC26.2 UC1.BV32
ESPI_CS#: JESPI1.7 UC1.CA28 UE1.B17
ESPI_IO0: JESPI1.3 RC192.2 UE1.A17
ESPI_IO0_R: RC192.1 UC1.CA29
ESPI_IO1: JESPI1.4 RC193.2 UE1.A18
ESPI_IO1_R: RC193.1 UC1.BY29
ESPI_IO2: JESPI1.5 RC194.2 UE1.B20
ESPI_IO2_R: RC194.1 UC1.BY27
ESPI_IO3: JESPI1.6 RC195.2 UE1.A19
ESPI_IO3_R: RC195.1 UC1.BV27
ESPI_RESET#: RC205.2 RE535.2 UC1.CA27 UE1.B16
FB_1.2V: PCM32.2 PRM21.1 PRM25.2 PUM01.13
FB_1.05V: PRH05.2 PRH06.1 PRH09.1 PUH01.13
FB_1.8V: PR1805.2 PR1806.2 PR1807.1 PU1801.10
FB_3V: PC315.1 PR307.2 PR308.1 PU301.10
FB_3V_R: PC315.2 PR306.1
FB_5V: PR507.2 PR508.2 PR509.1 PU501.13
FB_+1.35VGPU: PCW24.2 PRW13.2 PRW16.1 PUW01.14
FB_+1.35VGPU_R: PCW24.1 PRW21.2
FB_A_CLK0: RV1.1 UV1.D24 UV6.J12
FB_A_CLK0_R: CV4.1 RV1.2 RV2.1
FB_A_CLK1: RV3.1 UV1.N22 UV8.J12
FB_A_CLK1_R: CV5.1 RV3.2 RV4.1
FB_A_CLK#0: RV2.2 UV1.D25 UV6.J11
FB_A_CLK#1: RV4.2 UV1.M22 UV8.J11
FB_A_CMD0: UV1.C27 UV6.G12
FB_A_CMD1: UV1.C26 UV6.H10
FB_A_CMD2: UV1.E24 UV6.H11
FB_A_CMD3: UV1.F24 UV6.K11
FB_A_CMD4: UV1.D27 UV6.K10
FB_A_CMD5: UV1.D26 UV6.L12
FB_A_CMD6: UV1.F25 UV6.K4
FB_A_CMD7: UV1.F26 UV6.K5
FB_A_CMD8: UV1.F23 UV6.J4
FB_A_CMD9: UV1.G22 UV6.J5
FB_A_CMD10: UV1.G23 UV6.H4
FB_A_CMD11: UV1.G24 UV6.H5
FB_A_CMD12: UV1.F27 UV6.G3
FB_A_CMD13: RV2437.1 UV1.G25 UV6.J2
FB_A_CMD14: RV2439.1 UV1.G27 UV6.J3
FB_A_CMD15: UV1.G26 UV6.L3
FB_A_CMD16: UV1.M24 UV8.L12
FB_A_CMD17: UV1.M23 UV8.K10
FB_A_CMD18: UV1.K24 UV8.K11
FB_A_CMD19: UV1.K23 UV8.H11
FB_A_CMD20: UV1.M27 UV8.H10
FB_A_CMD21: UV1.M26 UV8.G12
FB_A_CMD22: UV1.M25 UV8.H4
FB_A_CMD23: UV1.K26 UV8.H5
FB_A_CMD24: UV1.K22 UV8.J4
FB_A_CMD25: UV1.J23 UV8.J5
FB_A_CMD26: UV1.J25 UV8.K4
FB_A_CMD27: UV1.J24 UV8.K5
FB_A_CMD28: UV1.K27 UV8.L3
FB_A_CMD29: RV2438.1 UV1.K25 UV8.J2
FB_A_CMD30: RV2440.1 UV1.J27 UV8.J3
FB_A_CMD31: UV1.J26 UV8.G3
FB_A_D0: UV1.E18 UV6.A4
FB_A_D1: UV1.F18 UV6.A2
FB_A_D2: UV1.E16 UV6.B4
FB_A_D3: UV1.F17 UV6.B2
FB_A_D4: UV1.D20 UV6.E4
FB_A_D5: UV1.D21 UV6.E2
FB_A_D6: UV1.F20 UV6.F4
FB_A_D7: UV1.E21 UV6.F2
FB_A_D8: UV1.E15 UV6.A11
FB_A_D9: UV1.D15 UV6.A13
FB_A_D10: UV1.F15 UV6.B11
FB_A_D11: UV1.F13 UV6.B13
FB_A_D12: UV1.C13 UV6.E11
FB_A_D13: UV1.B13 UV6.E13
FB_A_D14: UV1.E13 UV6.F11
FB_A_D15: UV1.D13 UV6.F13
FB_A_D16: UV1.B15 UV6.U11
FB_A_D17: UV1.C16 UV6.U13
FB_A_D18: UV1.A13 UV6.T11
FB_A_D19: UV1.A15 UV6.T13
FB_A_D20: UV1.B18 UV6.N11
FB_A_D21: UV1.A18 UV6.N13
FB_A_D22: UV1.A19 UV6.M11
FB_A_D23: UV1.C19 UV6.M13
FB_A_D24: UV1.B24 UV6.U4
FB_A_D25: UV1.C23 UV6.U2
FB_A_D26: UV1.A25 UV6.T4
FB_A_D27: UV1.A24 UV6.T2
FB_A_D28: UV1.A21 UV6.N4
FB_A_D29: UV1.B21 UV6.N2
FB_A_D30: UV1.C20 UV6.M4
FB_A_D31: UV1.C21 UV6.M2
FB_A_D32: UV1.R22 UV8.U4
FB_A_D33: UV1.R24 UV8.U2
FB_A_D34: UV1.T22 UV8.T4
FB_A_D35: UV1.R23 UV8.T2
FB_A_D36: UV1.N25 UV8.N4
FB_A_D37: UV1.N26 UV8.N2
FB_A_D38: UV1.N23 UV8.M4
FB_A_D39: UV1.N24 UV8.M2
FB_A_D40: UV1.V23 UV8.U11
FB_A_D41: UV1.V22 UV8.U13
FB_A_D42: UV1.T23 UV8.T11
FB_A_D43: UV1.U22 UV8.T13
FB_A_D44: UV1.Y24 UV8.N11
FB_A_D45: UV1.AA24 UV8.N13
FB_A_D46: UV1.Y22 UV8.M11
FB_A_D47: UV1.AA23 UV8.M13
FB_A_D48: UV1.AD27 UV8.A11
FB_A_D49: UV1.AB25 UV8.A13
FB_A_D50: UV1.AD26 UV8.B11
FB_A_D51: UV1.AC25 UV8.B13
FB_A_D52: UV1.AA27 UV8.E11
FB_A_D53: UV1.AA26 UV8.E13
FB_A_D54: UV1.W26 UV8.F11
FB_A_D55: UV1.Y25 UV8.F13
FB_A_D56: UV1.R26 UV8.A4
FB_A_D57: UV1.T25 UV8.A2
FB_A_D58: UV1.N27 UV8.B4
FB_A_D59: UV1.R27 UV8.B2
FB_A_D60: UV1.V26 UV8.E4
FB_A_D61: UV1.V27 UV8.E2
FB_A_D62: UV1.W27 UV8.F4
FB_A_D63: UV1.W25 UV8.F2
FB_A_DBI0: UV1.D19 UV6.D2
FB_A_DBI1: UV1.D14 UV6.D13
FB_A_DBI2: UV1.C17 UV6.P13
FB_A_DBI3: UV1.C22 UV6.P2
FB_A_DBI4: UV1.P24 UV8.P2
FB_A_DBI5: UV1.W24 UV8.P13
FB_A_DBI6: UV1.AA25 UV8.D13
FB_A_DBI7: UV1.U25 UV8.D2
FB_A_EDC0: UV1.E19 UV6.C2
FB_A_EDC1: UV1.C15 UV6.C13
FB_A_EDC2: UV1.B16 UV6.R13
FB_A_EDC3: UV1.B22 UV6.R2
FB_A_EDC4: UV1.R25 UV8.R2
FB_A_EDC5: UV1.W23 UV8.R13
FB_A_EDC6: UV1.AB26 UV8.C13
FB_A_EDC7: UV1.T26 UV8.C2
FB_A_MF: RV116.1 UV6.J1
FB_A_SEN: RV118.1 UV6.J10
FB_A_WCK0: UV1.D18 UV6.D4
FB_A_WCK1: UV1.D17 UV6.P4
FB_A_WCK2: UV1.T24 UV8.P4
FB_A_WCK3: UV1.V24 UV8.D4
FB_A_WCK#0: UV1.C18 UV6.D5
FB_A_WCK#1: UV1.D16 UV6.P5
FB_A_WCK#2: UV1.U24 UV8.P5
FB_A_WCK#3: UV1.V25 UV8.D5
FB_A_ZQ: RV120.1 UV6.J13
FB_B_MF: RV2453.1 UV8.J1
FB_B_SEN: RV2448.1 UV8.J10
FB_B_ZQ: RV2451.1 UV8.J13
FB_CAL_PD_VDDQ: RV41.1 UV1.D22
FB_CAL_PU_GND: RV42.2 UV1.C24
FB_CALTERM_GND: RV43.2 UV1.B25
FB_GPU: PRV44.1 PUV01.10
FB_VREF: T4988.1(TP-1) UV1.D23
FBRTN_GPU: PRV47.1 PUV01.9
FPR_SCAN#: Q27.1 R5.2 UE1.B28
FPR_SCAN#_CONN: ED11.5 ED11.6 JFP1.2 Q27.3 R6.2
GC6_FB_EN1V8: QV8.2 RV88.1 UV1.B2
GC6_FB_EN3V3: QV8.3 QV150.2 RV113.2 UC1.CA31 UV23.2
GC6_FB_EN3V3_Q: QV8.5 QV8.6 RV111.2
GPIO5: RM51.2 RM60.2 UM1.44
GPIO_0: RT505.1 UT1.W1
GPIO_1: RT506.1 UT1.W2
GPIO_3: RT507.1 UT1.Y1
GPP_B22: RC115.2 UC1.CA30
GPP_B23: RC46.1 UC1.CC34
GPP_C2: RC38.1 UC1.CJ15
GPP_C5: RC44.1 UC1.CG15
GPP_D12: RC567.2 RC568.2 UC1.CP22
GPP_H21: RC62.1 UC1.CF25
GPP_H23: RC65.1 UC1.CM26
GPS_DISABLE#: QN8.6 RC566.1 UC1.CG22
GPS_DISABLE#_R: JNGFF1.26 QN8.1
GPU_B+: PCV01.1 PCV02.1 PCV03.1 PCV04.1 PCV8.1 PCV9.1 PCV10.1 PCV11.1 PCV34.1 PCV37.1 PCV38.1 PLV03.2 PLV04.2 PRV34.2 PUV02.1 PUV02.8 PUV03.1 PUV03.8
GPU_CORE_PG: PRV43.2 PUV01.1 QV150.4 RV4997.2 UV11.1
GPU_EVENT#: DV3.1 UC1.CN12
GPU_EVENT#_D: DV3.2 RV72.1 UV1.D6
GPU_JTAG_TCK: T4986.1(TP-1) UV1.AE5
GPU_JTAG_TDI: T4985.1(TP-1) UV1.AE6
GPU_JTAG_TDO: T4987.1(TP-1) UV1.AF6
GPU_JTAG_TMS: T4984.1(TP-1) UV1.AD6
GPU_JTAG_TRST#: RV94.1 UV1.AG4
GPU_PWR_LEVEL: DV10.1 UE1.A53
GPU_PWR_LEVEL_R: DV10.2 RV92.1 UV1.D7
GPU_TESTMODE: RV71.1 UV1.AD9
GPU_THM_SMBCLK: Q11.3 Q28.6 QV2.3 RC196.1 UC1.CN15 UE1.B62
GPU_THM_SMBDAT: Q11.6 Q28.3 QV2.6 RC197.1 UC1.CM15 UE1.A59
H_CPUPWRGD: CC74.2 UC1.AR2
H_PROCHOT#: CE24.1 PQ1402.1 PR102.2 PRB19.2 PRM19.1 PRZ26.2 RC1.2 RC160.1 RE547.1 UE2.4
H_PROCHOT#_R: CC120.1 RC160.2 UC1.Y4
H_THERMTRIP#: RC2.2 UC1.BJ1
HDA_BIT_CLK: RC48.2 UC1.BN37
HDA_BIT_CLK_R: CC6.1 JIO1.28 RC48.1
HDA_SDIN0: JIO1.14 UC1.BN35
HDA_SDOUT: RC49.2 RC50.2 RC51.2 UC1.BN36
HDA_SDOUT_R: CC78.1 JIO1.13 RC49.1
HDA_SYNC: RC47.2 UC1.BN34
HDA_SYNC_R: CC77.1 JIO1.15 RC47.1
HDMI_CEC: CV930.2 JHDMI1.13 RM6.2
HDMI_CEC_R: RM6.1 UM1.1
HDMI_HPD: CV599.2 JHDMI1.19 RM5.1 RM17.2 UM1.32
HDMI_RESERVED: CV600.2 JHDMI1.14
HOST_DEBUG_TX: JDEG1.8 RE51.2 RE529.2 UE1.B42
HRESET_PD: RPD88.1 UPD1.44
HW_ACAV_IN: CE32.2 DV1.1 DZ12.1 PRB41.2 UE1.A61
I2C1_PD_L_CLK: JDB2.7 RPD163.1 UPD1.27
I2C1_PD_L_DAT: JDB2.8 RPD164.1 UPD1.28
I2C1_PD_L_INT#: RPD17.1 UPD1.29
I2C2_PD_L_CLK: JDB2.9 RPD21.1 UPD1.32
I2C2_PD_L_DAT: JDB2.10 RPD22.1 UPD1.33
I2C2_PD_L_INT#: RPD112.1 UPD1.34
I2C_0_SCL: ED12.5 ED12.6 JCAM1.9 R87.2 UC1.CN11
I2C_0_SDA: ED12.4 ED12.7 JCAM1.10 R86.2 UC1.CM11
I2C_1_SCL: Q10.1 R37.2 UC1.CJ12
I2C_1_SCL_R: C6908.1 ED10.3 JTP1.6 Q10.6 R33.1 R43.2
I2C_1_SDA: Q10.4 R36.2 UC1.CK12
I2C_1_SDA_R: C6907.1 ED10.2 JTP1.7 Q10.3 R32.1 R45.2
I2C_ADDR: RM50.2 UM1.45
I2CB_SCL: RV208.1 UV1.C9
I2CB_SDA: RV207.1 UV1.C8
I2CC_SCL: RV205.1 UV1.A9
I2CC_SDA: RV206.1 UV1.B9
I2CS_SCL: QV2.4 RV203.1 UV1.D9
I2CS_SDA: QV2.1 RV204.1 UV1.D8
I_ADP: CE26.1 RE46.1 UE1.B12
I_ADP_R: PRB35.2 RE46.2
I_BATT: CE31.1 RE47.1 UE1.A11
I_BATT_R: PRB34.2 RE47.2
I_SYS: PRB31.2 PRZ17.2
IA_B+: PCI01.1 PCI02.1 PCI04.1 PCI05.1 PCI06.1 PCI07.1 PCI08.1 PCI13.1 PCI14.1 PCI16.1 PCI17.1 PCI18.1 PCI19.1 PCI20.1 PCI25.1 PCI28.1 PCI29.1 PCI30.1 PCI31.1 PCI32.1 PCI39.1 PCI41.1 PCI42.1 PLI11.2 PLI12.2 PLI13.2 PRZ55.1 PUI01.1 PUI01.8 PUI02.1 PUI02.8 PUI03.1 PUI03.8
ILMT_1.05V: PRH01.2 PRH02.1 PUH01.18
IMONA_CPU: PCZ04.2 PRZ30.2 PUZ01.21
IMONB_CPU: PCZ05.2 PRZ31.2 PUZ01.22
IMONC_CPU: PCZ06.2 PRZ32.2 PUZ01.23
IMVP_VR_EN: R241.1 RE532.2 U10.1
IMVP_VR_ON: RE532.1 UE1.B1
IMVP_VR_ON_EN: PRZ06.2 R241.2 R242.1 U7.2 U10.4
IMVP_VR_PG: PRZ10.2 RC390.1 RC433.2 UC10.1
INPUT3VSEL: RC103.1 RC104.1 UC1.BT27
INT_TP#: JTP1.4 Q8.3 R42.2
INTRUDER#: RC87.2 UC1.BR35
INV_PWR_SRC: C1224.2 F4.1 R4931.2 U711.9
INV_PWR_SRC_C: C1224.1 U711.1
INV_PWR_SRC_R: R4931.1 U711.8
IREF_CPU: PRZ20.2 PUZ01.24
ISEN1: PRV25.1 PRV39.1 PUV01.16
ISEN2: PRV31.1 PRV35.1 PUV01.15
ISH_ACC1_INT#: JEDP1.27 RC550.1 UC1.BW35 US2.12
ISH_ALS_INT#: JCAM1.2 RC518.1 UC1.CA36
ISH_I2C_0_SCL: JEDP1.10 R91.1 RC208.1 UC1.CH20 US2.1
ISH_I2C_0_SCL_R: JEDP1.21 R91.2
ISH_I2C_0_SDA: JEDP1.11 JEDP1.28 RC207.1 UC1.CK22 US2.4
ISH_I2C_1_SCL: RS11.2 UC1.CJ22
ISH_I2C_1_SDA: RS12.2 UC1.CH22
ISH_P_SENSOR_INT#: JCAM1.3 RC516.1 UC1.BW34
JTAG_CLK: JDEG1.4 RE92.1 UE1.B59
JTAG_RST#: CE505.1 CLEC1.1 RE526.2 RE527.1 UE1.A40
JTAG_TDI: JDEG1.2 RE90.1 UE1.B58
JTAG_TDO: JDEG1.5 RE93.1 UE1.A55
JTAG_TMS: JDEG1.3 RE91.1 UE1.A56
KB_BL_CTRL#: C105.1 JKBBL1.4 Q7.1
KB_DET#: C104.2 JKB1.30 RC110.1 UC1.CK25
KB_LED_BL_DET: R38.1 R40.1 UC1.CM18
KB_LED_DET_C: JKBBL1.2 R38.2
KB_LED_PWM: Q7.2 UE1.B29
KSI0: JKB1.22 RE66.2 UE1.B32
KSI1: JKB1.24 RE67.2 UE1.A29
KSI2: JKB1.26 RE68.2 UE1.B31
KSI3: JKB1.23 RE69.2 UE1.B34
KSI4: JKB1.27 RE73.2 UE1.B35
KSI5: JKB1.25 RE72.2 UE1.A33
KSI6: JKB1.28 RE71.2 UE1.A32
KSI7: JKB1.29 RE70.2 UE1.B33
KSO00: JKB1.13 RE74.2 UE1.A31
KSO01: JKB1.15 RE75.2 UE1.B57
KSO02: JKB1.14 RE76.2 UE1.B44
KSO03: JKB1.16 RE77.2 UE1.A42
KSO04: JKB1.20 RE78.2 UE1.B36
KSO05: JKB1.21 RE79.2 UE1.B37
KSO06: JKB1.18 RE80.2 UE1.A35
KSO07: JKB1.19 RE81.2 UE1.A34
KSO08: JKB1.17 RE86.2 UE1.B45
KSO09: JKB1.7 RE18.2 UE1.A43
KSO10: JKB1.5 RE82.2 UE1.B46
KSO11: JKB1.6 RE83.2 UE1.B10
KSO12: JKB1.12 RE84.2 UE1.B47
KSO13: JKB1.9 RE85.2 UE1.A44
KSO14: JKB1.8 RE88.2 UE1.A9
KSO15: JKB1.10 RE87.2 UE1.A30
KSO16: JKB1.11 RE89.2 UE1.A49
LANWAKE#: RC93.2 UC1.BU32
LCD_CBL_DET#: JEDP1.32 R90.2 UC1.CF12
LCD_TST: JEDP1.26 UE1.A26
LCD_VCC_TEST_EN: D4.3 UE1.A3
LCDVDD_EN: D4.1 R17.1 U1.4
LCDVDD_MONITOR: QV21.2 RV630.2
LCDVDD_MONITOR_R: QV18.3 RV630.1
LDO_+1.35VGPU: PCW22.1 PUW01.16 PUW01.17
LG1_CHG: PQB01.6 PUB01.9
LG2_CHG: PQB02.6 PUB01.7
LID_CL_SIO#: CE16.1 D462.2 RE28.2 UE1.A36
LID_CLOSE#: CE34.1 EC2.1 R25.2 RE161.1 UE3.3
LID_POWER_ON#: Q19.1 RE31.1 UE1.A63
LID_POWER_ON#_G: Q19.2 RE98.2 U34.5
LX1_CHG: PCB25.2 PLB01.1 PQB01.7 PRB17.1 PUB01.10
LX2_CHG: PLB01.2 PQB02.7 PRB15.2 PRB18.1 PUB01.6
LX_1.2V: PCM27.2 PLM13.1 PRM24.1 PUM01.9
LX_1.05V: PCH10.2 PLH01.1 PRH04.1 PUH01.6 PUH01.7
LX_1.8V: PC1810.2 PL1801.1 PR1804.1 PR1808.1 PU1801.6
LX_3V: PC307.2 PL301.1 PR305.1 PU301.5 PU301.15 PU301.16
LX_5V: PC514.2 PL501.1 PR506.1 PR510.1 PU501.9
LX_+1.35VGPU: PCW18.2 PLW12.1 PRW12.1 PUW01.6 PUW01.19 PUW01.20
LX_GPU1: PCV13.2 PLV01.1 PRV24.1 PUV02.2 PUV02.3 PUV02.4
LX_GPU2: PCV39.2 PLV02.1 PRV30.1 PUV03.2 PUV03.3 PUV03.4
LX_GT: PCG08.2 PLG01.1 PRG02.1 PUG01.2 PUG01.3 PUG01.4
LX_IA1: PCI11.2 PLI01.1 PLI01.2 PRI02.1 PUI01.2 PUI01.3 PUI01.4
LX_IA2: PCI23.2 PLI02.1 PLI02.2 PRI04.1 PUI02.2 PUI02.3 PUI02.4
LX_IA3: PCI35.2 PLI03.1 PLI03.2 PRI06.1 PUI03.2 PUI03.3 PUI03.4
LX_SA: PCA09.2 PLA01.1 PRA02.1 PUA01.2 PUA01.3 PUA01.4
M2_SSD_PEDET: JSSD1.69 RS1.2 UC1.CM10
MASK_SATA_LED#: Q3.2 R26.2 RC158.1 UE1.B21
MCARD_WWAN_PWREN: RZ1420.1 UE1.A10
MCARD_WWAN_PWREN_R: CZ237.1 RZ36.1 RZ1420.2 UZ9.3
ME_FWP: RC50.1 UE1.A4
MEM_CONFIG0: RC215.2 RC216.1 UC1.CR20
MEM_CONFIG1: RC217.2 RC218.1 UC1.CM20
MEM_CONFIG2: RC219.2 RC220.1 UC1.CN19
MEM_CONFIG3: RC221.2 RC222.1 UC1.CM19
MEM_CONFIG4: RC223.2 RC224.1 UC1.CN18
MEM_SMBCLK: QC1.6 RC198.1 RC388.1 UC1.CK14
MEM_SMBDATA: QC1.3 RC199.1 RC387.1 UC1.CH15
MEM_VREF: QV50.2 RV102.1 UV1.C5
MODE1_5V: PR505.1 PU501.14
MODE2_5V: PR502.2 PU501.16
MODE_1.2V: PRM18.1 PUM01.14
MODEL_ID: CE10.1 RE3.2 RE4.2 UE1.A12
MSCLK: JDEG1.6 RE49.1 RE525.1 UE1.B43
MSDATA: JDEG1.7 RE50.1 RE57.1 UE1.A41
MUX_L_ENA_R: RM36.2 UM4.16
MUX_L_ENB_R: RM32.2 UM4.10
MUX_L_FLIP#: RM33.1 RM35.1 RPD127.1 RPD128.1 RPD129.1
MUX_L_FLIP#_R: RPD127.2 UPD1.41
MUX_L_SAI: RM33.2 UM4.14
MUX_L_SBI: RM35.2 UM4.12
NB_LID#: D3.1 D462.1 EU6.2 JFP1.3 R25.1 U34.2
NB_MUTE#: RE29.1 UE1.A1
NCT7718_DXN: C29.2 C30.2 Q13.3 U3.3
NCT7718_DXP: C29.1 C30.1 Q13.1 Q13.2 U3.2
NGFF_CONFIG_0: JNGFF1.21 RE478.1 RE549.2
NGFF_CONFIG_1: JNGFF1.69 RE479.1 UE1.A60
NRB_BIT: RC112.2 UC1.CE29
NRESET_IN: RE511.1 RE544.2 UE1.B2 UE5.4
NV_GPIO9: RV93.1 UV1.F8
NV_GPIO16: RV4991.1 UV1.D5
OSC_CLK: RE554.2 XE1.3
OTGEN/CMIN_CHG: PRB10.1 PRB13.1 PUB01.20
OVERT#: RV69.1 RV76.1 UV1.A6
P_SENSOR_PWR_SAVE#: JCAM1.4 RC517.2 UC1.CP12
PANEL_BKEN_EC: D463.3 UE1.B40
PANEL_MONITOR: QV19.1 QV21.1 RV623.2 RV624.1 UE1.B6
PBAT_CHARGER_SMBCLK: PD5.3 PR42.2 PRB16.2 RE9.1 UE1.B27
PBAT_CHARGER_SMBDAT: PD5.2 PR37.2 PRB14.2 RE8.1 UE1.A25
PBAT_PRES#: CE18.1 PC1816.1 PD6.2 PR39.2 PR41.1 PRB25.2 UE1.A45
PCH_BATLOW#: RC96.1 UC1.BV36
PCH_JTAG_TCK: RC258.2 UC1.W6
PCH_PCIE_WAKE#: RC92.2 RC102.2 UC1.BU30
PCH_PLTRST#: UC1.BJ35 UC4.1 UC4.2
PCH_POPIRCOMP: RC16.1 UC1.BW25
PCH_PWROK: RC381.1 RC390.2 UC1.BP31 UC10.4
PCH_RSMRST#: RE537.1 UE1.B38
PCH_RSMRST#_Q: RC75.2 UC1.BP30 UC1.BR36 UC5.4
PCH_RSMRST#_R: RE26.1 RE536.1 RE537.2 RZ1413.2 UC5.1
PCH_RTCRST#: CC8.1 CLRP2.1 JAPS1.9 RC82.2 UC1.BR34
PCH_RTCX1: CC11.1 RC95.1 UC1.BN31 YC2.1
PCH_RTCX2: CC12.1 RC95.2 UC1.BN32 YC2.2
PCH_SRTCRST#: CC7.1 RC77.2 UC1.BR37
PCH_SUSCLK: RE533.1 RE554.1 UE1.A62
PCH_TBT_PERST#: RC395.2 RC574.2 RT284.1 UC1.CR14
PCIE_CRX_C_DTX_N13: CT7.2 UT1.V22
PCIE_CRX_C_DTX_N14: CT9.2 UT1.P22
PCIE_CRX_C_DTX_N15: CT357.2 UT1.K22
PCIE_CRX_C_DTX_N16: CT358.2 UT1.F22
PCIE_CRX_C_DTX_P13: CT6.2 UT1.V23
PCIE_CRX_C_DTX_P14: CT8.2 UT1.P23
PCIE_CRX_C_DTX_P15: CT359.2 UT1.K23
PCIE_CRX_C_DTX_P16: CT360.2 UT1.F23
PCIE_CRX_DTX_N1: LN18.1 RN115.1 UC1.CB5
PCIE_CRX_DTX_N9: JSSD1.5 UC1.BP5
PCIE_CRX_DTX_N10: JSSD1.17 UC1.BN6
PCIE_CRX_DTX_N11: JSSD1.29 UC1.BN10
PCIE_CRX_DTX_N12: JSSD1.43 UC1.BL6
PCIE_CRX_DTX_N13: CT7.1 UC1.BK6
PCIE_CRX_DTX_N14: CT9.1 UC1.BJ6
PCIE_CRX_DTX_N15: CT357.1 UC1.BG5
PCIE_CRX_DTX_N16: CT358.1 UC1.BE5
PCIE_CRX_DTX_P1: LN18.4 RN116.1 UC1.CB6
PCIE_CRX_DTX_P9: JSSD1.7 UC1.BP6
PCIE_CRX_DTX_P10: JSSD1.19 UC1.BN5
PCIE_CRX_DTX_P11: JSSD1.31 UC1.BN8
PCIE_CRX_DTX_P12: JSSD1.41 UC1.BL5
PCIE_CRX_DTX_P13: CT6.1 UC1.BK5
PCIE_CRX_DTX_P14: CT8.1 UC1.BJ5
PCIE_CRX_DTX_P15: CT359.1 UC1.BG6
PCIE_CRX_DTX_P16: CT360.1 UC1.BE6
PCIE_CRX_L_DTX_N1: JNGFF1.41 LN18.2 RN115.2
PCIE_CRX_L_DTX_P1: JNGFF1.43 LN18.3 RN116.2
PCIE_CTX_C_DRX_N1: CN72.2 LN19.4 RN118.1
PCIE_CTX_C_DRX_N9: CS7.2 JSSD1.11
PCIE_CTX_C_DRX_N10: CS9.2 JSSD1.23
PCIE_CTX_C_DRX_N11: CS11.2 JSSD1.35
PCIE_CTX_C_DRX_N12: CS13.2 JSSD1.47
PCIE_CTX_C_DRX_N13: CT3.1 UT1.Y22
PCIE_CTX_C_DRX_N14: CT5.1 UT1.T22
PCIE_CTX_C_DRX_N15: CT353.1 UT1.M22
PCIE_CTX_C_DRX_N16: CT354.1 UT1.H22
PCIE_CTX_C_DRX_P1: CN73.2 LN19.1 RN117.1
PCIE_CTX_C_DRX_P9: CS8.2 JSSD1.13
PCIE_CTX_C_DRX_P10: CS10.2 JSSD1.25
PCIE_CTX_C_DRX_P11: CS12.2 JSSD1.37
PCIE_CTX_C_DRX_P12: CS14.2 JSSD1.49
PCIE_CTX_C_DRX_P13: CT2.1 UT1.Y23
PCIE_CTX_C_DRX_P14: CT4.1 UT1.T23
PCIE_CTX_C_DRX_P15: CT355.1 UT1.M23
PCIE_CTX_C_DRX_P16: CT356.1 UT1.H23
PCIE_CTX_DRX_N1: CN72.1 UC1.CA4
PCIE_CTX_DRX_N9: CS7.1 UC1.BR2
PCIE_CTX_DRX_N10: CS9.1 UC1.BR4
PCIE_CTX_DRX_N11: CS11.1 UC1.BN4
PCIE_CTX_DRX_N12: CS13.1 UC1.BN2
PCIE_CTX_DRX_N13: CT3.2 UC1.BM4
PCIE_CTX_DRX_N14: CT5.2 UC1.BL2
PCIE_CTX_DRX_N15: CT353.2 UC1.BL4
PCIE_CTX_DRX_N16: CT354.2 UC1.BJ4
PCIE_CTX_DRX_P1: CN73.1 UC1.CA3
PCIE_CTX_DRX_P9: CS8.1 UC1.BR1
PCIE_CTX_DRX_P10: CS10.1 UC1.BR3
PCIE_CTX_DRX_P11: CS12.1 UC1.BN3
PCIE_CTX_DRX_P12: CS14.1 UC1.BN1
PCIE_CTX_DRX_P13: CT2.2 UC1.BM3
PCIE_CTX_DRX_P14: CT4.2 UC1.BL1
PCIE_CTX_DRX_P15: CT355.2 UC1.BL3
PCIE_CTX_DRX_P16: CT356.2 UC1.BJ3
PCIE_CTX_L_DRX_N1: JNGFF1.47 LN19.3 RN118.2
PCIE_CTX_L_DRX_P1: JNGFF1.49 LN19.2 RN117.2
PCIE_RCOMPN: RC126.2 UC1.CE6
PCIE_RCOMPP: RC126.1 UC1.CE5
PCIE_WAKE#: JSSD1.54 RC102.1 RN112.1 RT186.2 RW10.1 UE1.A54 UN4.3
PCIE_WAKE#_AR: RT186.1 RT188.1 RT293.1 UT1.Y2
PCIE_WAKE#_R: RW10.2 WL1.29
PD_EE_CLK_L: JDB2.2 RPD205.2 UPD3.6 UPD5.6
PD_EE_CLK_L_R: RPD205.1 UPD1.38
PD_EE_CS#_L: JDB2.5 RPD11.2 UPD1.39 UPD3.1 UPD5.1
PD_EE_MISO_L: JDB2.4 RPD12.2 RPD181.2 UPD1.36 UPD3.2 UPD5.2
PD_EE_MOSI_L: JDB2.3 UPD1.37 UPD3.5 UPD5.5
PD_EE_WP#_L: RPD14.2 UPD3.3 UPD5.3
PD_HOLD#_L: RPD13.2 UPD3.7 UPD5.7
PD_L_DDM_MUX1_EN: RM36.1 RPD123.1
PD_L_DDM_MUX1_EN_R: RPD123.2 RPD191.1 UPD1.42
PD_L_DRAIN1: UPD1.8 UPD1.15 UPD1.19 UPD1.58
PD_L_DRAIN2: UPD1.7 UPD1.52 UPD1.56 UPD1.57
PD_L_GPIO2: RPD139.2 UPD1.18
PD_L_GPIO4: RPD141.1 UPD1.31
PD_L_GPIO16: RPD141.2 UPD1.48
PD_L_GPIO17: RPD139.1 UPD1.49
PD_L_GPIO18: RPD204.1 UPD1.50
PD_L_GPIO19: RPD204.2 UPD1.53
PD_L_USB_MUX1_EN: RM32.1 RPD187.1
PD_L_USB_MUX1_EN_R: RPD187.2 RPD190.1 UPD1.16
PE_CPU: PRZ18.1 PRZ19.2 PUZ01.36
PECI_EC: CE509.2 RE27.1 UE1.A37
PECI_EC_R: RE27.2 UC1.AR1
PECI_VREF: CE15.1 RE538.1 UE1.A38
PEG_CRX_C_GTX_N5: CV12.2 UV1.AB9
PEG_CRX_C_GTX_N6: CV14.2 UV1.AC10
PEG_CRX_C_GTX_N7: CV16.2 UV1.AC11
PEG_CRX_C_GTX_N8: CV18.2 UV1.AB12
PEG_CRX_C_GTX_P5: CV11.2 UV1.AC9
PEG_CRX_C_GTX_P6: CV13.2 UV1.AB10
PEG_CRX_C_GTX_P7: CV15.2 UV1.AD11
PEG_CRX_C_GTX_P8: CV17.2 UV1.AC12
PEG_CRX_GTX_N5: CV12.1 UC1.BW9
PEG_CRX_GTX_N6: CV14.1 UC1.BU6
PEG_CRX_GTX_N7: CV16.1 UC1.BT7
PEG_CRX_GTX_N8: CV18.1 UC1.BU9
PEG_CRX_GTX_P5: CV11.1 UC1.BW8
PEG_CRX_GTX_P6: CV13.1 UC1.BU5
PEG_CRX_GTX_P7: CV15.1 UC1.BT6
PEG_CRX_GTX_P8: CV17.1 UC1.BU8
PEG_CTX_C_GRX_N5: CV6.2 UV1.AG7
PEG_CTX_C_GRX_N6: CV8.2 UV1.AE7
PEG_CTX_C_GRX_N7: CV20.2 UV1.AF9
PEG_CTX_C_GRX_N8: CV22.2 UV1.AG10
PEG_CTX_C_GRX_P5: CV1.2 UV1.AG6
PEG_CTX_C_GRX_P6: CV7.2 UV1.AF7
PEG_CTX_C_GRX_P7: CV19.2 UV1.AE9
PEG_CTX_C_GRX_P8: CV21.2 UV1.AG9
PEG_CTX_GRX_N5: CV6.1 UC1.BW4
PEG_CTX_GRX_N6: CV8.1 UC1.BU4
PEG_CTX_GRX_N7: CV20.1 UC1.BU2
PEG_CTX_GRX_N8: CV22.1 UC1.BT4
PEG_CTX_GRX_P5: CV1.1 UC1.BW3
PEG_CTX_GRX_P6: CV7.1 UC1.BU3
PEG_CTX_GRX_P7: CV19.1 UC1.BU1
PEG_CTX_GRX_P8: CV21.1 UC1.BT3
PEX_TERMP: RV376.1 UV1.AF25
PHASE_ID1: RC70.2 RC72.1 UC1.CN14
PHASE_ID2: RC69.2 RC71.1 UC1.CM14
PHASE_ID3: RC572.2 RC573.1 UC1.CH12
PLT_RST_VGA#: RV74.1 RV378.1 RV5004.1 UV1.AC7 UV12.4 UV26.1
PLT_RST_VGA#_QV2: QV2.2 QV2.5 RV74.2
PLT_RST_VGA#_QV147: QV147.5 QV147.6 RV77.1 RV5004.2
PLT_RST_VGA#_UV26: QV150.5 UV26.4
PLTRST#: JSSD1.50 RC94.1 RT190.2 RT285.1 UC4.4 UN5.1 UV12.1 WL1.31
PM_SYS_RESET#: RC248.2 RC529.1 RC531.1
POK: DZ2.1 PR304.2 PR501.1 PU301.7 PU501.12 RC105.1 UC5.2
POWER_SW#_MB: ED11.4 ED11.7 JAPS1.11 JFP1.7 JIO1.7 RE25.2 SW1.1
POWER_SW_IN#: CE14.1 QZ21.3 RE20.2 RE25.1 UE1.B67
PRB01_CSIN: PRB01.3 PRB03.1
PRB01_CSIP: PRB01.2 PRB02.1
PRB12_CSON: PRB12.3 PRB36.2
PRB12_CSOP: PRB12.2 PRB32.2
PRIM_PWRGD: RE182.1 RE534.2 UE5.1
PRIM_PWRGD_R: RE165.1 RE182.2 RE473.2 RE507.1
PROCHOT#: RE45.2 RE547.2 UE1.B30 UE2.2
PROCHOT_CHG: PRB19.1 PUB01.23 ZTB02.1(TP-1)
PROG_CHG: PRB26.1 PUB01.27
PROJECT_ID1: RC52.2 RC55.1 UC1.CM16
PROJECT_ID2: RC200.2 RC201.1 UC1.CP16
PROJECT_ID3: RC53.2 RC56.1 UC1.CN16
PS_ID: RE548.1 RE549.1 UE1.B41
PS_ID_R: PR1.2 PR5.2 RE548.2
PS_SMBCLK: Q28.1 RS6.2 RS11.1 U16.A1
PS_SMBDAT: Q28.4 RS7.2 RS12.1 U16.B1
PSI_GPU: PCV43.1 PRV36.2 PRV38.1 PRV48.2 PUV01.3
PSID: PJPDC1.5 PQ1.1 PR3.1
PSID-1: PQ2.2 PR2.1 PR3.2
PSID-3: PQ1.3 PR1.1
PSYS_CHG: PRB31.1 PRB33.1 PUB01.30
PSYS_CPU: PCZ03.2 PRZ16.2 PRZ17.1 PUZ01.46
PTP_DIS#: D5.1 UE1.B60
PWM1: PRV21.1 PUV01.20
PWM2: PRV27.1 PUV01.19
PWM_CORE1: PUI01.9 PUZ01.43
PWM_CORE2: PUI02.9 PUZ01.42
PWM_CORE3: PUI03.9 PUZ01.41
PWM_FAN1: JIO1.16 RE17.1 UE1.A27
PWM_GT1: PUG01.9 PUZ01.39
PWM_SA: PUA01.9 PUZ01.38
PWR_DEBUG#_XDP: JXDP1.45 RC256.2 RC536.2
PWRGD_XDP: JXDP1.39 RC250.2
REFCLK_CNV: LC5.2 RC86.1 RW32.1
REFCLK_CNV_L: LC5.1 UC1.CM3
REFCLK_CNV_R: RW32.2 WL1.A44
RESET_N: RPD124.2 UPD1.17
RESET_OUT#: RE22.1 RE550.1 UE1.B3
RESET_OUT#_R: CC106.1 JXDP1.47 RC241.2 RC370.2 RC537.2
REXT_PS175: RM13.1 UM1.20
ROM_SCLK: RV80.2 RV381.1 UV1.C12
ROM_SI: RV84.2 UV1.B12
ROM_SO: RV81.2 UV1.A12
RTCRST_ON: D8.1 Q17.2 R64.2 R65.1 UE1.A46
RTCRST_ON_R: C2.1 D8.2 Q18.2 R64.1
RTD3_CIO_PWR_EN: RC575.1 RT392.2 UC1.CN26
RTD3_CIO_PWR_EN_R: RT372.1 RT392.1 RT604.1 UT1.T5
RTD3_USB_PWR_EN: RT26.1 UT1.V5
RUNPWROK: RE508.1 UC10.2 UE1.A2
SAO_UM4: RM38.1 UM4.15
SAR_ACT#: RS10.2 UE1.A20
SAR_DPR#: QN7.6 UE1.B50
SAR_DPR_R: JNGFF1.25 QN7.1 RN3.2
SATA_LED#: JSSD1.10 Q16.2 RC127.1 UC1.CN7
SATA_LED#_Q16: Q16.5 Q16.6 R31.2
SATA_LED#_R: Q3.3 Q16.3 R30.2
SBO_UM4: RM34.1 UM4.11
SCL_CHG: PRB16.1 PUB01.22
SCL_P: PRV49.2 PUV01.5 ZTV02.1(TP-1)
SCL_P_CPU: PRZ03.2 PRZ08.1 PUZ01.33
SCLK_CPU: PRZ11.2 PUZ01.27
SCLK_CPU_R: PRZ11.1 PRZ22.2 PRZ27.1
SD_PWR_EN: RR144.2 UC1.BW36
SD_PWR_EN_R: RR144.1 RR167.1 U6903.4
SD_RCOMP: RC54.2 UC1.CK33 UC1.CM34
SD_READ_MODE: RI55.1 UC1.CC36
SD_WP: RI55.2 UC1.CK34
SDA_CHG: PRB14.1 PUB01.21
SDA_P: PRV50.2 PUV01.4 ZTV01.1(TP-1)
SDA_P_CPU: PRZ02.2 PRZ09.1 PUZ01.32
SDIO_0_CD#: RR156.2 UC1.CH35
SDIO_0_CLK: CC110.1 JREAD1.5 RC555.2 RR132.1
SDIO_0_CLK_R: RC555.1 UC1.CK36
SDIO_0_CMD: RR127.1 RR165.2 UC1.CH36
SDIO_0_CMD_R: JREAD1.3 RR127.2
SDIO_0_DATA0: RR123.1 RR161.2 UC1.CL35
SDIO_0_DATA0_R: JREAD1.7 RR123.2
SDIO_0_DATA1: RR124.1 RR162.2 UC1.CL36
SDIO_0_DATA1_R: JREAD1.8 RR124.2
SDIO_0_DATA2: RR125.1 RR163.2 UC1.CM35
SDIO_0_DATA2_R: JREAD1.1 RR125.2
SDIO_0_DATA3: RR126.1 RR164.2 UC1.CN35
SDIO_0_DATA3_R: JREAD1.2 RR126.2
SDIO_0_R_CD#: JREAD1.9 RR156.1
SDIO_CPU: PRZ13.2 PUZ01.28
SDIO_CPU_R: PRZ13.1 PRZ24.2 PRZ29.1
SHD_CLK: RC524.2 UE1.A23
SHD_CS0#: RC556.2 RE516.2 RE536.2 UE1.B24
SHD_IO0: RC525.2 UE1.A22
SHD_IO1: RC526.2 UE1.B22
SHD_IO2: RC527.2 RE534.1 UE1.B23
SHD_IO3: RC528.2 UE1.A21
SIO_EXT_WAKE#: RC113.1 UC1.CG12 UE1.A57
SIO_PWRBTN#: RC98.1 UC1.BU28 UE1.B7
SIO_SLP_A#: JAPS1.6 RC513.2 UC1.BU37
SIO_SLP_S0#: JAPS1.15 PRZ07.1 RC211.1 UC1.BJ37
SIO_SLP_S3: Q29.5 Q29.6 QE11.2 RE177.2
SIO_SLP_S3#: DZ6.1 JAPS1.2 Q29.2 RC10.2 RT593.1 RZ2.1 RZ3.1 U10.2 U19.3 U711.2 UC1.BU36 UC9.1 UM2.6 UT1.U1 UZ3.3 UZ3.5
SIO_SLP_S4#: DZ5.1 DZ7.1 JAPS1.5 RC11.2 RZ9.1 RZ1416.1 RZ1418.1 UC1.BU27
SIO_SLP_S4#_UZ8: CZ220.1 RZ1416.2 UZ8.3
SIO_SLP_S5#: JAPS1.4 RC514.2 UC1.BT29
SIO_SLP_SUS#: PR1813.2 RC553.2 RZ1419.1 UC1.BU29
SKTOCC#: RC547.2 UC1.E1
SLP_S0#_CPU: PRZ04.2 PRZ07.2 PUZ01.35
SM_RCOMP0: RC17.1 UC1.BN28
SM_RCOMP1: RC18.1 UC1.BN27
SM_RCOMP2: RC20.1 UC1.BN29
SML0_SMBCLK: RC33.1 UC1.CH14
SML0_SMBDATA: RC34.1 UC1.CF15
SN_1.2V: PCM30.1 PRM24.2
SN_1.05V: PCH11.1 PRH04.2
SN_1.8V: PC1812.1 PR1808.2
SN_3V: PC309.1 PR305.2
SN_5V: PC516.1 PR510.2
SN_+1.35VGPU: PCW17.1 PRW12.2
SN_GPU1: PCV15.1 PRV24.2
SN_GPU2: PCV41.1 PRV30.2
SN_GT: PCG09.1 PRG02.2
SN_IA1: PCI12.1 PRI02.2
SN_IA2: PCI24.1 PRI04.2
SN_IA3: PCI36.1 PRI06.2
SN_SA: PCA10.1 PRA02.2
SNUB1_CHG: PCB36.1 PRB17.2
SNUB2_CHG: PCB37.1 PRB18.2
SOLC: JEDP1.25 UE1.B49
SPI_CLK_ROM: RC40.2 U27.6 UC3.6
SPI_D0_ROM: RC42.2 U27.5 UC3.5
SPI_D1_ROM: RC43.2 U27.2 UC3.2
SPI_D2_ROM: RC39.2 U27.3 UC3.3
SPI_D3_ROM: RC41.2 U27.7 UC3.7
SPKR: JIO1.9 RC57.2 UC1.CF35
SSD_DEVSLP: JSSD1.38 UC1.CR8
SSD_SCP#: JSSD1.8 RE163.2 UE1.B64
STRAP0: RV383.1 RV384.2 UV1.D1
STRAP1: RV51.2 RV390.1 UV1.D2
STRAP2: RV382.2 RV388.1 UV1.E4
STRAP3: RV387.1 RV389.2 UV1.E3
STRAP4: RV61.2 RV385.1 UV1.D3
STRAP5: RV398.2 RV399.1 UV1.C1
STRAPREF0: RV44.1 UV1.F6
SUSCLK: RC79.1 RE533.2 UC1.BT32
SUSCLK_WLAN: RC79.2 WL1.27 WL1.A25
SUSCLK_WWAN: JNGFF1.68 RN193.2
SW_USB20_1_N3: LU3.3 RU6.1 UM4.2
SW_USB20_1_N3_R: DT40.1 DT40.9 JUSBC1.A7 LU3.4 RU6.2
SW_USB20_1_P3: LU3.2 RU5.1 UM4.1
SW_USB20_1_P3_R: DT40.2 DT40.8 JUSBC1.A6 LU3.1 RU5.2
SW_USB20_2_N3: LU4.3 RU8.1 UM4.4
SW_USB20_2_N3_R: DT39.4 DT39.7 JUSBC1.B7 LU4.4 RU8.2
SW_USB20_2_P3: LU4.2 RU7.1 UM4.3
SW_USB20_2_P3_R: DT39.5 DT39.6 JUSBC1.B6 LU4.1 RU7.2
SX9310_CS0: RS9.2 U16.A3
SX9310_CS1: TP78.1(TP-1) U16.B4
SYNC: PUA01.10 PUG01.10 PUI01.10 PUI02.10 PUI03.10 PUZ01.34
SYS_PWROK: RE550.2 UC1.CR10
SYS_RESET#: CC75.2 JAPS1.13 RC100.2 UC1.CN10
SYSPWR_PRES: RE30.2 RE32.1 RE546.2 UE1.B68
T_CRIT#: DV12.1 PR524.1 QV147.3 R55.2 U3.4
T_CRIT#_D: DV11.1 DV12.2 QV150.3 RV4996.2
TABLE_MODE#: RC213.1 UC1.CA35 UE1.A39
TACH_FAN1: JIO1.17 RE16.1 UE1.B55
TBT_A_SBU1: DT39.2 DT39.8 JUSBC1.A8 UT1.H4
TBT_A_SBU2: DT39.1 DT39.9 JUSBC1.B8 UT1.J4
TBT_A_TRX_DTX_N1: DT14.1 JUSBC1.B10 UT1.A21
TBT_A_TRX_DTX_N2: DT9.1 JUSBC1.A10 UT1.B15
TBT_A_TRX_DTX_P1: DT13.1 JUSBC1.B11 UT1.B21
TBT_A_TRX_DTX_P2: DT10.1 JUSBC1.A11 UT1.A15
TBT_A_TTX_C_DRX_N1: CT98.2 DT6.1 JUSBC1.A3
TBT_A_TTX_C_DRX_N2: CT96.2 DT18.1 JUSBC1.B3
TBT_A_TTX_C_DRX_P1: CT97.2 DT5.1 JUSBC1.A2
TBT_A_TTX_C_DRX_P2: CT95.2 DT17.1 JUSBC1.B2
TBT_A_TTX_DRX_N1: CT98.1 UT1.B19
TBT_A_TTX_DRX_N2: CT96.1 UT1.B17
TBT_A_TTX_DRX_P1: CT97.1 UT1.A19
TBT_A_TTX_DRX_P2: CT95.1 UT1.A17
TBT_CIO_PLUG_EVENT#: RT391.1 UC1.CM27 UT1.AA1
TBT_DP1_AUXN: CM24.1 UT1.N5
TBT_DP1_AUXN_C: CM24.2 UM1.55
TBT_DP1_AUXP: CM23.1 UT1.N4
TBT_DP1_AUXP_C: CM23.2 UM1.56
TBT_DP1_N0: CM16.1 UT1.AC21
TBT_DP1_N0_C: CM16.2 RM53.1
TBT_DP1_N0_R: RM53.2 UM1.4
TBT_DP1_N1: CM18.1 UT1.AB19
TBT_DP1_N1_C: CM18.2 RM54.1
TBT_DP1_N1_R: RM54.2 UM1.7
TBT_DP1_N2: CM20.1 UT1.AC17
TBT_DP1_N2_C: CM20.2 RM56.1
TBT_DP1_N2_R: RM56.2 UM1.10
TBT_DP1_N3: CM22.1 UT1.AB15
TBT_DP1_N3_C: CM22.2 RM58.1
TBT_DP1_N3_R: RM58.2 UM1.13
TBT_DP1_P0: CM15.1 UT1.AB21
TBT_DP1_P0_C: CM15.2 RM52.1
TBT_DP1_P0_R: RM52.2 UM1.3
TBT_DP1_P1: CM17.1 UT1.AC19
TBT_DP1_P1_C: CM17.2 RM55.1
TBT_DP1_P1_R: RM55.2 UM1.6
TBT_DP1_P2: CM19.1 UT1.AB17
TBT_DP1_P2_C: CM19.2 RM57.1
TBT_DP1_P2_R: RM57.2 UM1.9
TBT_DP1_P3: CM21.1 UT1.AC15
TBT_DP1_P3_C: CM21.2 RM59.1
TBT_DP1_P3_R: RM59.2 UM1.12
TBT_FORCE_PWR: RPD130.1 RT27.1 RT592.1 UC1.CG25 UT1.V4
TBT_I2C_SCL: RPD21.2 RT609.1 UT1.V2
TBT_I2C_SDA: RPD22.2 RT608.1 UT1.V1
TBT_JTAG_TCK: RT6.1 UT1.W19
TBT_JTAG_TDI: RT8.1 UT1.W20
TBT_JTAG_TDO: RT5.1 UT1.Y19
TBT_JTAG_TMS: RT7.1 UT1.Y20
TBT_L_FORCE_PWR: RPD130.2 UPD1.43
TBT_PCIE_RBIAS: RT34.1 UT1.N16
TBT_PERST#: RT190.1 RT287.2 UT1.T4
TBT_PERST#_R: RT287.1 RT288.1 UT14.4
TBT_RBIAS: RT39.1 UT1.J6
TBT_RESET_N: RPD124.1 RPD169.1 RPD170.1 RT121.1 UT1.E5
TBT_RESET_N_EC: RT121.2 RT605.1 UE1.A51
TBT_ROM_CLK: RT610.1 UT1.Y16
TBT_ROM_CLK_R: RT610.2 UT2.6
TBT_ROM_CS#: RT2.1 UT1.W18 UT2.1
TBT_ROM_DI: UT1.Y18 UT2.5
TBT_ROM_DO: RT3.1 UT1.W16 UT2.2
TBT_ROM_HOLD#: RT1.1 UT2.7
TBT_ROM_WP#: RT4.1 UT1.W4 UT2.3
TBT_RSENSE: RT39.2 UT1.J5
TBT_RTD3_WAKE#: RC58.2 RT188.2 UC1.BV35
TBT_SRC_HPD: CM52.1 RM10.2 RT184.1 UT1.R5
TBT_SRC_HPD_R: RM10.1 UM1.46
TBTA_CC1: CPD3.1 DT40.5 DT40.6 JUSBC1.A5 UPD1.24
TBTA_CC2: CPD2.1 DT40.4 DT40.7 JUSBC1.B5 UPD1.26
TBTA_HPD: RPD126.1 RT23.1 UT1.T2
TBTA_HPD_R: RPD126.2 UPD1.30
TBTA_I2C_INT#: RPD112.2 RT16.1 UT1.M4
TBTA_USB2_RBIAS: RT41.2 UT1.H19
TBTB_HPD: RT33.1 UT1.T1
TDOCK_BATLOW#: RT20.1 UT1.U2
TEMP: PCV46.1 PRV22.1 PRV28.1 PRV45.1 PUV01.8
TEMP_CPU: PCZ07.1 PRZ33.1 PRZ34.1 PUZ01.45
TEST_PWRGD: RT36.1 UT1.W5
THM_SML1_CLK: Q11.4 R50.2 U3.8
THM_SML1_DATA: Q11.1 R49.2 U3.7
TMDS_CFG0: RM44.2 RM46.1 UM1.35
TMDS_CFG1: RM45.2 RM47.1 RM60.1 UM1.50
TMDS_T_TX0N: LI2.2 RI2.1 UM1.33
TMDS_T_TX0N_R: JHDMI1.9 LI2.1 RI2.2 RI4.1
TMDS_T_TX0P: LI2.3 RI6.1 UM1.34
TMDS_T_TX0P_R: JHDMI1.7 LI2.4 RI4.2 RI6.2
TMDS_T_TX1N: LI4.2 RI12.1 UM1.36
TMDS_T_TX1N_R: JHDMI1.6 LI4.1 RI10.1 RI12.2
TMDS_T_TX1P: LI4.3 RI8.1 UM1.37
TMDS_T_TX1P_R: JHDMI1.4 LI4.4 RI8.2 RI10.2
TMDS_T_TX2N: LI3.2 RI11.1 UM1.39
TMDS_T_TX2N_R: JHDMI1.3 LI3.1 RI9.1 RI11.2
TMDS_T_TX2P: LI3.3 RI7.1 UM1.40
TMDS_T_TX2P_R: JHDMI1.1 LI3.4 RI7.2 RI9.2
TMDS_T_TXCN: LI1.2 RI5.1 UM1.30
TMDS_T_TXCN_R: JHDMI1.12 LI1.1 RI3.1 RI5.2
TMDS_T_TXCP: LI1.3 RI1.1 UM1.31
TMDS_T_TXCP_R: JHDMI1.10 LI1.4 RI1.2 RI3.2
TOUCH_PAD_INT#: DZ1.2 RC5.2 UC1.CB34
TOUCH_PANEL_PD#: D465.1 R6908.2 RC6.2 UC1.CN3
TOUCH_PANEL_PD#_R: D3.2 D464.2 D465.2 JCAM1.1 R6908.1
TOUCH_SCREEN_INT#: JCAM1.12 RC203.2 UC1.CM12
TOUCH_SCREEN_RST#: JCAM1.7 R88.2 UC1.CC27
TOUCHPAD_INTR#: DZ1.1 Q8.1 RE12.1 UE1.B13
TP_EN#: R41.1 RE542.1 UE1.B52
TP_EN#_R: C23.2 Q5.2 Q5.5 R41.2
TP_LOCK#: D5.2 JTP1.3 R46.2
TYPEC_SMBCLK: Q30.6 RE531.1 RM31.2 RPD163.2
TYPEC_SMBDA: Q30.3 RE530.1 RM37.2 RPD164.2
UG1_CHG: PQB01.1 PUB01.11
UG2_CHG: PQB02.1 PUB01.5
UIM_CLK: CS1.1 JNGFF1.32 RN192.1
UIM_CLK_R: CS6.1 DS1.1 DS1.9 JSIM1.3 RN192.2
UIM_DATA: CS36.1 CS38.1 DS1.4 DS1.7 JNGFF1.34 JSIM1.7 RS2.2
UIM_DET: JNGFF1.66 RN10.1
UIM_DET_R: Q26.1 RN10.2 RN196.1 RN197.2
UIM_DET_SIM#: CS2.1 DS1.5 DS1.6 JSIM1.5 Q26.2 RN198.2
UIM_RESET: CS37.1 DS1.2 DS1.8 JNGFF1.30 JSIM1.2
UPD1_SMBCLK: PRZ08.2 Q30.1 RE101.1 RE531.2 UE1.A58
UPD1_SMBDAT: PRZ09.2 Q30.4 RE100.1 RE530.2 UE1.B61
UPD1_SMBINT#: RE155.1 RPD17.2 UE1.B56
UPD_L_SMBCLK: RM31.1 UM4.18
UPD_L_SMBDAT: RM37.1 UM4.17
USB2_COMP: RC123.1 UC1.CC5
USB2_ID: RC124.1 UC1.CE8
USB2_VBUSSENSE: RC125.1 UC1.CC6
USB3_CRX_DTX_N3: JIO1.31 UC1.BY7
USB3_CRX_DTX_N4: JIO1.37 UC1.BW6
USB3_CRX_DTX_P3: JIO1.30 UC1.BY6
USB3_CRX_DTX_P4: JIO1.36 UC1.BW5
USB3_CTX_DRX_N3: JIO1.34 UC1.BY4
USB3_CTX_DRX_N4: JIO1.40 UC1.BW2
USB3_CTX_DRX_P3: JIO1.33 UC1.BY3
USB3_CTX_DRX_P4: JIO1.39 UC1.BW1
USB20_N1: LIO1.4 RIO4.1 UC1.CE3
USB20_N1_R: JIO1.19 LIO1.3 RIO4.2
USB20_N2: LIO2.4 RIO5.1 UC1.CE1
USB20_N2_R: JIO1.22 LIO2.3 RIO5.2
USB20_N3: UC1.CG3 UM4.9
USB20_N5: LFP4.1 RFP8.1 UC1.CG5
USB20_N5_R: ED11.1 ED11.9 JFP1.6 LFP4.2 RFP8.2
USB20_N6: L3.1 R10.1 UC1.CC1
USB20_N6_R: ED12.2 ED12.8 JEDP1.30 L3.2 R10.2
USB20_P1: LIO1.1 RIO3.1 UC1.CE4
USB20_P1_R: JIO1.20 LIO1.2 RIO3.2
USB20_P2: LIO2.1 RIO6.1 UC1.CE2
USB20_P2_R: JIO1.23 LIO2.2 RIO6.2
USB20_P3: UC1.CG4 UM4.8
USB20_P5: LFP4.4 RFP7.1 UC1.CG6
USB20_P5_R: ED11.2 ED11.8 JFP1.5 LFP4.3 RFP7.2
USB20_P6: L3.4 R12.1 UC1.CC2
USB20_P6_R: ED12.1 ED12.9 JEDP1.31 L3.3 R12.2
USB_EN#: JIO1.10 RE19.2 RE512.2
USB_OC0#: JIO1.11 RC189.1 UC1.CK6
USB_OC1#: RC190.1 UC1.CK5
USB_OC2#: RC191.1 UC1.CK8
USB_OC3#: RC188.1 UC1.CK9
USB_PWR_EN#: RE512.1 UE1.A14
VDIFFA_CPU: PRZ47.1 PUZ01.6
VDIFFB_CPU: PRZ43.1 PUZ01.10
VDIFFC_CPU: PRZ35.1 PUZ01.14
VFBA_CPU: PRZ46.1 PRZ47.2 PUZ01.7
VFBB_CPU: PRZ42.1 PRZ43.2 PUZ01.11
VFBC_CPU: PRZ35.2 PRZ36.1 PUZ01.15
VGA_CORE_EN: CV197.2 DV4.1 PRV51.1 QV146.2 RV105.2
VGA_CORE_EN#: QV146.5 QV146.6 RV2008.2
VIDALERT#: RC135.1 UC1.AA3
VIDSCLK: RC264.1 UC1.AA1
VIDSOUT: RC263.1 UC1.AA2
VORTNA_CPU: PRZ44.2 PUZ01.9
VORTNB_CPU: PRZ40.2 PUZ01.13
VORTNC_CPU: PRZ39.2 PUZ01.17
VOSENA_CPU: PRZ45.2 PUZ01.8
VOSENB_CPU: PRZ41.2 PUZ01.12
VOSENC_CPU: PRZ38.2 PUZ01.16
VR_CAP: CE23.1 UE1.B8
VR_SVID_ALERT#: PRZ28.2 RC134.2 RC135.2
VR_SVID_CLK: PRZ27.2 RC264.2
VR_SVID_DATA: PRZ29.2 RC136.2 RC263.2
VRA_VDD18: PCZ12.1 PRZ54.2 PUZ01.26
VRA_VDD33: PCZ11.1 PRZ53.2 PUZ01.44
VRACPU_VINSEN: PCZ13.1 PRZ55.2 PRZ56.1 PUZ01.47
VRACPU_VTEMP: PRZ33.2 PUA01.11 PUG01.11 PUI01.11 PUI02.11 PUI03.11
VRAM_ID1: RC118.2 RC120.1 UC1.CE27
VRAM_ID2: RC117.2 RC119.1 UC1.CN23
VRAM_VDD_CTL: RV4989.1 UV1.E9
VRHOT#_CPU: PRZ21.2 PRZ26.1 PUZ01.31
VRRDY_CPU: PRZ10.1 PUZ01.30
VSA_SEN+: PRZ38.1 RC164.2 UC1.BG7
VSA_SEN-: PRZ39.1 RC165.1 UC1.BE7
VSYS_CHG: PCB35.1 PRB21.1 PUB01.3
VTTREF_1.2V: PCM19.1 PUM01.7
WHITE_LED_BAT: Q32.1 R27.2
WHITE_LED_BAT_R: LED1.2 R27.1
WIFI_RF_EN: RC571.2 RW60.1 UC1.CR24
WIFI_RF_EN_R: RW60.2 WL1.28
WLAN_COEX1: RW14.2 WL1.11
WLAN_COEX2: RW15.2 WL1.12
WLAN_COEX3: RW16.2 WL1.13
WWAN_BB_RST#: RN73.1 UC1.CG23
WWAN_BB_RST#_R: CN59.1 JNGFF1.67 RN73.2 RN199.1
WWAN_COEX1: JNGFF1.64 RW11.1 RW14.1
WWAN_COEX2: JNGFF1.62 RW12.1 RW15.1
WWAN_COEX3: JNGFF1.60 RW13.1 RW16.1
WWAN_FULL_PWR_EN: CN18.1 JNGFF1.6 RN7.2 UC1.CM23
WWAN_GPIO_CTRL: RN90.1 UE1.A16
WWAN_GPIO_CTRL#: QN3.1 RN89.2 UN4.6
WWAN_GPIO_CTRL_R: QN3.2 RN90.2 RN91.1
WWAN_GPIO_PERST#: RN85.2 RN86.1 RN113.1 UC1.CH23
WWAN_GPIO_PERST#_R: RN86.2 RN97.1 UN5.6
WWAN_GPIO_WAKE#: RN80.1 RN82.1 UC1.CK23
WWAN_GPIO_WAKE#_R: RN80.2 UN4.1
WWAN_PERST#: JNGFF1.50 RN87.2 RN88.1 RN113.2
WWAN_PERST#_R: RN87.1 UN5.4
WWAN_PEWAKE#: JNGFF1.54 RN74.1 RN81.2 RN82.2 RN112.2
WWAN_PEWAKE#_R: RN81.1 UN4.4
WWAN_RADIO_DIS#: QN8.3 RC565.1 UC1.CF22
WWAN_RADIO_DIS#_R: JNGFF1.8 QN8.4
WWAN_WAKE#_R: JNGFF1.23 QN7.4 RN92.2
XCLK_BIASREF: RC83.1 UC1.CJ1
XDP_BPM#0: TP135.1(TP-1) UC1.U1
XDP_BPM#1: TP136.1(TP-1) UC1.U2
XDP_BPM#2: TP4.1(TP-1) UC1.U3
XDP_BPM#3: TP5.1(TP-1) UC1.U4
XDP_DBRESET#: CC105.1 JXDP1.48 RC248.1
XDP_ITP_PMODE: TP137.1(TP-1) UC1.W4
XDP_OBS0: JXDP1.21 RC245.2
XDP_OBS1: JXDP1.23 RC246.2
XDP_PIN1: JXDP1.1 RC253.2
XDP_PRSENT#: JXDP1.60 RC243.1 RC533.2
XDP_PWRBTN#: CC109.1 JXDP1.41 RC247.2 RC535.1
XDP_RST#: JXDP1.46 RC249.1 RC538.2
XDP_TCK1: JXDP1.55 RC238.2
XTAL24_IN: RC89.1 UC1.CK3
XTAL24_IN_R: CC9.1 RC89.2 RC90.1 YC1.3
XTAL24_OUT: RC91.1 UC1.CK2
XTAL24_OUT_R: CC10.1 RC90.2 RC91.2 YC1.1
XTAL_25_IN: RT394.1 UT1.D22
XTAL_25_OUT: RT40.1 UT1.D23
XTAL_25_OUT_R: CT20.1 RT40.2 YT1.3
XTAL_IN: CV210.2 UV1.C11 YV1.1
XTAL_OUT: RV22.1 UV1.B10
XTAL_OUT_R: CV209.2 RV22.2 YV1.3
XTAL_OUTBUFF: RV20.1 UV1.C10
XTAL_SSIN: RV21.1 UV1.A10
N2683228: PRV23.1 PUV02.10
N2712313: PRV21.2 PUV02.9
N2712398: PRV22.2 PUV02.11
N2712532: PRV25.2 PUV02.12
N2726002: PRV29.1 PUV03.10
N2726340: PRV27.2 PUV03.9
N2726376: PRV31.2 PUV03.12
N20727249: QV146.3 RV2009.2
N20754656: QV147.2 RV76.2
N26715581: Q18.1 R63.2
N26762311: CD27.2 RD13.1
N26762425: CD113.2 RD26.1
N26763132: CD52.2 RD24.1
N26877476: Q15.2 Q15.5 R89.2
N26881990: QZ3.1 RZ25.1
N28778657: QV145.3 RV2006.2
N30699666: QV3.2 RV5001.1
N30795396: QV50.1 RV200.1
N30856173: T20.1(TP-1) UV1.F22
N30856176: T21.1(TP-1) UV1.J22
N31419621: CS1.2 RS3.1
N31764539: PCZ10.1 PRZ46.2
N31764585: PCZ09.1 PRZ42.2
N31764615: PCZ08.1 PRZ36.2
N32054988: RT285.2 UT14.1
N32054990: RT284.2 UT14.2
N32488305: RS5.2 RS10.1 U16.B2
N32831687: QN4.1 QN4.4
N33308105: PQB12.2 PQB13.1
N33308155: PQB04.2 PRB23.1 PRB43.1
N33308158: PDB01.1 PDB02.1 PRB08.1
N33308352: PCB42.1 PRB30.2
N33308361: PCB25.1 PRB06.2
N33308363: PRB29.1 ZTB01.1(TP-1)
N33308373: PCB30.2 PRB15.1
N33310985: PC515.1 PR506.2 PR507.1
N33311343: CC104.1 UC1.BP24
N33312418: PC1811.1 PR1804.2 PR1805.1
N35403675: PC100.2 PQ100.2 PR105.1
N35404139: PC100.1 PQ100.3 PR101.2
N35404409: PQ100.5 PR103.2 PR104.1
N35676409: T18.1(TP-1) UC1.CP36
N35676427: T27.1(TP-1) UC1.A34
N35676429: T28.1(TP-1) UC1.B35
N35676431: RC420.1 UC1.C34
N35676631: T4989.1(TP-1) UC1.AH26
N35676633: RC436.2 UC1.AJ27
N35774230: PRV28.2 PUV03.11
N35920315: Q29.3 RE477.2
N36044932: CZ235.1 UZ9.6
N36098789: JESPI1.8 RE535.1
N36100634: QE11.1 RE213.2
N36372155: TP86.1(TP-1) UE1.B66

# Allegro board Dell Inspiron 7490 Compal LA-H451P EDW40 Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCC_SA: length 14.8
  BOTTOM w0.102: 147.6,50.91 v5(147.84,51.14) ; v5(147.84,51.14) 148.03,50.95 ; v5(147.84,51.14) 147.55,51.42 ; v5(147.84,51.14) 148.04,51.35 ; 149.43,50.45 v5(149.2,50.68) ; v5(149.2,50.68) 149.39,50.87 ; v5(149.2,50.68) 148.99,50.89 ; v5(149.2,50.68) 149,50.47 ; 148.43,41.45 v5(148.64,41.25) ; v5(148.64,41.25) 148.83,41.44 ; v5(148.64,41.25) 148.41,41.02 ; v5(148.64,41.25) 148.85,41.04 ; 149.78,40.11 v5(149.56,40.33) ; v5(149.56,40.33) 149.33,40.1 149.33,40.1 ; v5(149.56,40.33) 149.78,40.55 ; v5(149.56,40.33) 149.36,40.53 ; 150.67,40.52 UC1.BJ8 ; UC1.BJ8 150.72,40.09 ; UC1.BJ8 150.25,40.1 ; 149.83,40.98 v5(150.02,40.79) ; v5(150.02,40.79) 150.24,40.57 ; v5(150.02,40.79) 149.82,40.59 ; v5(150.02,40.79) 150.24,41.01 ; 148.52,50.45 v5(148.29,50.68) ; v5(148.29,50.68) 148.09,50.88 ; v5(148.29,50.68) 148.5,50.89 ; v5(148.29,50.68) 148.06,50.45 ; 151.14,40.59 v5(150.95,40.79) ; v5(150.95,40.79) 150.75,40.98 ; v5(150.95,40.79) 151.14,40.98 ; v5(150.95,40.79) 150.73,40.58 ; 148.45,40.15 v5(148.64,40.33) ; v5(148.64,40.33) 148.82,40.52 ; v5(148.64,40.33) 148.83,40.14 ; v5(148.64,40.33) 148.42,40.55 ; 150.31,40.53 v5(150.49,40.35) ; 151.18,41.02 v5(151.41,41.25) 151.21,41.45 ; 151.22,40.52 v5(151.41,40.33) 151.22,40.14 ; 148.89,40.59 v5(149.1,40.79) ; v5(149.1,40.79) 149.33,41.02 ; v5(149.1,40.79) 148.89,41 ; v5(149.1,40.79) 149.33,40.56 ; 150.3,41.06 v5(150.48,41.25) ; v5(150.48,41.25) 150.67,41.43 ; v5(150.48,41.25) 150.29,41.44 ; v5(150.48,41.25) 150.69,41.05 ; 149.45,50.93 v5(149.66,51.14) 149.44,51.36
  vias: v2(149.29,43.61) v2(149.29,43.04) v2(149.29,42.47) v2(150.08,48.83) v2(150.08,48.37) v2(150.08,47.66) v2(150.08,46.47) v2(150.08,45.98) v2(150.08,44.03) v2(150.08,43.55) v2(150.14,51.23) v2(150.1,47.13) v2(150.1,45.25) v2(150.1,44.76) v2(150.1,42.83) v2(150.1,42.35) v2(150.2,50.43) v3(148.68,24.79) v4(147.65,48.88) v4(147.91,50.74) v4(148.01,43.37) v4(148.17,50.23) v4(148.27,51.14) v4(148.27,49.73) v4(148.21,49.1) v4(148.77,48.71) v4(148.88,50.38) v4(149.35,52.38) v4(149.67,47.39) v4(149.69,46.19) v4(149.69,45) v4(149.69,43.78) v4(149.64,40.77) v4(149.72,48.63) v4(149.72,42.59) v4(150.11,41.26) v4(150.28,40.1) v4(150.46,46.19) v4(150.51,48.63) v4(150.51,47.41) v4(150.57,45) v4(150.51,43.78) v4(150.53,42.59) v4(150.52,40.79) v4(150.95,41.12) v4(150.95,40.28) v5(149.2,51.61) v5(149.66,52.07) v5(149.67,51.54) v6(145.07,27.14) v6(145.07,26.51) v6(145.71,27.14) v6(145.71,26.51) v6(146.34,27.14) v6(146.34,26.51) v6(146.98,27.14) v6(146.98,26.51) v6(147.61,27.14) v6(147.61,26.51)
+VCCIO: length 75.8
  TOP w0.254: v2(128.64,12.39) 128.15,12.39 127.9,12.64 125.18,12.64 124.84,12.3 124.18,12.3 123.45,13.03 v3(123.45,16.33) 123.45,30.2 v6(120.89,32.76) ; v2(159.12,38.75) 159.12,38.24 RC4.1
  IN1 w0.254: v2(145.75,6.7) 145.75,10.18 143.54,12.38 141.88,12.38 141.46,11.96 135.5,11.96 135.18,12.28 133.55,12.28 133.13,12.7 128.95,12.7 v2(128.64,12.39) ; v2(161.08,49.57) 161.08,48.47 161.96,47.59 161.96,45.59 161.03,44.66 160.39,44.66 159.41,43.68 159.41,42.33 159.79,41.95 159.79,41.54 159.41,41.16 159.41,40.11 159.12,39.83 v2(159.12,38.75)
  BOTTOM w0.102: 150.77,50.42 v5(151.03,50.68) ; v5(151.03,50.68) 150.84,50.86 ; v5(151.03,50.68) 151.22,50.48 ; v5(151.03,50.68) 151.24,50.89 ; 161.26,50.88 v5(161.05,50.68) ; v5(161.05,50.68) 160.84,50.89 ; v5(161.05,50.68) 161.27,50.46 ; v5(161.05,50.68) 160.81,50.44 ; 161.76,51.81 v5(161.96,51.61) 161.75,51.39 ; 161.32,51.33 v5(161.51,51.14) ; v5(161.51,51.14) 161.69,51.33 ; v5(161.51,51.14) 161.3,50.94 ; v5(161.51,51.14) 161.72,50.92 ; 146.96,45.47 v5(147.16,45.27) ; 150.77,50.94 v5(150.57,51.14) ; v5(150.57,51.14) 150.38,50.95 ; v5(150.57,51.14) 150.37,51.34 ; v5(150.57,51.14) 150.78,51.35 ; 150.34,50.9 v5(150.11,50.68) 150.33,50.47 ; 160.79,51.87 v5(160.6,52.07) 160.8,52.27 ; 161.27,51.38 v5(161.05,51.61) ; v5(161.05,51.61) 160.86,51.8 ; v5(161.05,51.61) 160.83,51.39 ; v5(161.05,51.61) 161.25,51.8 ; 146.95,45.89 v5(147.16,46.11) 146.94,46.33 ; 160.79,50.95 UC1.AM25 160.8,51.35 ; 150.75,51.89 v5(150.57,52.07) ; v5(150.57,52.07) 150.36,52.28 ; v5(150.57,52.07) 150.76,52.26 ; v5(150.57,52.07) 150.37,51.87 ; 150.31,51.41 150.12,51.61 v5(150.11,51.61) 150.32,51.81 ; 161.77,50.87 v5(161.96,50.68) 161.73,50.44 161.73,50.44 ; 151.23,51.4 v5(151.03,51.61) ; v5(151.03,51.61) 150.82,51.4 ; v5(151.03,51.61) 150.82,51.81 ; 161.3,51.86 v5(161.51,52.07) ; v5(161.51,52.07) 161.73,52.29 ; v5(161.51,52.07) 161.28,52.3 ; v5(161.51,52.07) 161.73,51.84
  vias: v2(147.51,45.23) v2(148.1,45.23) v2(148.68,45.23) v2(148.86,46.9) v2(148.88,46.5) v2(149.27,45.23) v2(150.07,49.83) v2(151.34,50.07) v2(161.08,51.23) v2(161.08,50.48) v2(161.99,51.23) v2(161.97,49.54) v2(162.02,50.47) v4(148.02,46.12) v4(148.45,46.62) v4(149.77,50.18) v4(150.2,52.05) v4(150.53,51.62) v4(150.96,51.25) v4(150.91,50.15) v4(160.65,51.63) v4(160.77,50.85) v4(161.48,51.5) v4(161.48,50.54) v4(161.79,50.96) v5(160.6,51.14) v6(107.59,23.33) v6(108.23,25.06) v6(108.23,24.48) v6(108.23,23.89) v6(108.23,23.31) v6(108.81,25.06) v6(108.81,24.48) v6(108.81,23.89) v6(108.81,23.31)
+VCCIO_OUT: length 1
  TOP w0.081: 114.96,24.86 v1(115.91,24.86)
+VCCLDOSRAM_1P24: length 1.3
  TOP w0.254: RC133.1 142.88,49.87 v6(142.89,49.87)
  IN3 w0.254: v6(142.89,49.87) 143.26,49.5 v5(143.26,49.47)
+VCCPLL_OC: length 10.3
  TOP w0.508: RZ11.2 151.5,58.75 RZ12.2 150.79,57.6 150.27,57.08 v3(150.27,56.33) 149.3,55.36 149.3,52.09 149.09,51.88
  IN1 w0.254: v2(148.93,51.25) 148.93,51.47 v4(148.72,51.69)
  IN3 w0.254: v5(148.75,52.07) 148.72,52.04 v4(148.72,51.69) 148.37,51.69 v5(148.29,51.61)
  BOTTOM w0.254: v5(148.75,52.07) 148.75,52.06 v5(148.29,51.61)
+VCCPLL_OC_R:
  vias: v1(154.53,56.69)
+VCCST: length 58.7
  IN1 w0.254: v4(163.33,24.07) v4(163.33,21.25)
  IN2 w0.254: v4(163.33,21.25) 163.8,20.78 163.8,20.23 162.63,19.06 162.63,18.12 162.98,17.78 163.72,17.78 164.08,17.42 164.08,16.47 163.37,15.76 160.82,15.76 v4(160.69,15.89)
  IN2 w0.508: 150.3,33.76 150.3,33.77 149.82,34.26 148.8,34.26 147.04,36.02 147.04,36.84 v4(147.03,36.84) 147.15,36.97 147.15,39.97 146.51,40.62 v6(146.31,40.62)
  IN3 w0.254: v4(147.03,36.84) 147.03,36.56 146.99,36.51 v5(146.99,36.31) ; v5(167.96,30.78) 167.94,30.76 167.57,30.76 v5(166.48,31.84) ; v5(163.33,23.63) v4(163.33,24.07) 163.33,24.07 v5(163.33,25.81) ; v5(163.33,21.67) v4(163.33,21.25) ; v4(160.69,15.89) 160.66,15.92 160.66,16.36 v5(160.8,16.5)
  BOTTOM w0.102: 146.95,41.69 UC1.BP11 146.89,42.18
  BOTTOM w0.203: PRZ21.1 163.79,21.26 PCZ02.1
  BOTTOM w0.254: RC136.1 v5(167.96,30.78) 168.12,30.94 RC134.1 ; 158.5,30.52 158.5,29.9 158.87,29.53 162.63,29.53 163.22,28.94 163.22,26.74 163.33,26.63 v5(163.33,25.81) ; 158.5,30.52 164.38,30.52 164.68,30.82 165.47,30.82 v5(166.48,31.84) ; 158.5,30.52 154.65,30.52 153.53,29.41 151.48,29.41 v5(151.26,29.19) ; RC2.1 151.07,32.97 151,32.9 RC554.1 150.68,32.87 v5(150.62,32.82) ; PRZ22.1 163.47,23.76 v5(163.33,23.63) ; v5(146.99,36.31) 147.04,36.26 147.04,36.16 UC1.BP2
  vias: v3(144.23,42.06) v4(150.34,33.17) v5(146.02,41.39) v5(146.39,41.47) v5(146.8,41.53) v5(149.86,31.27) v5(150.12,31.21)
+VCCSTG: length 56.6
  TOP w0.203: RC1.1 166.82,37.71 167.11,37.71 v2(167.14,37.73)
  TOP w0.254: v2(160.01,51.17) 160.01,51.46 159.83,51.64 159.83,52.24 v3(159.87,52.28) 159.96,52.36 160.31,52.36 160.77,51.91 RZ1421.2 161.02,52.19 161.4,52.57 RC436.1 ; RC239.1 170.9,37.56 RC240.1 v2(169.62,37.56)
  IN1 w0.254: 161.02,37.47 160.32,36.76 156.95,36.76 156.73,36.98 154.62,36.98 154.38,36.74 153.49,36.74 153.3,36.94 v4(151.79,36.94) 151.79,37.35 v2(151.88,37.44) ; 161.02,37.47 161.95,36.54 165.02,36.54 165.56,37.08 166.48,37.08 v2(167.14,37.73) 167.17,37.7 167.17,37.12 167.65,36.64 168.91,36.64 169.62,37.35 v2(169.62,37.56) ; 161.02,37.47 161.02,37.74 160.8,37.97 160.8,40.49 160.64,40.64 160.64,43.61 162.34,45.31 162.34,47.84 161.57,48.61 161.57,49.81 161.32,50.06 160.65,50.06 160.39,50.32 160.39,50.58 160.01,50.97 v2(160.01,51.17)
  IN2 w0.508: v4(151.79,36.94) 151.7,36.85 151.7,31.06 149.24,28.6 147.38,28.6 v4(146.91,28.13)
  IN3 w0.254: v5(151.41,36.94) v4(151.79,36.94) ; v5(147.34,28.48) 147.06,28.2 146.98,28.2 v4(146.91,28.13)
  BOTTOM w0.254: CZ231.1 147.5,28.58 RZ30.2 v5(147.34,28.48)
+VCCSTG_OUT:
  vias: v6(145.99,28.11)
+VIN_3V3_L_TBT: length 3.2
  IN3 w0.254: v5(25.67,32.68) 25.69,32.71 27.38,32.71 27.77,33.1 v5(27.77,34)
GND: length 2624.6
  TOP w0.076: RV388.2 98.79,76.52 v8(98.77,76.54) ; v8(123.35,55.87) 123.35,56.36 122.69,57.01 122.47,57.01 120.69,58.79 120.69,58.92 ; 125.03,50.71 125.26,50.94 125.26,53.81 124.95,54.12 ; 124.22,50.64 v8(124.22,50.64) 124.22,50.82 124.82,51.41 124.82,53.14 124.37,53.58
  TOP w0.102: 124.95,54.12 124.63,54.45 124.63,55.72 121.91,58.43 121.91,58.49
  TOP w0.203: v8(16.36,27.87) 16.6,27.63 RPD181.1 ; RV378.2 v8(110.91,46.79) ; RT604.2 27.81,52.97 v8(27.97,53.13) ; RV71.2 v8(111.45,55.6) ; RM14.2 v8(22.43,36.72) ; RC573.2 140.35,41.84 v8(140.41,41.9) ; RC61.1 141.19,46.43 v8(141.36,46.61) ; v8(144.08,56.71) 144.31,56.71 RC513.1 ; CC75.1 v8(137.27,40.72) ; RC72.2 136.27,42.98 v8(136.08,42.79) ; RM15.2 v8(21.77,36.72) ; RM47.2 v8(22.88,37.39) ; RM27.2 v8(21.93,47.71) ; RV102.2 v8(99.64,69.31) ; RM13.2 v8(23.3,47.72) ; UV2.11 v8(118.73,52.71) ; RV20.2 v8(96.96,67.42) ; v8(136.5,47.67) 137.02,47.67 RC227.2 ; RT553.2 v8(28.19,51.92) ; v8(195.49,21.75) 195.73,21.75 195.81,21.67 195.81,21.62 196.21,21.23 v8(196.49,21.23) 196.49,21 196.24,20.75 v8(195.49,20.75) ; v8(97.24,67.73) 97.37,67.73 RV4989.2 ; v8(146.05,50.44) RC104.2 ; v8(143.85,51.78) RC553.1 ; v8(140.54,52.69) RC205.1 ; RV390.2 102.65,74.72 v8(102.58,74.64) ; v8(93.5,66.13) 93.56,66.07 RV120.2 ; v8(140.3,47.02) 140.52,47.02 RC108.1 ; v8(102.64,74.26) 102.72,74.18 RV383.2 ; RC514.1 v8(145.92,54) ; RC94.2 v8(137.57,69.86) ; v6(88.34,74.16) 88.35,74.15 UV6.F5 ; RT27.2 v8(30.06,50.83) ; UZ3.11 v8(91.19,27.1) ; v8(145.54,56.68) RC10.1 ; v8(135.04,49.36) 135.03,49.35 RC119.2 ; RT36.2 v8(28.68,50.84) ; v8(136.18,56.01) RC74.1 ; UV8.E3 v2(91.39,42.04) ; v8(144.89,50.39) RC11.1 ; v8(138.75,52.62) RC73.1 ; RV381.2 v8(96.22,65.73) ; CV930.1 v8(28.11,38.47) ; RM28.2 v8(20.85,47.51) ; UM4.5 v8(19.12,70.43) ; UV6.R14 v8(88.71,63.05) ; RV44.2 v8(103.02,67.42) ; UV8.F5 v8(89.73,42.31) ; CV600.1 v8(15.94,45.23) ; 87.22,64.54 v8(87.22,63.96) ; RC12.2 v8(137.18,39.78) ; RT288.2 v8(33.45,61.18) ; 86.65,65.11 v6(87.19,65.11) ; RT26.2 v8(28.22,53.39)
  TOP w0.229: UV8.F10 v8(87.4,39.05) ; UV8.U12 79.55,44.45 v8(79.43,44.56) ; v6(91.99,40.2) UV8.C4 ; v2(86.92,36.13) 87.01,36.22 v8(87.47,36.22) ; UV8.R3 v6(85.77,48.67) ; UV8.R12 v8(80.68,42.44) ; RC55.2 v8(137.8,45.84) ; v6(87.17,49.77) 86.9,49.51 UV8.R1 86.87,49.2 v2(86.39,49.2) ; UV8.B5 91.86,39.48 v6(91.37,39.48) ; UV8.U3 v8(84.64,49.9) ; UV8.B10 v8(89.75,36.79) ; UV8.N12 v8(81.81,41.41)
  TOP w0.254: v6(90.67,71.14) 91.05,70.76 UV6.F10 ; U16.A4 72.72,74.68 v8(72.86,74.82) ; UV8.A3 v8(94.16,39.72) ; CV220.2 v8(102.31,68.99) ; QV146.4 v8(115.23,74.28) ; CV217.2 v8(95.92,62.66) ; v8(112.99,43.76) 112.56,43.76 112.48,43.84 UV10.3 ; UV6.H14 v8(92.79,66.89) ; v8(82.76,68.65) 82.69,68.71 82.69,69.07 ; RM34.2 v8(19.76,76.6) ; UV6.U12 v6(86.09,62.82) ; v6(112.33,25.15) 112.65,25.47 UZ2.5 ; v8(85.48,70.31) 85.52,70.35 UV6.L5 ; CV197.1 119.24,44.34 v8(119.24,44.15) ; v8(147.28,49.77) CZ40.2 ; v8(141.9,42.44) 141.61,42.15 CC18.2 ; PCV42.2 v8(44.8,64.72) ; CV778.2 v8(97.41,64.48) ; v8(86.34,76.81) 86.38,76.81 86.65,76.54 86.65,76.42 ; CM47.1 v8(18.08,76.68) ; UV8.R11 81.19,43.53 v6(81.19,43.05) ; v8(92.99,62.3) CV772.2 92.99,62.75 CV773.2 ; v8(80.3,32.25) QV152.1 ; CM1.2 v8(34.22,38.17) ; UV8.H2 v8(90.9,44.71) ; UV8.T10 v8(81.58,45.04) ; v8(82.27,69.15) 82.13,69.29 82.13,69.63 ; UV6.U3 v8(80.67,68.17) ; UV8.A14 v8(87.1,33.59) ; UV6.A14 96.3,71.33 v6(96.76,70.86) ; 86.65,66.24 v8(86.65,65.68) ; CC49.2 142.6,45.22 v8(142.35,45.48) ; UV8.C1 94.02,42.77 v6(94.02,42.87) ; UV6.T10 v8(85.52,65.68) ; PC1815.2 v8(71.73,10.33) ; UV8.N14 v8(80.3,40.37) ; v8(91.36,45.56) 91.07,45.27 UV8.H1 ; UV6.U1 v8(79.48,70.01) ; UV6.E12 v8(92.88,69.62) ; v2(87.41,37.79) 87.75,37.79 87.87,37.92 UV8.D10 v6(88.03,37.37) UV8.C11 ; v6(95.57,69.71) 95.14,70.14 UV6.C14 ; UV6.R1 v8(80.62,71.14) ; v2(87.36,47.96) 87.5,48.1 UV8.N1 ; UV8.M5 v6(85.94,44.87) ; UV6.G5 87.86,73.03 88.29,72.59 v6(88.29,72.52) ; v8(195.49,20.75) v8(194.91,20.75) 194.72,20.94 v8(194.72,21.24) 194.66,21.37 194.8,21.7 v8(194.91,21.75) v8(195.49,21.75) ; v8(15.32,66.64) DT40.3 v8(13.12,66.64) ; v8(88.75,42.03) UV8.G5 ; C6671.1 v8(78.16,33) ; PC1814.2 v8(70.84,10.32) ; UV8.P10 v6(82.78,43.98) ; v8(147.25,52.53) RC20.2 ; UV6.H2 v8(85.05,74.16) ; v8(50.43,15.35) 50.43,14.89 UC3.4 50.23,14.7 U27.4 ; QV144.4 v8(117.93,54.07) ; v8(117.62,48) 117.62,47.83 CV322.2 ; 94.01,69.07 v8(94.45,68.63) ; QV146.1 v8(113.93,72.43) ; v8(136.14,70.19) 136.14,70.2 CZ221.2 ; UV26.3 109.49,45.73 v8(109.49,45.82) ; v8(144.63,45.82) 144.86,45.59 CC85.2 ; v8(13.27,63.07) DT39.3 v8(15.42,63.07) ; UV8.H13 UV8.H14 v6(83.1,37.51) ; CV213.2 v8(97.31,68.71) ; v8(112.13,54.23) CV207.2 ; UV6.D10 v8(91.89,72.31) ; UV6.C3 v8(89.48,76.42) ; 99.27,64.94 99.27,64.81 99.53,64.56 v8(99.53,64.38) ; v8(25.9,5.5) 25.65,5.75 DS1.3 v8(23.84,5.75) ; PR1810.2 v8(67.24,16.47) ; UV6.L10 88.25,68.03 v6(88.25,68.45) ; v8(85.74,39.58) 86.3,39.58 UV8.G10 v8(86.91,39.62) ; UV6.C11 v8(93.44,71.32) 93.45,71.33 UV6.C12 ; QV50.3 v8(96.4,64.51) ; v2(2.53,26.05) 2.22,26.05 1.93,25.76 JREAD1.6 ; v6(86.34,36.79) UV8.E12 86.41,37.42 v2(86.41,37.93) ; v8(142.18,56.61) CC3.2 ; C1223.2 v8(18.64,76.68) ; v8(115.84,50.87) 116.13,51.16 CV788.2 ; v8(82.59,67.55) 82.69,67.65 UV6.T5 ; UV8.T5 84.07,47.52 v6(83.72,47.17) ; UV8.K1 v8(90.21,46.88) ; UV6.H1 v8(84.52,75.16) ; v8(82.94,40.25) 82.94,39.62 UV8.K13 v8(82.94,39.06) ; v8(79.56,33.55) QV152.4 ; v8(90.21,70.6) UV6.G10 ; CV159.2 93.45,64 CV158.2 92.88,63.66 92.99,63.56 CV773.2 ; v6(89.79,45.9) 89.7,45.81 89.19,45.81 UV8.K2 ; v2(88.05,47.52) 88.05,48.08 UV8.N1 ; CV773.2 v8(92.5,63.33) ; v6(87.29,67.52) 87.42,67.39 87.77,67.39 UV6.M10 ; UV8.E14 v8(84.77,35.78) ; v6(93.08,73.49) 93.44,73.13 UV6.B10 ; 82.13,71.9 82.08,71.9 81.76,72.22 v6(81.72,72.22) ; U711.5 41.98,76.63 v8(42.13,76.77) ; PC1813.2 v8(69.81,16.4) ; RC64.2 138.16,45.42 v8(138.16,45.84) ; v8(121.24,47.2) 121.48,47.44 QV151.1 ; UV6.B5 90.87,75.6 v6(91.21,75.6) ; RT184.2 v8(29.93,54.82) ; v8(148.32,50.86) 148.33,50.87 RC17.2 ; v8(41.53,16.22) 41.44,16.31 v8(41.44,16.62) ; UV8.K14 v8(81.99,38.66) ; CV776.2 v8(102.87,68.96) ; v2(89.12,35.12) 89.09,35.09 UV8.A12 ; UV6.H13 v8(91.33,67.94) ; CV212.2 v8(97.3,68.13) ; v6(84.46,42.32) 84.46,42.32 84.07,41.93 UV8.L10 ; 78.42,43.01 v8(77.86,43.01) ; PRV32.2 v8(44.78,64) ; CV326.2 v8(117.34,53.18) ; UV8.N1 v8(88.46,48.53) ; PCV44.2 v8(43.93,66.55) ; UV6.C4 89.43,75.91 88.97,75.91 v8(88.92,75.86) ; U6903.2 v8(11.13,31.59) ; UV8.C4 UV8.C3 ; UV8.C14 v8(85.93,34.68) ; UV6.K2 v8(83.83,73.03) ; v8(138.58,70.93) UZ8.5 ; C61.2 v8(51.63,45.61) ; v6(93.09,43.99) 92.67,43.58 UV8.E1 ; UV8.M10 v8(83.85,42.79) ; CZ235.2 v8(47.5,46.26) ; CV211.2 v8(103.45,68.93) ; UV8.R4 v8(85.21,48.05) ; PUV01.11 v8(42.34,62.86) ; C62.2 v8(51.62,44.99) ; CV221.2 v8(99.25,62.71) ; UV8.R14 v8(79.15,41.48) ; UV6.A1 v8(89.27,79.04) ; QV144.1 v8(117.34,55.37) ; UV8.L5 v8(86.57,44.37) ; UV6.A3 v8(90.05,77.99) ; UV6.N12 v6(87.78,65.67) ; RN193.1 v8(48.44,51.82) ; CC19.2 v8(151.77,36.15) ; 85.77,50.36 v8(86.08,50.67) ; UV6.K13 v8(91.17,66.8) ; CV214.2 v8(99.14,63.15) ; CV219.2 v8(101.75,69.01) ; UV8.A1 v8(95.13,41.01) ; UV6.C1 v8(87.46,77.88) ; RR167.2 v8(13.68,32.15) ; UV6.K1 v8(83.44,73.98) ; UV8.N3 v8(87.45,46.97) ; v8(90.72,66.24) UV6.K14 ; v6(60.51,53.35) 60.79,53.35 61.3,52.84 61.3,51.82 61.23,51.75 61.23,51.52 61.02,51.31 v6(60.75,51.31) 60.02,51.31 59.78,51.55 v8(58.14,51.55) v8(56.32,51.55) 56.08,51.55 55.34,50.81 v8(55.13,50.81) 54.97,50.97 53.14,50.97 v8(53.05,51.06) 52.87,51.23 52.87,51.63 52.02,52.49 51.52,52.49 51.04,52.97 v8(51.04,53) 51.04,55.87 51.5,56.33 v8(52,56.33) v8(53.56,56.33) 54.02,56.79 v6(54.02,58.56) 54.02,58.65 54.46,59.09 56.27,59.09 56.58,58.78 56.58,55.75 55.97,55.14 v6(55.43,55.14) 54.95,55.14 v8(54.61,54.81) 54.55,54.74 v8(54.55,54.17) v8(54.55,53.13) 54.77,52.9 v8(56.28,52.9) v8(59.17,52.9) 59.69,52.9 60.13,53.35 v6(60.51,53.35)
  TOP w0.305: US2.3 v8(27.88,74.98) ; US2.8 v8(27.88,78.25) ; US2.5 v8(29.23,76.32) ; US2.6 v8(29.22,76.82) ; US2.7 v8(28.38,78.23)
  TOP w0.356: CZ9.2 v8(115.72,29.49) ; v6(112.33,25.15) 111.95,25.15 111.75,24.94 CZ12.2
  TOP w0.381: UC18.3 111.48,26.41 v6(111.85,26.41)
  GND1 w0.203: 1.63,60.93 JUSBC1.5 ; JUSBC1.5 2.91,59.37 ; JUSBC1.5 4.19,60.15 ; JUSBC1.5 4.19,59.37 ; JUSBC1.5 1.63,59.37 ; JUSBC1.5 4.19,60.93 ; JUSBC1.5 2.91,60.93 ; JUSBC1.5 1.63,60.15 ; H13.1 128.48,61.74 ; H13.1 123.52,57.26 ; H13.1 126,57.26 ; H13.1 128.48,57.26 ; H13.1 123.52,59.5 ; H13.1 123.52,61.74 ; H13.1 128.48,59.5 ; H13.1 126,61.74 ; H19.1 27.97,69.52 ; H19.1 27.97,66.48 ; H19.1 24.93,69.52 ; H19.1 24.93,66.48 ; H19.1 26.45,65.92 ; H19.1 26.45,70.08 ; H19.1 24.37,68 ; H19.1 28.53,68 ; JHDMI1.20 4.81,35.28 ; JHDMI1.20 6.09,34.35 ; JHDMI1.20 3.53,35.28 ; JHDMI1.20 3.53,33.42 ; JHDMI1.20 4.81,33.42 ; JHDMI1.20 6.09,35.28 ; JHDMI1.20 3.53,34.35 ; H16.1 57.55,12.92 ; H16.1 58.11,11.4 ; H16.1 54.5,9.88 ; H16.1 54.5,12.92 ; H16.1 56.03,13.48 ; H16.1 53.94,11.4 ; H16.1 57.55,9.88 ; H16.1 56.03,9.32 ; 12.29,39.5 JHDMI1.2 ; JHDMI1.2 12.86,38.93 ; JHDMI1.2 13.43,39.5 ; JHDMI1.2 13.32,39.95 ; JHDMI1.2 12.41,39.95 ; JHDMI1.2 13.32,39.04 ; JHDMI1.2 12.41,39.04 ; JHDMI1.21 14.29,36.25 ; JHDMI1.21 14.29,35.32 ; JHDMI1.21 13.01,35.32 ; JHDMI1.21 13.01,37.18 ; JHDMI1.21 11.73,36.25 ; JHDMI1.21 11.73,37.18 ; JHDMI1.21 14.29,37.18 ; JHDMI1.21 11.73,35.32 ; 10.86,46.54 JHDMI1.17 ; JHDMI1.17 11.77,47.45 ; JHDMI1.17 10.74,47 ; JHDMI1.17 11.77,46.54 ; JHDMI1.17 11.88,47 ; JHDMI1.17 10.86,47.45 ; 77.59,56.44 H11.1 ; H11.1 77.02,58 ; H11.1 79.15,55.87 ; H11.1 81.28,58 ; H11.1 77.59,59.56 ; H11.1 79.15,60.13 ; H11.1 80.71,56.44 ; H11.1 80.71,59.56 ; H7.1 130.24,30 ; H7.1 129.62,31.67 ; H7.1 127.95,32.29 ; H7.1 129.62,28.33 ; H7.1 126.28,28.33 ; H7.1 125.66,30 ; H7.1 127.95,27.71 ; H7.1 126.28,31.67 ; 7.68,74.23 H10.1 ; H10.1 8.95,77.23 ; H10.1 7.22,75.5 ; H10.1 7.68,76.77 ; H10.1 10.68,75.5 ; H10.1 8.95,73.77 ; H10.1 10.22,76.77 ; H10.1 10.22,74.23 ; 2.91,71.07 JUSBC1.6 ; JUSBC1.6 4.19,71.85 ; JUSBC1.6 1.63,71.85 ; JUSBC1.6 1.63,71.07 ; JUSBC1.6 2.91,72.63 ; JUSBC1.6 4.19,71.07 ; JUSBC1.6 4.19,72.63 ; JUSBC1.6 1.63,72.63 ; H4.1 36.18,25.78 ; H4.1 35.62,24.26 ; H4.1 32.57,27.3 ; H4.1 32.57,24.26 ; H4.1 34.09,23.7 ; H4.1 32.01,25.78 ; H4.1 35.62,27.3 ; H4.1 34.09,27.86 ; JHDMI1.5 11.77,41.45 ; JHDMI1.5 11.77,40.54 ; JHDMI1.5 10.86,40.54 ; JHDMI1.5 10.86,41.45 ; JHDMI1.5 10.74,41 ; JHDMI1.5 11.88,41 ; H8.1 196.38,73.53 ; H8.1 194.14,73.53 ; H8.1 191.91,78.49 ; H8.1 194.14,78.49 ; H8.1 191.91,73.53 ; H8.1 196.38,78.49 ; H8.1 196.38,76.01 ; H8.1 191.91,76.01 ; H5.1 193.12,34.62 ; H5.1 189.78,31.29 ; H5.1 193.74,32.95 ; H5.1 189.78,34.62 ; H5.1 189.16,32.95 ; H5.1 193.12,31.29 ; H5.1 191.45,30.67 ; H5.1 191.45,35.24 ; JHDMI1.23 4.84,52.65 ; JHDMI1.23 2.28,53.58 ; JHDMI1.23 3.56,51.72 ; JHDMI1.23 3.56,53.58 ; JHDMI1.23 2.28,52.65 ; JHDMI1.23 4.84,51.72 ; JHDMI1.23 4.84,53.58 ; JHDMI1.23 2.28,51.72 ; H12.1 10.68,56.5 ; H12.1 10.22,55.23 ; H12.1 7.68,57.77 ; H12.1 7.68,55.23 ; H12.1 7.22,56.5 ; H12.1 8.95,58.23 ; H12.1 10.22,57.77 ; H12.1 8.95,54.77 ; 7.85,60.3 JUSBC1.1 ; JUSBC1.1 7.14,60.3 ; JUSBC1.1 7.14,60.69 ; 118.45,78.17 H42.1 ; H42.1 119.72,78.63 ; H42.1 117.18,81.17 ; H42.1 117.18,78.63 ; H42.1 120.18,79.9 ; H42.1 119.72,81.17 ; H42.1 116.72,79.9 ; JHDMI1.8 13.43,42.5 ; JHDMI1.8 12.41,42.04 ; JHDMI1.8 12.41,42.95 ; JHDMI1.8 13.32,42.04 ; JHDMI1.8 13.32,42.95 ; JHDMI1.8 12.29,42.5 ; 156.89,4.01 H2.1 ; H2.1 159.13,6.25 ; H2.1 158.52,4.62 ; H2.1 156.89,8.49 ; H2.1 155.26,7.88 ; H2.1 155.26,4.62 ; H2.1 154.65,6.25 ; H2.1 158.52,7.88 ; JUSBC1.4 8.59,71.71 ; JUSBC1.4 7.91,69.09 ; JUSBC1.4 7.91,71.71 ; JUSBC1.4 8.59,69.09 ; JUSBC1.4 7.14,71.71 ; 10.86,43.54 JHDMI1.11 ; JHDMI1.11 10.86,44.45 ; JHDMI1.11 11.88,44 ; JHDMI1.11 10.74,44 ; JHDMI1.11 11.77,44.45 ; JHDMI1.11 11.77,43.54 ; H9.1 21.29,6.34 ; H9.1 21.78,5 ; H9.1 18.61,6.34 ; H9.1 19.95,6.83 ; H9.1 18.61,3.66 ; H9.1 19.95,3.17 ; H9.1 21.29,3.66 ; H9.1 18.12,5 ; 43.87,76.5 H18.1 ; H18.1 48.03,76.5 ; H18.1 47.47,78.02 ; H18.1 45.95,78.58 ; H18.1 44.43,78.02 ; H18.1 45.95,74.42 ; H18.1 47.47,74.98 ; H18.1 44.43,74.98 ; JHDMI1.22 14.29,50.75 ; JHDMI1.22 11.73,51.68 ; JHDMI1.22 14.29,49.82 ; JHDMI1.22 13.01,51.68 ; JHDMI1.22 13.01,49.82 ; JHDMI1.22 11.73,49.82 ; JHDMI1.22 11.73,50.75 ; JHDMI1.22 14.29,51.68 ; 7.85,71.7 JUSBC1.2 ; JUSBC1.2 7.14,71.31 ; JUSBC1.2 7.14,71.7 ; JUSBC1.3 8.59,62.91 ; JUSBC1.3 7.14,60.29 ; JUSBC1.3 7.91,60.29 ; JUSBC1.3 7.91,62.91 ; JUSBC1.3 8.59,60.29
  IN1 w0.102: v2(6.48,10.18) 7.53,9.13 16.53,9.13 16.67,9.28 23.76,9.28 v2(23.98,9.05) ; 137.88,37.19 v9(137.88,36.93) 137.88,36.47 v9(137.96,36.39) v9(137.96,35.51) 137.78,35.33 137.77,35.33 v9(137.56,35.12) 137.56,35.1 v9(136.89,34.43) 136.84,34.43 136.08,33.67 v9(136.08,33.63) 136.07,33.63 135.56,33.11 v9(135.34,33.11) 135.28,33.05 v9(134.58,33.05) v9(133.82,33.05) 133.5,33.05 133.33,32.87 v9(133.01,32.87) v9(132.61,33.27) v9(132.61,33.83) 133.13,34.35 v9(133.52,34.35) v9(134.53,34.35) v9(135.55,34.35) 135.66,34.35 v9(136.41,35.1) 136.41,35.11 v9(137.02,35.73) 137.02,35.73 v9(137.02,36.4) 137.02,37.04 v9(137.02,37.04) 137.32,37.35 v9(137.72,37.35) 137.88,37.19
  IN1 w0.203: v2(152.03,42.09) 152.22,42.23 152.26,42.51 v4(152.25,42.53) v2(152.44,42.82) ; v2(152.44,43.38) v4(152.25,43.65) v2(152.44,43.94) ; v2(152.44,49.01) v4(152.1,49.01) ; v2(152.44,47.86) v4(152.25,48.13) v2(152.44,48.42) ; v2(152.44,47.31) v4(152.24,47.03) 152.4,46.81 v2(152.44,46.76) ; v2(157.93,44.52) v4(157.6,44.52) ; v2(152.44,45.66) v4(152.25,45.93) v2(152.44,46.22) ; v2(157.93,46.38) v4(157.59,46.38) ; v2(154.88,44.55) v4(155.23,44.55) ; v2(152.42,45.08) 152.31,44.92 v4(152.22,44.79) v2(152.42,44.52)
  IN1 w0.254: v4(43.4,23.95) 43.48,23.95 v2(43.71,24.18) ; v2(46.73,27.21) 46.78,27.21 v4(47.01,26.98) ; v2(46.73,24.18) v4(46.16,23.61) 46.73,23.03 v2(46.73,22.66) ; v2(155.65,36.01) 156.31,35.36 v4(156.64,35.36) ; v2(45.23,22.66) 45.23,22.34 v4(45.17,22.28) ; v4(150.09,39.39) 150.09,38.98 150.43,38.64 v2(150.7,38.64) ; v2(149.28,49.67) 149,49.7 149,49.71 v4(148.92,49.72) ; v2(174.31,40.58) v4(174.57,40.84) ; v9(146.69,33.69) 146.7,33.68 v9(147.44,33.68) 147.45,33.69 v9(148.29,33.69) v9(148.98,34.38) v9(149.49,34.38) v9(149.99,34.38) v9(150.5,34.38) v9(151.01,34.38) v9(151.52,34.38) 152.36,34.38 153.03,33.71 v9(153.25,33.71) v9(153.76,33.71) v9(154.27,33.71) v9(154.78,33.71) v9(155.29,33.71) v9(155.79,33.71) v9(156.3,33.71) v9(156.81,33.71) v9(157.32,33.71) v9(157.83,33.71) v9(158.33,33.71) v9(160.01,33.71) v9(160.52,33.71) v9(161.03,33.71) v9(161.54,33.71) v9(162.05,33.71) v9(162.55,33.71) v9(163.06,33.71) v9(163.57,33.71) v9(164.08,33.71) v9(164.96,32.83) 164.97,32.82 v9(165.38,32.82) v9(165.88,32.82) v9(166.46,32.82) v9(167.23,32.82) v9(168.01,32.82) 168.06,32.77 169.77,32.77 v9(169.77,32.78) v9(170.61,32.78) v9(171.1,32.78) v9(171.84,32.78) 172.5,32.78 v9(172.5,32.78) v9(173.16,32.78) 173.98,32.78 v9(173.98,32.78) v9(174.59,32.78) v9(175.22,32.78) 175.84,32.78 v9(175.85,32.78) 176.87,32.78 v9(176.88,32.78) v9(177.39,32.78) v9(177.89,32.78) v9(178.4,32.78) v9(178.91,32.78) v9(179.42,32.78) v9(179.93,32.78) v9(180.43,32.78) v9(180.94,32.78) v9(181.45,32.78) v9(181.96,32.78) v9(182.47,32.78) v9(182.97,32.78) v9(183.48,32.78) v9(183.99,32.78) v9(184.5,32.78) v9(185.01,32.78) v9(185.51,32.78) v9(186.02,32.78) v9(186.66,32.78) 186.84,32.6 186.85,32.6 v9(187.1,32.35) 187.11,32.35 v9(187.4,32.05) v9(187.73,31.72) v9(188.1,31.36) v9(188.47,30.99) v9(188.89,30.57) v9(189.28,30.18) v9(189.56,29.9) v9(190.03,29.43) v9(190.33,29.12) v9(190.7,28.75) 190.95,28.51 v9(191.03,28.51) 191.23,28.3 v9(191.42,28.3) v9(192.11,28.3) 192.84,28.3 v9(192.84,28.3) 193.36,27.78 v9(193.38,27.78) 193.53,27.63 v2(194.14,27.63) 194.31,27.8 v9(194.67,27.8) 195.2,27.27 v9(195.22,27.27) 195.22,27.07 v9(195.66,26.64) v9(196.19,26.64) 196.72,26.11 v9(196.73,26.11) 197.12,25.73 v9(197.12,25.71) 197.44,25.39 v4(197.44,24.52) 197.44,23.7 197.1,23.36 v4(197.06,23.36) 197.04,23.34 v2(196.48,23.34) 196.25,23.34 v9(195.95,23.64) v9(195.95,24.78) 195.95,24.86 195.65,25.16 v4(195.62,25.16) 195.58,25.13 v9(194.37,25.13) 194.2,25.3 v4(193.52,25.3) 193.38,25.3 v9(193.03,25.66) v9(192.42,25.66) v9(191.75,24.99) v9(191.75,24.11) 192.18,23.69 v9(192.19,23.69) 192.21,23.67 v9(193.04,23.67) 193.69,23.67 v9(193.72,23.63) 194.07,23.28 v9(194.07,23.07) 194.07,22.39 v9(193.88,22.2) 193.55,21.87 v4(193.55,21.77) v9(193.06,21.77) 192.83,21.77 192.47,21.41 v9(192.47,21.23) v9(192.47,20.87) v9(192.47,20.31) v9(192.47,19.74) v9(192.47,19.2) 192.47,19.2 v9(192.47,18.68) v9(192.47,18.15) v9(192.47,17.56) 192.47,17.16 v9(192.17,16.86) 192.02,16.7 v9(191.68,16.7) 191.61,16.64 v9(190.9,16.64) 190.51,17.02 v9(190.51,17.22) v9(190.16,17.57) v9(190.16,18.28) 190.16,19.02 v9(190.17,19.03) 190.16,19.04 v9(190.16,19.75) 190.16,19.75 v9(190.16,20.16) v9(190.16,20.77) v9(190.16,21.35) v9(189.59,21.92) v9(189.19,22.32) v9(189.19,23.05) 189.19,23.66 v9(189.19,23.66) 189.19,24.43 v9(188.92,24.71) v9(188.38,25.24) v9(187.95,25.67) v9(187.57,26.05) v9(187.19,26.43) v9(186.71,26.92) v9(186.27,27.35) v9(185.83,27.79) v9(185.41,28.21) v9(185.08,28.54) v9(184.47,28.54) v9(183.96,28.54) v9(183.5,28.54) v9(183.05,28.54) v9(182.64,28.54) v9(182.18,28.54) v9(181.72,28.54) v9(181.25,28.54) v9(180.75,28.54) v9(180.24,28.54) v9(179.73,28.54) v9(179.22,28.54) v9(178.71,28.54) v9(178.21,28.54) v9(177.7,28.54) v9(177.19,28.54) v9(176.68,28.54) v9(176.17,28.54) v9(175.6,28.54) v9(175.09,28.54) v9(174.65,28.54) v9(174.14,28.54) v9(173.63,28.54) v9(173.06,28.54) v9(172.62,28.54) v9(172.11,28.54) v9(171.6,28.54) v9(171.09,28.54) v9(170.59,28.54) v9(170.08,28.54) v9(169.63,28.54) v9(169.13,28.54) v9(168.43,28.54) v9(167.98,28.54) v9(167.54,28.54) v9(166.9,28.54) v9(166.46,28.54) v9(166.01,28.54) v9(165.44,28.54) v9(165,28.54) v9(164.49,28.54) v9(163.98,28.54) v9(163.47,28.54) 163.02,28.54 v9(162.91,28.65) v9(162.49,29.07) 161.99,29.57 v9(161.57,29.57) v9(161.06,29.57) v9(160.55,29.57) v9(160.04,29.57) v9(159.53,29.57) v9(159.03,29.57) v9(158.52,29.57) v9(158.01,29.57) v9(157.5,29.57) v9(156.99,29.57) v9(156.49,29.57) v9(155.98,29.57) v9(155.47,29.57) v9(154.96,29.57) v9(154.45,29.57) v9(153.95,29.57) 153.72,29.34 v9(153.25,29.34) v9(152.1,29.34) v9(151.3,29.34) 151.29,29.34 v9(150.45,29.34) 150.44,29.33 v9(149.68,29.33) v9(148.69,29.33) v9(147.73,29.33) 147.71,29.34 v9(146.92,29.34) v9(146.04,29.34) v9(145.22,29.34) v9(144.43,29.34) 144.42,29.35 v9(143.73,29.35) v9(143.22,29.35) 142.65,29.35 v9(142.47,29.53) v9(141.92,30.08) 141.33,30.67 v9(141.33,30.68) 141.19,30.82 v9(141.19,31.4) 141.19,31.72 v9(140.67,32.23) 140.16,32.75 v9(140.16,32.75) 139.59,33.32 v9(139.59,33.33) 139.59,34.06 v9(139.61,34.08) 139.61,34.37 v9(139.25,34.73) 138.85,34.73 v9(138.41,35.17) 138.41,35.3 138.78,35.67 138.78,37 v9(138.41,37.36) ; v2(179.95,41.4) v4(180.36,41.4) ; v4(48.72,25.71) 48.69,25.68 v2(48.26,25.68) ; v2(45.23,27.21) 45,26.97 v4(45,26.9)
  IN1 w0.381: v4(103.17,55.56) v2(103.17,56.09)
  GND2 w0.203: 32.01,25.78 H4.1 ; H4.1 34.09,27.86 ; H4.1 32.57,27.3 ; H4.1 35.62,24.26 ; H4.1 34.09,23.7 ; H4.1 35.62,27.3 ; H4.1 32.57,24.26 ; H4.1 36.18,25.78 ; H13.1 128.48,61.74 ; H13.1 126,61.74 ; H13.1 123.52,59.5 ; H13.1 123.52,57.26 ; H13.1 128.48,59.5 ; H13.1 128.48,57.26 ; H13.1 123.52,61.74 ; H13.1 126,57.26 ; JHDMI1.2 13.43,39.5 ; JHDMI1.2 12.29,39.5 ; JHDMI1.2 13.32,39.95 ; JHDMI1.2 12.86,38.93 ; JHDMI1.2 12.41,39.95 ; JHDMI1.2 13.32,39.04 ; JHDMI1.2 12.41,39.04 ; JUSBC1.6 4.19,71.07 ; JUSBC1.6 4.19,71.85 ; JUSBC1.6 1.63,72.63 ; JUSBC1.6 2.91,71.07 ; JUSBC1.6 1.63,71.07 ; JUSBC1.6 4.19,72.63 ; JUSBC1.6 2.91,72.63 ; JUSBC1.6 1.63,71.85 ; 189.16,32.95 H5.1 ; H5.1 193.12,31.29 ; H5.1 193.74,32.95 ; H5.1 191.45,30.67 ; H5.1 189.78,34.62 ; H5.1 191.45,35.24 ; H5.1 193.12,34.62 ; H5.1 189.78,31.29 ; H11.1 81.28,58 ; H11.1 79.15,55.87 ; H11.1 77.59,59.56 ; H11.1 80.71,56.44 ; H11.1 77.02,58 ; H11.1 80.71,59.56 ; H11.1 79.15,60.13 ; H11.1 77.59,56.44 ; 7.14,60.29 JUSBC1.3 ; JUSBC1.3 8.59,62.91 ; JUSBC1.3 7.91,60.29 ; JUSBC1.3 8.59,60.29 ; JUSBC1.3 7.91,62.91 ; 10.74,41 JHDMI1.5 ; JHDMI1.5 11.77,40.54 ; JHDMI1.5 11.88,41 ; JHDMI1.5 10.86,41.45 ; JHDMI1.5 11.77,41.45 ; JHDMI1.5 10.86,40.54 ; H9.1 21.78,5 ; H9.1 21.29,3.66 ; H9.1 19.95,6.83 ; H9.1 21.29,6.34 ; H9.1 18.61,6.34 ; H9.1 19.95,3.17 ; H9.1 18.12,5 ; H9.1 18.61,3.66 ; H18.1 45.95,78.58 ; H18.1 45.95,74.42 ; H18.1 47.47,78.02 ; H18.1 44.43,74.98 ; H18.1 43.87,76.5 ; H18.1 48.03,76.5 ; H18.1 44.43,78.02 ; H18.1 47.47,74.98 ; 191.91,76.01 H8.1 ; H8.1 194.14,78.49 ; H8.1 196.38,78.49 ; H8.1 196.38,73.53 ; H8.1 194.14,73.53 ; H8.1 191.91,78.49 ; H8.1 196.38,76.01 ; H8.1 191.91,73.53 ; JHDMI1.23 4.84,52.65 ; JHDMI1.23 4.84,53.58 ; JHDMI1.23 3.56,53.58 ; JHDMI1.23 2.28,51.72 ; JHDMI1.23 2.28,53.58 ; JHDMI1.23 4.84,51.72 ; JHDMI1.23 3.56,51.72 ; JHDMI1.23 2.28,52.65 ; H42.1 119.72,81.17 ; H42.1 119.72,78.63 ; H42.1 117.18,78.63 ; H42.1 118.45,78.17 ; H42.1 116.72,79.9 ; H42.1 120.18,79.9 ; H42.1 117.18,81.17 ; JHDMI1.22 13.01,51.68 ; JHDMI1.22 14.29,51.68 ; JHDMI1.22 14.29,49.82 ; JHDMI1.22 14.29,50.75 ; JHDMI1.22 11.73,50.75 ; JHDMI1.22 13.01,49.82 ; JHDMI1.22 11.73,51.68 ; JHDMI1.22 11.73,49.82 ; H12.1 10.22,55.23 ; H12.1 8.95,54.77 ; H12.1 7.68,55.23 ; H12.1 7.68,57.77 ; H12.1 10.68,56.5 ; H12.1 8.95,58.23 ; H12.1 7.22,56.5 ; H12.1 10.22,57.77 ; 13.01,35.32 JHDMI1.21 ; JHDMI1.21 11.73,36.25 ; JHDMI1.21 14.29,35.32 ; JHDMI1.21 13.01,37.18 ; JHDMI1.21 14.29,37.18 ; JHDMI1.21 11.73,35.32 ; JHDMI1.21 14.29,36.25 ; JHDMI1.21 11.73,37.18 ; H16.1 58.11,11.4 ; H16.1 57.55,12.92 ; H16.1 54.5,9.88 ; H16.1 53.94,11.4 ; H16.1 57.55,9.88 ; H16.1 56.03,9.32 ; H16.1 56.03,13.48 ; H16.1 54.5,12.92 ; 7.14,71.31 JUSBC1.2 ; JUSBC1.2 7.85,71.7 ; JUSBC1.2 7.14,71.7 ; JUSBC1.5 4.19,59.37 ; JUSBC1.5 1.63,60.15 ; JUSBC1.5 2.91,59.37 ; JUSBC1.5 1.63,60.93 ; JUSBC1.5 1.63,59.37 ; JUSBC1.5 4.19,60.93 ; JUSBC1.5 2.91,60.93 ; JUSBC1.5 4.19,60.15 ; 12.41,42.95 JHDMI1.8 ; JHDMI1.8 13.43,42.5 ; JHDMI1.8 13.32,42.95 ; JHDMI1.8 13.32,42.04 ; JHDMI1.8 12.41,42.04 ; JHDMI1.8 12.29,42.5 ; 154.65,6.25 H2.1 ; H2.1 156.89,8.49 ; H2.1 158.52,4.62 ; H2.1 158.52,7.88 ; H2.1 156.89,4.01 ; H2.1 159.13,6.25 ; H2.1 155.26,4.62 ; H2.1 155.26,7.88 ; 8.95,73.77 H10.1 ; H10.1 8.95,77.23 ; H10.1 7.22,75.5 ; H10.1 10.22,76.77 ; H10.1 10.22,74.23 ; H10.1 10.68,75.5 ; H10.1 7.68,74.23 ; H10.1 7.68,76.77 ; JHDMI1.20 4.81,35.28 ; JHDMI1.20 3.53,35.28 ; JHDMI1.20 3.53,33.42 ; JHDMI1.20 4.81,33.42 ; JHDMI1.20 6.09,35.28 ; JHDMI1.20 6.09,34.35 ; JHDMI1.20 3.53,34.35 ; JHDMI1.11 11.77,44.45 ; JHDMI1.11 10.86,44.45 ; JHDMI1.11 10.74,44 ; JHDMI1.11 11.77,43.54 ; JHDMI1.11 10.86,43.54 ; JHDMI1.11 11.88,44 ; 127.95,27.71 H7.1 ; H7.1 126.28,28.33 ; H7.1 125.66,30 ; H7.1 130.24,30 ; H7.1 126.28,31.67 ; H7.1 129.62,28.33 ; H7.1 129.62,31.67 ; H7.1 127.95,32.29 ; JHDMI1.17 11.77,46.54 ; JHDMI1.17 10.86,47.45 ; JHDMI1.17 10.74,47 ; JHDMI1.17 11.88,47 ; JHDMI1.17 10.86,46.54 ; JHDMI1.17 11.77,47.45 ; 24.93,66.48 H19.1 ; H19.1 27.97,69.52 ; H19.1 24.93,69.52 ; H19.1 26.45,70.08 ; H19.1 24.37,68 ; H19.1 28.53,68 ; H19.1 26.45,65.92 ; H19.1 27.97,66.48 ; 7.91,69.09 JUSBC1.4 ; JUSBC1.4 8.59,71.71 ; JUSBC1.4 7.14,71.71 ; JUSBC1.4 8.59,69.09 ; JUSBC1.4 7.91,71.71 ; 7.85,60.3 JUSBC1.1 ; JUSBC1.1 7.14,60.69 ; JUSBC1.1 7.14,60.3
  VCC w0.203: 7.68,74.23 H10.1 ; H10.1 10.68,75.5 ; H10.1 10.22,76.77 ; H10.1 8.95,77.23 ; H10.1 7.22,75.5 ; H10.1 7.68,76.77 ; H10.1 10.22,74.23 ; H10.1 8.95,73.77 ; 12.41,42.04 JHDMI1.8 ; JHDMI1.8 13.32,42.95 ; JHDMI1.8 13.32,42.04 ; JHDMI1.8 12.29,42.5 ; JHDMI1.8 12.41,42.95 ; JHDMI1.8 13.43,42.5 ; 10.86,44.45 JHDMI1.11 ; JHDMI1.11 11.77,43.54 ; JHDMI1.11 11.77,44.45 ; JHDMI1.11 10.74,44 ; JHDMI1.11 10.86,43.54 ; JHDMI1.11 11.88,44 ; 3.53,33.42 JHDMI1.20 ; JHDMI1.20 3.53,35.28 ; JHDMI1.20 6.09,35.28 ; JHDMI1.20 3.53,34.35 ; JHDMI1.20 4.81,33.42 ; JHDMI1.20 6.09,34.35 ; JHDMI1.20 4.81,35.28 ; JHDMI1.21 14.29,36.25 ; JHDMI1.21 13.01,37.18 ; JHDMI1.21 11.73,36.25 ; JHDMI1.21 14.29,37.18 ; JHDMI1.21 11.73,35.32 ; JHDMI1.21 11.73,37.18 ; JHDMI1.21 13.01,35.32 ; JHDMI1.21 14.29,35.32 ; H5.1 193.12,34.62 ; H5.1 189.78,34.62 ; H5.1 191.45,35.24 ; H5.1 189.16,32.95 ; H5.1 193.12,31.29 ; H5.1 191.45,30.67 ; H5.1 189.78,31.29 ; H5.1 193.74,32.95 ; JHDMI1.17 11.88,47 ; JHDMI1.17 11.77,47.45 ; JHDMI1.17 10.74,47 ; JHDMI1.17 10.86,47.45 ; JHDMI1.17 10.86,46.54 ; JHDMI1.17 11.77,46.54 ; 12.29,39.5 JHDMI1.2 ; JHDMI1.2 12.41,39.04 ; JHDMI1.2 12.41,39.95 ; JHDMI1.2 13.32,39.04 ; JHDMI1.2 13.32,39.95 ; JHDMI1.2 13.43,39.5 ; JHDMI1.2 12.86,38.93 ; 7.14,60.3 JUSBC1.1 ; JUSBC1.1 7.85,60.3 ; JUSBC1.1 7.14,60.69 ; JUSBC1.3 8.59,60.29 ; JUSBC1.3 7.91,60.29 ; JUSBC1.3 7.14,60.29 ; 7.14,71.7 JUSBC1.2 ; JUSBC1.2 7.85,71.7 ; JUSBC1.2 7.14,71.31 ; H12.1 10.22,55.23 ; H12.1 8.95,54.77 ; H12.1 7.22,56.5 ; H12.1 7.68,55.23 ; H12.1 10.68,56.5 ; H12.1 7.68,57.77 ; H12.1 10.22,57.77 ; H12.1 8.95,58.23 ; 2.28,52.65 JHDMI1.23 ; JHDMI1.23 4.84,51.72 ; JHDMI1.23 3.56,51.72 ; JHDMI1.23 2.28,51.72 ; JHDMI1.23 2.28,53.58 ; JHDMI1.23 3.56,53.58 ; JHDMI1.23 4.84,52.65 ; JHDMI1.23 4.84,53.58 ; JUSBC1.5 4.19,60.93 ; JUSBC1.5 4.19,59.37 ; JUSBC1.5 2.91,60.93 ; JUSBC1.5 1.63,60.15 ; JUSBC1.5 4.19,60.15 ; JUSBC1.5 1.63,59.37 ; JUSBC1.5 1.63,60.93 ; JUSBC1.5 2.91,59.37 ; H8.1 196.38,73.53 ; H8.1 196.38,76.01 ; H8.1 191.91,78.49 ; H8.1 191.91,76.01 ; H8.1 191.91,73.53 ; H8.1 194.14,73.53 ; H8.1 194.14,78.49 ; H8.1 196.38,78.49 ; 10.74,41 JHDMI1.5 ; JHDMI1.5 11.88,41 ; JHDMI1.5 11.77,40.54 ; JHDMI1.5 11.77,41.45 ; JHDMI1.5 10.86,41.45 ; JHDMI1.5 10.86,40.54 ; JHDMI1.22 14.29,51.68 ; JHDMI1.22 13.01,49.82 ; JHDMI1.22 14.29,50.75 ; JHDMI1.22 13.01,51.68 ; JHDMI1.22 11.73,49.82 ; JHDMI1.22 14.29,49.82 ; JHDMI1.22 11.73,51.68 ; JHDMI1.22 11.73,50.75 ; JUSBC1.4 8.59,71.71 ; JUSBC1.4 7.14,71.71 ; JUSBC1.4 7.91,71.71 ; 2.91,71.07 JUSBC1.6 ; JUSBC1.6 4.19,72.63 ; JUSBC1.6 4.19,71.07 ; JUSBC1.6 1.63,71.07 ; JUSBC1.6 4.19,71.85 ; JUSBC1.6 1.63,72.63 ; JUSBC1.6 1.63,71.85 ; JUSBC1.6 2.91,72.63
  IN2 w0.254: 193.51,25.3 193.51,25.17 194.02,24.66 194.02,22.7 193.55,22.23 v4(193.55,21.77) 193.55,21.71 193.96,21.29 194.58,21.29 195.29,22.01 195.29,23.16 195.26,23.19 v4(195.26,24.53) 195.26,24.91 195.52,25.16 v4(195.62,25.16) 195.12,25.66 195.12,25.66 192.9,27.89 191.5,27.89 186.32,33.06 v4(186.32,33.66) 186.09,33.89 186.09,35.35 182.9,38.54 v4(182.9,40.96) 182.85,41.01 v4(182.85,44.69) 182.85,57.2 182.79,57.27 182.79,57.27 177.43,62.63 161.34,62.63 161.34,62.64 158.29,62.64 158.28,62.64 152.88,62.64 v4(152.63,62.38) 152.47,62.54 138.37,62.54 v4(138.22,62.39) 138.1,62.27 138.06,62.27 v6(137.4,61.6) 137.61,61.6 138,61.21 138.53,61.21 138.77,61.45 v4(138.89,61.45) 138.98,61.37 150.14,61.37 150.39,61.11 153.12,61.11 v4(153.52,61.51) 153.54,61.51 153.61,61.44 176.87,61.44 178.88,59.43 178.88,58.95 181.74,56.09 v4(181.74,52.79) 181.74,45.02 181.74,45.01 181.74,44.64 181.74,44.63 v4(181.74,44.48) 181.66,44.39 181.66,41.06 v4(181.73,40.99) 181.73,38.08 182.74,37.07 182.74,36.22 184.87,34.09 v4(184.87,33.29) 184.87,32.87 187.09,30.65 187.09,30.4 190.9,26.59 192.27,26.59 193.51,25.36 193.51,25.3 ; 193.51,25.3 v4(193.52,25.3)
  GND3 w0.203: JHDMI1.21 13.01,37.18 ; JHDMI1.21 14.29,37.18 ; JHDMI1.21 11.73,37.18 ; JHDMI1.21 13.01,35.32 ; JHDMI1.21 11.73,35.32 ; JHDMI1.21 14.29,36.25 ; JHDMI1.21 14.29,35.32 ; JHDMI1.21 11.73,36.25 ; H11.1 80.71,56.44 ; H11.1 80.71,59.56 ; H11.1 77.59,59.56 ; H11.1 79.15,60.13 ; H11.1 81.28,58 ; H11.1 77.02,58 ; H11.1 77.59,56.44 ; H11.1 79.15,55.87 ; H4.1 34.09,27.86 ; H4.1 32.57,27.3 ; H4.1 35.62,27.3 ; H4.1 32.01,25.78 ; H4.1 35.62,24.26 ; H4.1 34.09,23.7 ; H4.1 36.18,25.78 ; H4.1 32.57,24.26 ; H8.1 196.38,76.01 ; H8.1 194.14,73.53 ; H8.1 191.91,76.01 ; H8.1 194.14,78.49 ; H8.1 191.91,73.53 ; H8.1 196.38,73.53 ; H8.1 191.91,78.49 ; H8.1 196.38,78.49 ; 2.91,71.07 JUSBC1.6 ; JUSBC1.6 1.63,71.07 ; JUSBC1.6 4.19,72.63 ; JUSBC1.6 2.91,72.63 ; JUSBC1.6 1.63,72.63 ; JUSBC1.6 4.19,71.85 ; JUSBC1.6 4.19,71.07 ; JUSBC1.6 1.63,71.85 ; JUSBC1.4 8.59,71.71 ; JUSBC1.4 8.59,69.09 ; JUSBC1.4 7.14,71.71 ; JUSBC1.4 7.91,69.09 ; JUSBC1.4 7.91,71.71 ; JHDMI1.20 4.81,35.28 ; JHDMI1.20 3.53,35.28 ; JHDMI1.20 6.09,34.35 ; JHDMI1.20 6.09,35.28 ; JHDMI1.20 3.53,34.35 ; JHDMI1.20 4.81,33.42 ; JHDMI1.20 3.53,33.42 ; 10.86,40.54 JHDMI1.5 ; JHDMI1.5 10.86,41.45 ; JHDMI1.5 11.88,41 ; JHDMI1.5 10.74,41 ; JHDMI1.5 11.77,40.54 ; JHDMI1.5 11.77,41.45 ; 10.86,46.54 JHDMI1.17 ; JHDMI1.17 11.77,47.45 ; JHDMI1.17 10.86,47.45 ; JHDMI1.17 10.74,47 ; JHDMI1.17 11.88,47 ; JHDMI1.17 11.77,46.54 ; JHDMI1.22 14.29,49.82 ; JHDMI1.22 13.01,49.82 ; JHDMI1.22 14.29,51.68 ; JHDMI1.22 11.73,49.82 ; JHDMI1.22 14.29,50.75 ; JHDMI1.22 11.73,50.75 ; JHDMI1.22 13.01,51.68 ; JHDMI1.22 11.73,51.68 ; 1.63,60.93 JUSBC1.5 ; JUSBC1.5 1.63,59.37 ; JUSBC1.5 4.19,60.93 ; JUSBC1.5 2.91,60.93 ; JUSBC1.5 4.19,60.15 ; JUSBC1.5 4.19,59.37 ; JUSBC1.5 2.91,59.37 ; JUSBC1.5 1.63,60.15 ; H5.1 193.12,31.29 ; H5.1 191.45,35.24 ; H5.1 193.12,34.62 ; H5.1 189.78,34.62 ; H5.1 193.74,32.95 ; H5.1 191.45,30.67 ; H5.1 189.16,32.95 ; H5.1 189.78,31.29 ; H7.1 127.95,32.29 ; H7.1 129.62,31.67 ; H7.1 129.62,28.33 ; H7.1 130.24,30 ; H7.1 126.28,28.33 ; H7.1 127.95,27.71 ; H7.1 125.66,30 ; H7.1 126.28,31.67 ; 12.29,39.5 JHDMI1.2 ; JHDMI1.2 13.32,39.95 ; JHDMI1.2 13.43,39.5 ; JHDMI1.2 13.32,39.04 ; JHDMI1.2 12.41,39.95 ; JHDMI1.2 12.86,38.93 ; JHDMI1.2 12.41,39.04 ; JHDMI1.23 4.84,52.65 ; JHDMI1.23 2.28,52.65 ; JHDMI1.23 2.28,53.58 ; JHDMI1.23 2.28,51.72 ; JHDMI1.23 4.84,51.72 ; JHDMI1.23 3.56,53.58 ; JHDMI1.23 3.56,51.72 ; JHDMI1.23 4.84,53.58 ; H13.1 128.48,59.5 ; H13.1 123.52,61.74 ; H13.1 126,61.74 ; H13.1 128.48,61.74 ; H13.1 128.48,57.26 ; H13.1 123.52,59.5 ; H13.1 126,57.26 ; H13.1 123.52,57.26 ; H9.1 21.78,5 ; H9.1 19.95,6.83 ; H9.1 19.95,3.17 ; H9.1 21.29,6.34 ; H9.1 18.12,5 ; H9.1 18.61,3.66 ; H9.1 21.29,3.66 ; H9.1 18.61,6.34 ; 7.14,71.7 JUSBC1.2 ; JUSBC1.2 7.85,71.7 ; JUSBC1.2 7.14,71.31 ; H16.1 56.03,13.48 ; H16.1 58.11,11.4 ; H16.1 54.5,9.88 ; H16.1 56.03,9.32 ; H16.1 57.55,12.92 ; H16.1 57.55,9.88 ; H16.1 53.94,11.4 ; H16.1 54.5,12.92 ; 7.85,60.3 JUSBC1.1 ; JUSBC1.1 7.14,60.69 ; JUSBC1.1 7.14,60.3 ; H19.1 27.97,69.52 ; H19.1 24.93,69.52 ; H19.1 27.97,66.48 ; H19.1 24.37,68 ; H19.1 26.45,65.92 ; H19.1 28.53,68 ; H19.1 24.93,66.48 ; H19.1 26.45,70.08 ; JHDMI1.11 11.77,44.45 ; JHDMI1.11 11.88,44 ; JHDMI1.11 10.86,44.45 ; JHDMI1.11 11.77,43.54 ; JHDMI1.11 10.86,43.54 ; JHDMI1.11 10.74,44 ; 155.26,7.88 H2.1 ; H2.1 158.52,7.88 ; H2.1 154.65,6.25 ; H2.1 158.52,4.62 ; H2.1 155.26,4.62 ; H2.1 156.89,8.49 ; H2.1 159.13,6.25 ; H2.1 156.89,4.01 ; 7.22,56.5 H12.1 ; H12.1 8.95,54.77 ; H12.1 10.22,55.23 ; H12.1 7.68,57.77 ; H12.1 7.68,55.23 ; H12.1 8.95,58.23 ; H12.1 10.22,57.77 ; H12.1 10.68,56.5 ; JHDMI1.8 13.43,42.5 ; JHDMI1.8 12.41,42.95 ; JHDMI1.8 12.41,42.04 ; JHDMI1.8 13.32,42.04 ; JHDMI1.8 13.32,42.95 ; JHDMI1.8 12.29,42.5 ; 7.14,60.29 JUSBC1.3 ; JUSBC1.3 8.59,60.29 ; JUSBC1.3 7.91,60.29 ; JUSBC1.3 8.59,62.91 ; JUSBC1.3 7.91,62.91 ; 44.43,78.02 H18.1 ; H18.1 47.47,78.02 ; H18.1 47.47,74.98 ; H18.1 43.87,76.5 ; H18.1 44.43,74.98 ; H18.1 48.03,76.5 ; H18.1 45.95,78.58 ; H18.1 45.95,74.42 ; H10.1 8.95,77.23 ; H10.1 8.95,73.77 ; H10.1 7.68,74.23 ; H10.1 7.22,75.5 ; H10.1 10.68,75.5 ; H10.1 7.68,76.77 ; H10.1 10.22,74.23 ; H10.1 10.22,76.77 ; H42.1 120.18,79.9 ; H42.1 119.72,78.63 ; H42.1 118.45,78.17 ; H42.1 117.18,81.17 ; H42.1 116.72,79.9 ; H42.1 117.18,78.63 ; H42.1 119.72,81.17
  IN3 w0.102: v5(197.4,24.16) v4(197.44,24.52)
  IN3 w0.152: 136.04,62.3 135.78,62.03 135.87,61.93 135.87,60.97 135.8,60.9 135.8,60.2 135.98,60.03 135.98,58.5 v5(135.78,58.3) 135.9,58.17 135.9,56.72 136.09,56.53 136.09,56.13 136.92,55.31 136.92,55.04 136.9,55.02 136.9,54.97 136.38,54.45 134.9,54.45 132.95,56.4 132.95,56.5 132.94,56.51 132.94,56.96 132.95,56.96 132.95,57.32 133.25,57.62 133.25,57.83 133.37,57.96 133.37,58.53 133.39,58.59 133.39,63.48 133.44,63.53 v5(133.44,63.6) 133.44,63.61 133.28,63.76 133.28,68.83 134.11,69.66 v5(134.96,69.66) 135.69,69.66 v5(136.54,68.81) 137.06,68.3 137.06,65.64 136.04,64.62 136.04,62.3
  IN3 w0.203: v5(23.74,55) v4(23.51,54.76) ; v4(179.08,72.64) 179.41,72.31 v5(179.41,72.24) ; v4(179.08,72.64) 179.41,72.96 v5(179.41,73.04) ; v4(179.08,72.64) 178.76,72.31 v5(178.76,72.24) ; v4(22.19,57.38) 22.4,57.6 v5(22.44,57.6) ; v5(139.72,65.84) 139.4,65.51 v4(139.4,65.44) ; v5(23.09,55) v4(22.86,54.76) ; v5(144.27,65.84) 144.56,65.55 v4(144.58,65.55) ; v5(144.27,72.24) 144.6,71.91 v4(144.6,71.84) ; v4(186.66,53.94) 186.83,54.11 v5(186.83,54.42) ; v5(22.44,56.3) v4(22.01,55.86) ; v5(180.72,72.24) v4(180.4,71.92) ; v5(22.44,55) v4(22.2,54.76) ; v4(195.18,54.09) 194.86,53.77 v5(194.83,53.77) ; v4(160.47,74.24) 160.17,73.94 v5(160.17,73.84) ; v5(171.73,39.68) v4(171.48,39.46) ; v5(23.74,54.35) v4(23.51,54.11) ; v5(22.44,55.65) v4(22.08,55.29)
  IN3 w0.254: v4(164.37,73.44) 164.04,73.11 v5(164.04,73.04) ; v5(161.44,71.44) 161.77,71.11 v4(161.77,71.04) ; v4(142,71.84) 142,71.91 v5(142.32,72.24) ; v4(193.63,51.43) 193.63,51.49 193.3,51.82 v5(193.23,51.82) ; v4(174.39,49.73) 174.72,50.05 v5(174.72,50.18) ; v5(191.63,56.37) 191.7,56.37 v4(192.03,56.69) ; v5(182.01,70.64) 182.01,70.71 v4(182.33,71.04) ; v4(192.02,49.46) 192.02,49.53 191.68,49.87 v5(191.63,49.87) ; v5(142.97,73.04) 142.97,73.11 v4(143.3,73.44) 143.3,73.51 v5(143.62,73.84) ; v5(119.08,77.38) 119.08,77.37 v4(118.76,77.06) v5(118.44,77.38) 118.44,77.37 v4(118.13,77.06) v5(117.81,77.38) ; v5(191.63,51.82) 191.7,51.82 192.03,51.49 v4(192.03,51.43) ; v4(194.43,49.48) 194.43,49.54 194.1,49.87 v5(194.03,49.87) ; v4(157.87,71.84) 157.87,71.91 v5(158.19,72.24) ; v5(184.61,72.24) 184.93,72.56 v4(184.93,72.64) ; v5(166.19,41.25) 165.82,41.25 v4(165.75,41.31) ; v5(161.44,70.64) 161.77,70.31 v4(161.77,70.24) ; v5(174.72,42.62) v4(174.95,42.39) ; v4(145.9,69.44) 145.9,69.36 v5(145.57,69.04) ; v5(162.12,72.24) 162.12,72.34 v4(162.42,72.64) ; v4(142,70.24) 142,70.31 v5(142.32,70.64) ; v4(136.68,58.51) 136.49,58.31 v5(136.39,58.31) ; v5(139.72,73.84) v4(139.72,74.32) ; v5(193.23,56.37) 193.3,56.37 v4(193.63,56.69) ; v4(178.88,42.14) 178.88,42.36 v5(178.62,42.62) ; v5(142.97,72.24) 142.65,71.91 v4(142.65,71.84) ; v5(162.42,52.72) 162.29,52.85 162.16,52.85 v4(161.96,53.04) 161.76,52.84 161.63,52.84 v5(161.51,52.72) ; v5(163.92,79.15) 163.12,79.15 v4(163.08,79.11) 162.99,79.2 162.41,79.2 v5(162.39,79.21) ; v4(147.2,70.24) 147.2,70.31 v5(146.87,70.64) ; v5(157.86,53.37) 158.19,53.69 v4(158.32,53.69) ; v4(156.57,71.04) 156.57,71.11 v5(156.89,71.44) ; v5(193.23,49.87) 193.3,49.87 193.63,49.54 v4(193.63,49.48) ; v5(161.42,72.24) 161.42,72.26 v4(161.09,72.59) ; v5(182.66,72.24) 182.66,72.31 v4(182.98,72.64) ; v5(154.18,40.33) v4(153.95,40.1) ; v5(183.96,73.04) 183.96,73.11 v4(184.28,73.44) ; v5(178.62,44.5) v4(178.85,44.27) ; v5(156.24,73.04) v4(155.85,72.65) ; v5(146.87,72.24) 147.2,71.91 v4(147.2,71.84) ; v5(176.67,50.18) 176.67,50.05 v4(176.34,49.73) ; v4(140.05,70.24) 140.05,70.31 v5(140.37,70.64) ; v4(173.74,48.6) 174.07,48.93 v5(174.07,49.06) ; v5(161.51,53.37) 161.64,53.37 v4(161.96,53.69) ; v5(150.57,52.72) 150.69,52.84 150.82,52.84 v4(151.03,53.04) ; v4(160.18,41.25) v5(160.65,41.25) ; v4(182.38,68.61) 182.37,68.61 v5(182.01,68.24) ; v4(154.67,53.69) 154.54,53.69 v5(154.22,53.37) ; v5(140.37,71.44) 140.05,71.11 v4(140.05,71.04) ; v4(176.48,71.04) 176.48,71.11 v5(176.81,71.44) ; v5(194.03,57.67) v4(194.36,58) ; v5(178.2,40.7) v4(177.96,40.46) ; v5(177.55,48.28) 177.55,48.06 v4(177.18,47.69) ; v4(103.17,53.98) v5(103.17,54.47) v5(103.17,55.02) ; v4(183.63,71.04) 183.31,70.71 v5(183.31,70.64) ; v4(189.63,52.79) 189.55,52.79 v5(189.23,53.12) ; v5(184.61,70.64) 184.61,70.71 v4(184.93,71.04) ; v5(146.22,70.64) 146.55,70.31 v4(146.55,70.24) ; v5(192.43,58.97) 192.45,58.97 v4(192.82,59.34) ; v5(163.39,71.44) 163.72,71.11 v4(163.72,71.04) ; v4(159.97,65.46) 159.59,65.84 v5(159.49,65.84) ; v4(158.33,41.29) 158.27,41.23 v5(157.87,41.23) ; v5(159.68,54.67) 159.81,54.79 159.94,54.79 v4(160.14,54.99) ; v4(164.83,79.11) 164.87,79.15 165.51,79.15 v5(165.63,79.28) 165.76,79.28 v5(166.01,79.53) ; v5(176.81,40.79) v4(176.48,40.79) ; v4(161.12,68.64) 161.12,68.56 v5(160.79,68.24) ; v4(194.43,50.84) 194.1,51.17 v5(194.03,51.17) ; v4(149.2,54.99) 149,54.79 148.87,54.79 v5(148.75,54.67) ; v4(142.65,70.24) 142.65,70.31 v5(142.97,70.64) ; v5(26.34,53.05) v5(26.99,52.4) ; v4(191.99,59.34) 191.99,59.33 v5(191.63,58.97) ; v5(192.43,57.02) 192.45,57.02 192.76,57.33 v4(192.76,57.36) ; v5(156.24,69.04) 155.92,69.36 v4(155.92,69.44) ; v4(185.58,74.24) 185.26,73.91 v5(185.26,73.84) ; v5(28.94,56.3) v4(28.7,56.54) ; v4(190.43,52.79) 190.35,52.79 v5(190.03,53.12) ; v4(190.43,50.84) 190.35,50.84 v5(190.03,51.17) ; v5(174.72,44.5) v4(174.95,44.27) ; v5(174.07,50.18) 174.07,50.05 v4(173.74,49.73) ; v4(166.55,53.82) 166.36,54.02 v5(166.06,54.02) ; v4(195.23,49.54) 194.9,49.87 v5(194.83,49.87) ; v4(160.14,54.34) 159.94,54.14 159.81,54.14 v5(159.68,54.02) ; v5(185.26,73.04) 185.26,73.11 v4(185.58,73.44) ; v5(191.63,57.02) 191.69,57.02 192,57.33 v4(192,57.36) ; v5(158.19,73.04) 158.19,73.03 157.87,72.71 v4(157.87,72.67) ; v5(179.27,37.25) v4(179.5,37.02) ; v4(148.5,70.24) 148.5,70.31 v5(148.17,70.64) ; v5(169.71,54.02) 169.91,54.02 v4(170.09,53.84) ; v5(163.39,72.24) 163.39,72.31 v4(163.72,72.64) ; v5(148.82,65.84) 148.82,65.8 v4(149.17,65.45) ; v5(148.88,73.82) 149.15,74.09 v4(149.15,74.24) ; v4(141.35,71.04) 141.35,71.11 v5(141.67,71.44) ; v5(149.56,41.25) v4(149.28,41.53) ; v5(183.96,65.84) 183.96,65.74 v4(184.31,65.39) ; v4(185.58,71.84) 185.26,71.51 v5(185.26,71.44) ; v4(177.13,69.44) 177.13,69.36 v5(177.46,69.04) ; v5(194.03,58.32) v4(194.36,58.65) ; v4(193.63,52.14) 193.63,52.14 193.3,52.47 v5(193.23,52.47) ; v5(144.92,67.44) 144.92,67.36 v4(145.25,67.04) ; v4(155.27,72.64) 155.27,72.71 v5(155.59,73.04) ; v4(161.75,65.44) 161.44,65.74 v5(161.44,65.84) ; v4(149.15,70.24) 149.15,70.31 v5(148.82,70.64) ; v4(178.43,72.64) 178.11,72.31 v5(178.11,72.24) ; v5(158.19,69.04) 157.87,69.36 v4(157.87,69.44) ; v4(152.85,53.04) 152.65,52.84 152.52,52.84 v5(152.39,52.72) ; v5(176.67,42.62) 176.95,42.33 v4(176.95,42.14) ; v4(141.35,71.84) 141.35,71.91 v5(141.67,72.24) ; v5(178.2,48.28) 178.2,47.92 v4(177.89,47.61) ; v5(148.82,71.44) 149.15,71.11 v4(149.15,71.04) ; v4(151.03,53.69) 150.82,53.49 150.69,53.49 v5(150.57,53.37) ; v5(171.73,41.25) 171.73,41.37 171.88,41.52 v4(171.88,41.62) ; v4(152.85,54.99) 152.65,54.79 152.52,54.79 v5(152.39,54.67) ; v5(177.32,38.87) v4(177.09,38.63) ; v4(159.2,71.86) 159.49,72.16 v5(159.49,72.24) ; v5(162.09,71.44) 162.42,71.11 v4(162.42,71.04) ; v5(186.83,49.87) 186.75,49.87 v4(186.43,49.54) ; v4(182.98,71.84) 182.66,71.51 v5(182.66,71.44) ; v4(192.03,50.19) 191.97,50.19 191.64,50.52 v5(191.63,50.52) ; v5(28.29,56.95) v4(28.04,56.7) ; v5(174.07,51.09) 174.07,50.96 v4(173.74,50.64) ; v4(156.59,40.33) v5(156.95,40.33) ; v5(162.09,70.64) 162.42,70.31 v4(162.42,70.24) ; v4(160.42,67.05) 160.14,67.33 v5(160.14,67.44) ; v4(192.83,49.48) 192.83,49.54 192.5,49.87 v5(192.43,49.87) ; v4(156.57,71.84) 156.57,71.91 v5(156.89,72.24) ; v5(177.46,73.04) 177.46,72.96 v4(177.78,72.64) ; v5(185.26,65.84) 185.32,65.84 185.7,65.46 v4(185.72,65.46) ; v4(149.19,53.11) 148.8,52.72 v5(148.75,52.72) ; v4(186.43,52.14) 186.75,52.47 v5(186.83,52.47) ; v4(149.2,54.34) 149,54.14 148.87,54.14 v5(148.75,54.02) ; v5(148.82,72.24) 149.15,71.91 v4(149.15,71.84) ; v4(181.68,67.04) 181.36,67.36 v5(181.36,67.44) ; v5(167.98,39.69) 167.97,39.68 167.91,39.68 167.7,39.47 v4(167.7,39.41) ; v5(152.39,53.37) 152.52,53.49 152.65,53.49 v4(152.85,53.69) ; v5(183.31,71.44) 183.31,71.51 v4(183.63,71.84) ; v4(142.65,69.44) 142.65,69.36 v5(142.97,69.04) ; v4(157.87,70.24) 157.87,70.31 v5(158.19,70.64) ; v5(178.11,71.44) 177.78,71.11 v4(177.78,71.04) ; v5(183.31,72.24) 183.31,72.31 v4(183.63,72.64) ; v4(163.07,69.44) 163.07,69.36 v5(162.74,69.04) ; v5(162.74,65.84) 162.74,65.73 v4(163.05,65.43) ; v5(190.03,57.67) v4(190.42,58.05) ; v5(27.64,55) v4(27.88,55.23) ; v5(146.22,72.24) 146.55,71.91 v4(146.55,71.84) ; v5(164.04,70.64) 164.37,70.31 v4(164.37,70.24) ; v4(158.32,53.04) 158.11,52.84 157.98,52.84 v5(157.86,52.72) ; v4(146.55,71.04) 146.55,71.11 v5(146.22,71.44) ; v5(139.72,70.64) 139.4,70.31 v4(139.4,70.24) ; v4(160.14,53.04) 159.94,52.84 159.81,52.84 v5(159.68,52.72) ; v5(26.34,55) v4(26.1,55.24) ; v5(157.54,71.44) 157.51,71.44 157.22,71.15 v4(157.22,71.04) ; v5(156.89,70.64) 156.57,70.31 v4(156.57,70.24) ; v5(160.79,70.64) 161.12,70.31 v4(161.12,70.24) ; v4(163.19,50.36) v5(162.87,50.68) ; v4(156.64,35.36) 156.31,35.68 v5(156.29,35.68) ; v4(179.08,69.44) 179.08,69.36 v5(179.41,69.04) ; v5(178.65,38.15) 178.65,38.12 v4(178.41,37.88) 178.09,37.76 v5(178.06,37.77) ; v5(146.87,71.44) 147.2,71.11 v4(147.2,71.04) ; v5(176.02,48.15) 176.02,48.02 v4(175.69,47.69) ; v5(167.89,54.02) 168.33,53.57 v4(168.33,53.48) ; v5(184.61,71.44) 184.93,71.76 v4(184.93,71.84) ; v5(192.43,50.52) 192.75,50.19 v4(192.83,50.19) ; v4(148.5,71.84) 148.5,71.91 v5(148.17,72.24) ; v5(182.66,70.64) 182.66,70.71 v4(182.98,71.04) ; v5(193.23,50.52) 193.3,50.52 v4(193.63,50.19) ; v4(147.85,69.44) 147.85,69.36 v5(147.52,69.04) ; v4(186.43,50.84) 186.75,51.17 v5(186.83,51.17) ; v5(159.68,53.37) 159.81,53.49 159.94,53.49 v4(160.14,53.69) ; v5(176.81,70.64) 176.48,70.31 v4(176.48,70.24) ; v4(193.61,57.36) 193.61,57.33 193.3,57.02 v5(193.23,57.02) ; v4(179.08,70.24) 179.08,70.31 v5(179.41,70.64) ; v4(140.7,72.64) 140.7,72.71 v5(141.02,73.04) ; v5(160.79,69.04) 161.12,69.36 v4(161.12,69.49) ; v5(175.37,48.15) 175.37,48.02 v4(175.04,47.69) ; v5(192.43,52.47) 192.5,52.47 192.83,52.14 v4(192.83,52.14) ; v4(155.27,70.24) 155.27,70.31 v5(155.59,70.64) ; v4(137.26,58.5) 137.36,58.4 137.48,58.4 137.56,58.31 v5(137.58,58.31) ; v5(149.56,39.68) 149.8,39.68 v4(150.09,39.39) ; v4(184.28,69.44) 184.28,69.36 v5(183.96,69.04) ; v5(145.57,68.24) v4(145.92,68.59) ; v5(157.54,72.24) 157.22,71.91 v4(157.22,71.84) ; v4(155.27,71.04) 155.27,71.11 v5(155.59,71.44) ; v4(192.77,58.66) v5(192.43,58.32) ; v5(26.34,55.65) v4(26.08,55.91) ; v5(176.16,70.64) 175.83,70.31 v4(175.83,70.24) ; v4(152.85,54.34) 152.65,54.14 152.52,54.14 v5(152.39,54.02) ; v4(142,71.04) 142,71.11 v5(142.32,71.44) ; v4(191.95,58.66) 191.95,58.66 191.63,58.34 v5(191.63,58.32) ; v4(176.34,47.69) 176.67,48.02 v5(176.67,48.15) ; v4(24.04,53.96) 24.13,53.96 v5(24.39,53.7) ; v5(191.63,53.12) 191.95,52.79 v4(192.03,52.79) ; v5(191.63,55.72) 191.7,55.72 192.03,56.04 v4(192.03,56.07) ; v4(163.72,70.24) 163.72,70.31 v5(163.39,70.64) ; v5(148.17,71.44) 148.5,71.11 v4(148.5,71.04) ; v4(152.1,41.48) v5(152.33,41.25) ; v4(154.62,70.24) 154.62,70.31 v5(154.94,70.64) ; v4(140.7,69.44) 140.7,69.36 v5(141.02,69.04) ; v5(180.06,73.84) v4(180.06,74.21) ; v4(178.43,71.04) 178.43,71.11 v5(178.76,71.44) ; v5(164.04,73.84) 164.04,73.87 164.37,74.2 v4(164.37,74.24) ; v5(25.69,53.05) v5(26.34,52.4) ; v4(185.58,71.04) 185.26,70.71 v5(185.26,70.64) ; v5(176.16,71.44) 175.83,71.11 v4(175.83,71.04) ; v4(149.2,53.75) 148.94,53.49 148.87,53.49 v5(148.75,53.37) ; v4(174.57,40.84) 174.91,40.84 v5(174.96,40.79) ; v4(169.25,53.47) 169.25,53.55 168.8,54 v5(168.8,54.02) ; v5(176.38,37.31) v4(176.15,37.08) ; v5(164.04,71.44) 164.37,71.11 v4(164.37,71.04) ; v4(164.43,65.62) 164.26,65.62 v5(164.04,65.84) ; v5(182.66,65.84) 182.66,65.7 v4(182.92,65.44) ; v4(185.58,72.64) 185.26,72.31 v5(185.26,72.24) ; v4(155.23,73.45) 154.94,73.74 v5(154.94,73.84) ; v5(194.83,58.97) v4(195.12,59.26) ; v5(177.32,38.22) v4(177.65,38.22) ; v5(178.76,70.64) 178.43,70.31 v4(178.43,70.24) ; v5(157.54,70.64) 157.22,70.31 v4(157.22,70.24) ; v4(146.45,65.35) 146.22,65.58 v5(146.22,65.84) ; v4(192.83,51.43) 192.83,51.49 192.5,51.82 v5(192.43,51.82) ; v5(152.33,40.33) v4(152.1,40.1) ; v5(140.37,73.04) 140.05,72.71 v4(140.05,72.64) ; v5(182.01,69.04) 182.33,69.36 v4(182.33,69.44) ; v4(192.03,52.14) 192.03,52.14 191.7,52.47 v5(191.63,52.47) ; v4(154.62,71.04) 154.62,71.11 v5(154.94,71.44) ; v4(176.48,72.64) 176.81,72.96 v5(176.81,73.04) ; v4(193.63,56.04) 193.3,55.72 v5(193.23,55.72) ; v4(188.03,53.44) 188.35,53.77 v5(188.43,53.77) ; v4(192.83,56.69) 192.5,56.37 v5(192.43,56.37) ; v5(164.04,72.24) 164.04,72.31 v4(164.37,72.64) ; v5(177.46,40.7) v4(177.22,40.46) ; v5(177.32,40) v4(177.09,39.77) ; v5(166.98,54.02) v4(167.29,53.7) ; v4(151.56,51.57) 151.56,51.22 v5(151.48,51.14) ; v4(141.35,70.24) 141.35,70.31 v5(141.67,70.64) ; v5(168.96,41.25) v4(169.19,41.48) ; v5(176.67,44.5) v4(176.9,44.27) ; v4(145.9,70.24) 145.9,70.31 v5(145.57,70.64) ; v5(178.85,40.7) v4(179.18,40.7) ; v4(26.04,57.25) v5(26.34,56.95) ; v4(177.78,70.24) 177.78,70.31 v5(178.11,70.64) ; v4(170.43,39.45) 170.57,39.45 170.73,39.61 v5(170.81,39.68) ; v5(190.03,55.72) v4(190.41,56.1) ; v5(162.74,73.04) 162.74,73.11 v4(163.07,73.44) ; v4(176.69,36.95) 176.69,36.88 v5(176.48,36.67) ; v5(163.42,41.25) 163.42,41.38 v4(163.15,41.65) ; v5(26.34,56.3) v4(26.07,56.57) ; v4(174.39,47.69) 174.72,48.02 v5(174.72,48.15) ; v4(139.4,71.04) 139.4,71.11 v5(139.72,71.44) ; v4(147.73,65.35) 147.52,65.56 v5(147.52,65.84)
  IN3 w0.381: v5(103.17,55.89) v4(103.17,55.56) ; v4(104.9,54.3) 104.72,54.47 v5(104.58,54.47) ; v5(101.75,54.47) v4(101.75,53.59) v5(101.75,53.06)
  GND4 w0.203: 24.37,68 H19.1 ; H19.1 26.45,70.08 ; H19.1 27.97,66.48 ; H19.1 27.97,69.52 ; H19.1 24.93,69.52 ; H19.1 24.93,66.48 ; H19.1 26.45,65.92 ; H19.1 28.53,68 ; 189.78,34.62 H5.1 ; H5.1 193.12,34.62 ; H5.1 189.78,31.29 ; H5.1 193.74,32.95 ; H5.1 193.12,31.29 ; H5.1 191.45,30.67 ; H5.1 191.45,35.24 ; H5.1 189.16,32.95 ; 11.73,36.25 JHDMI1.21 ; JHDMI1.21 14.29,37.18 ; JHDMI1.21 14.29,35.32 ; JHDMI1.21 11.73,35.32 ; JHDMI1.21 14.29,36.25 ; JHDMI1.21 11.73,37.18 ; JHDMI1.21 13.01,35.32 ; JHDMI1.21 13.01,37.18 ; 126.28,31.67 H7.1 ; H7.1 129.62,31.67 ; H7.1 127.95,32.29 ; H7.1 129.62,28.33 ; H7.1 126.28,28.33 ; H7.1 125.66,30 ; H7.1 127.95,27.71 ; H7.1 130.24,30 ; 155.26,4.62 H2.1 ; H2.1 159.13,6.25 ; H2.1 156.89,4.01 ; H2.1 155.26,7.88 ; H2.1 158.52,7.88 ; H2.1 154.65,6.25 ; H2.1 156.89,8.49 ; H2.1 158.52,4.62 ; 194.14,73.53 H8.1 ; H8.1 191.91,76.01 ; H8.1 196.38,73.53 ; H8.1 194.14,78.49 ; H8.1 196.38,78.49 ; H8.1 191.91,73.53 ; H8.1 196.38,76.01 ; H8.1 191.91,78.49 ; JHDMI1.11 11.77,44.45 ; JHDMI1.11 11.88,44 ; JHDMI1.11 11.77,43.54 ; JHDMI1.11 10.86,44.45 ; JHDMI1.11 10.86,43.54 ; JHDMI1.11 10.74,44 ; H18.1 47.47,74.98 ; H18.1 48.03,76.5 ; H18.1 43.87,76.5 ; H18.1 45.95,78.58 ; H18.1 44.43,74.98 ; H18.1 44.43,78.02 ; H18.1 45.95,74.42 ; H18.1 47.47,78.02 ; 18.12,5 H9.1 ; H9.1 18.61,6.34 ; H9.1 18.61,3.66 ; H9.1 21.29,6.34 ; H9.1 19.95,6.83 ; H9.1 21.78,5 ; H9.1 21.29,3.66 ; H9.1 19.95,3.17 ; H4.1 35.62,27.3 ; H4.1 32.57,27.3 ; H4.1 35.62,24.26 ; H4.1 32.01,25.78 ; H4.1 34.09,27.86 ; H4.1 32.57,24.26 ; H4.1 36.18,25.78 ; H4.1 34.09,23.7 ; 12.41,39.04 JHDMI1.2 ; JHDMI1.2 13.32,39.04 ; JHDMI1.2 13.32,39.95 ; JHDMI1.2 12.29,39.5 ; JHDMI1.2 13.43,39.5 ; JHDMI1.2 12.41,39.95 ; JHDMI1.2 12.86,38.93 ; 117.18,78.63 H42.1 ; H42.1 117.18,81.17 ; H42.1 120.18,79.9 ; H42.1 116.72,79.9 ; H42.1 119.72,78.63 ; H42.1 119.72,81.17 ; H42.1 118.45,78.17 ; JHDMI1.5 11.77,40.54 ; JHDMI1.5 10.74,41 ; JHDMI1.5 10.86,40.54 ; JHDMI1.5 11.88,41 ; JHDMI1.5 11.77,41.45 ; JHDMI1.5 10.86,41.45 ; H11.1 79.15,60.13 ; H11.1 81.28,58 ; H11.1 77.59,56.44 ; H11.1 80.71,56.44 ; H11.1 79.15,55.87 ; H11.1 77.59,59.56 ; H11.1 77.02,58 ; H11.1 80.71,59.56 ; 8.95,73.77 H10.1 ; H10.1 7.68,74.23 ; H10.1 10.68,75.5 ; H10.1 7.68,76.77 ; H10.1 10.22,76.77 ; H10.1 7.22,75.5 ; H10.1 10.22,74.23 ; H10.1 8.95,77.23 ; H12.1 10.68,56.5 ; H12.1 8.95,54.77 ; H12.1 10.22,55.23 ; H12.1 8.95,58.23 ; H12.1 7.68,55.23 ; H12.1 10.22,57.77 ; H12.1 7.68,57.77 ; H12.1 7.22,56.5 ; JUSBC1.6 4.19,72.63 ; JUSBC1.6 4.19,71.07 ; JUSBC1.6 2.91,71.07 ; JUSBC1.6 1.63,71.07 ; JUSBC1.6 4.19,71.85 ; JUSBC1.6 1.63,72.63 ; JUSBC1.6 1.63,71.85 ; JUSBC1.6 2.91,72.63 ; JHDMI1.17 11.77,47.45 ; JHDMI1.17 11.77,46.54 ; JHDMI1.17 10.86,47.45 ; JHDMI1.17 10.86,46.54 ; JHDMI1.17 10.74,47 ; JHDMI1.17 11.88,47 ; 12.41,42.04 JHDMI1.8 ; JHDMI1.8 12.41,42.95 ; JHDMI1.8 12.29,42.5 ; JHDMI1.8 13.32,42.95 ; JHDMI1.8 13.32,42.04 ; JHDMI1.8 13.43,42.5 ; 2.91,59.37 JUSBC1.5 ; JUSBC1.5 1.63,60.15 ; JUSBC1.5 4.19,60.93 ; JUSBC1.5 2.91,60.93 ; JUSBC1.5 1.63,59.37 ; JUSBC1.5 1.63,60.93 ; JUSBC1.5 4.19,59.37 ; JUSBC1.5 4.19,60.15 ; 3.53,35.28 JHDMI1.20 ; JHDMI1.20 3.53,33.42 ; JHDMI1.20 4.81,35.28 ; JHDMI1.20 6.09,35.28 ; JHDMI1.20 6.09,34.35 ; JHDMI1.20 3.53,34.35 ; JHDMI1.20 4.81,33.42 ; 11.73,50.75 JHDMI1.22 ; JHDMI1.22 14.29,51.68 ; JHDMI1.22 13.01,51.68 ; JHDMI1.22 14.29,50.75 ; JHDMI1.22 14.29,49.82 ; JHDMI1.22 11.73,49.82 ; JHDMI1.22 13.01,49.82 ; JHDMI1.22 11.73,51.68 ; 3.56,51.72 JHDMI1.23 ; JHDMI1.23 4.84,53.58 ; JHDMI1.23 2.28,51.72 ; JHDMI1.23 2.28,53.58 ; JHDMI1.23 4.84,52.65 ; JHDMI1.23 2.28,52.65 ; JHDMI1.23 3.56,53.58 ; JHDMI1.23 4.84,51.72 ; 7.14,71.31 JUSBC1.2 ; JUSBC1.2 7.14,71.7 ; JUSBC1.2 7.85,71.7 ; H16.1 57.55,9.88 ; H16.1 57.55,12.92 ; H16.1 54.5,9.88 ; H16.1 58.11,11.4 ; H16.1 54.5,12.92 ; H16.1 56.03,9.32 ; H16.1 56.03,13.48 ; H16.1 53.94,11.4 ; JUSBC1.3 8.59,60.29 ; JUSBC1.3 7.91,60.29 ; JUSBC1.3 8.59,62.91 ; JUSBC1.3 7.91,62.91 ; JUSBC1.3 7.14,60.29 ; H13.1 128.48,59.5 ; H13.1 123.52,59.5 ; H13.1 128.48,57.26 ; H13.1 126,57.26 ; H13.1 126,61.74 ; H13.1 123.52,61.74 ; H13.1 128.48,61.74 ; H13.1 123.52,57.26 ; 7.85,60.3 JUSBC1.1 ; JUSBC1.1 7.14,60.3 ; JUSBC1.1 7.14,60.69 ; 7.14,71.71 JUSBC1.4 ; JUSBC1.4 7.91,69.09 ; JUSBC1.4 8.59,71.71 ; JUSBC1.4 8.59,69.09 ; JUSBC1.4 7.91,71.71
  GND4 w0.254: 110.83,10.67 111.3,10.67
  BOTTOM w0.102: v11(30.94,60.9) 30.94,60.89 30.57,60.52 ; UC1.CM29 v11(136.67,53.3)
  BOTTOM w0.127: v11(123.34,51.75) 123.34,51.46 RC75.1 ; UT1.B22 UT1.A22 21.74,61.49 21.62,61.61 21.41,61.61 21.28,61.49 UT1.A23 ; UC1.CN2 136.06,36.28 136.16,36.55 136.28,36.85 136.56,37.48 UC1.CM4 ; v11(90.18,56.84) UV1.E25
  BOTTOM w0.152: v11(28.15,71.57) 27.1,71.57 v11(27.05,71.62) 27.03,71.64 25.7,71.64 v11(25.68,71.62) 25.63,71.57 v11(24.45,71.57) 23.41,71.57 23.41,71.58 ; v11(30.55,71.57) v11(29.35,71.57) ; v5(30.24,60.2) 30.46,59.98 UT1.D2 UT1.D1 ; v11(23.37,72.24) 23.42,72.29 v11(23.42,74.6) ; v11(36.55,71.57) v11(37.75,71.57) 37.84,71.49 38.87,71.49 v11(38.95,71.57) v11(40.15,71.57) v11(41.46,71.57) 42.41,71.57 42.54,71.7 v11(42.54,72.24) 42.49,72.29 v11(42.49,74.6) ; v11(35.35,71.57) v11(34.15,71.57) v11(32.95,71.57) 32.91,71.62 31.8,71.62 v11(31.75,71.57) ; UT1.AB6 UT1.AC6 29.1,51.19 29.58,50.71 ; JANT2.4 38.34,68.65 v11(38.38,68.61) ; UT1.F1 UT1.F2 ; UT1.A1 UT1.B1 v11(30.94,60.9) UT1.A2 UT1.A1
  BOTTOM w0.178: UT1.B12 UT1.A12 ; UT1.B8 UT1.A8 ; v11(18.64,62.54) 18.77,62.67 v11(20.24,62.67) 20.58,62.33 ; UT1.N23 v11(21.74,55.84) ; UT1.AA23 UT1.AA22 ; UT1.AC18 UT1.AB18 ; UT1.AC16 UT1.AB16 ; v11(27.26,51.7) UT1.AC10 ; UT1.AC20 UT1.AB20 ; UT1.A10 UT1.B10 ; UT1.R23 v11(21.74,54.92) ; UT1.A6 v11(29.1,60.9) ; UT1.A16 UT1.B16 ; UT1.L23 v11(21.74,56.76) ; UT1.AC8 v11(28.18,51.7) ; v11(30.02,60.9) UT1.A4 ; UT1.W23 v11(21.74,53.08) ; CT20.2 18.92,60.16 v11(19.26,59.82) v11(20.68,59.82) 20.98,59.52 UT1.E23 UT1.E22 ; UT1.AC22 UT1.AB22 ; UT1.J23 v11(21.74,57.68) ; UT1.A20 UT1.B20 ; UT1.B14 UT1.A14 ; UT1.U23 v11(21.74,54) ; UT1.G23 v11(21.74,58.6) ; v11(26.34,51.7) UT1.AC12 ; UT1.AC14 v11(25.42,51.7) ; UT1.M2 UT1.M1 ; UT1.A18 UT1.B18
  BOTTOM w0.203: RPD128.2 16.86,33.06 v11(16.99,32.93) ; RV118.2 88.25,68.86 88.25,68.46 v6(88.25,68.45) 88.31,68.4 CV4.2 ; RV387.2 v11(106.39,74.57) ; v11(24.79,40.05) 24.89,40.15 RM41.2 ; PUG01.13 v11(201.14,35.99) ; v11(103.05,76.32) 103.18,76.32 RV88.2 ; RT507.2 v11(33.63,51.13) ; RT293.2 34.36,49.86 v11(34.54,49.68) ; CV5.2 v11(84.96,42.93) ; v11(131.94,41.65) RC13.2 ; v11(131.91,47.41) RC220.2 ; RV2448.2 v11(85.49,42.91) ; v11(139.15,61.41) 139.09,61.36 137.79,61.36 137.55,61.6 v6(137.4,61.6) ; v11(131.89,46.1) RC224.2 ; DT9.2 v5(13.44,68.11) ; v11(131.88,48.74) RC218.2 ; v6(137.4,61.6) 137.51,61.72 137.51,61.92 138.14,62.54 v11(138.88,62.54) ; v6(137.4,61.6) 137.29,61.71 RC213.2 ; RT33.2 v11(33.63,53.7) ; JEDP1.15 v11(35.15,72.91) ; RV385.2 100.82,76.62 100.49,76.62 v11(100.4,76.53) ; RV43.1 v11(83.74,52.99) ; RT505.2 v11(33.62,51.77) ; v11(34.67,53.58) 34.56,53.7 RT23.2 ; DT17.2 v5(12.34,67.53) ; RT509.2 v11(33.63,54.33) ; RPD191.2 v11(16,34.35) ; DT14.2 v5(12.4,63.59) ; v11(131.9,46.76) RC222.2 ; v11(131.96,49.99) RC107.2 ; RV21.2 v11(97.44,72.13) ; UC1.CM4 137.26,37.5 UC1.CK4 138.04,37.67 UC1.CJ4 UC1.CJ3 UC1.CJ2 138.04,36.33 UC1.CK1 137.39,34.7 v11(137.27,34.58) 137.27,34.2 v11(137.05,33.98) v11(137.35,33.69) 137.47,33.69 v11(137.72,33.43) v11(138.07,33.09) 138.28,32.87 v11(138.28,32.73) v11(138.28,32.22) v11(138.28,31.74) v11(138.28,31.31) v11(138.28,30.85) v11(137.97,30.54) 137.84,30.4 v11(137.53,30.4) 137.34,30.4 v11(137.12,30.19) v11(136.69,30.19) v11(136.23,30.19) v11(135.62,30.19) 135.55,30.11 135.05,30.11 v11(135.03,30.14) v11(134.45,30.14) 133.79,30.14 133.78,30.13 v11(133.76,30.13) 133.74,30.14 133.31,30.14 v11(133.26,30.19) 132.99,30.19 132.68,30.51 ; v6(89.79,45.9) 89.97,46.08 RV2438.2 ; RT506.2 34.36,51.73 v11(34.64,51.46) ; RPD190.2 v11(24.17,26.13) ; CC76.1 v11(180.86,49.29) ; v11(131.94,49.39) RC567.1 ; RC105.2 v11(120.1,53.4) ; CC74.1 v11(158.2,32.97) ; v11(131.94,44.64) RC56.2 ; RC71.2 v11(131.97,43.65) ; RV94.2 v11(119.34,54.75) ; RV42.1 v11(84.2,52.55) ; RPD88.2 v11(19.69,36.68) ; v11(104.89,76.04) 104.69,76.04 RV399.2 ; RC120.2 v11(129.2,48.91) ; DT13.2 v5(12.39,62.21) ; v11(131.91,45.4) RC201.2 ; DT5.2 v11(12.5,64.18) ; v11(135.45,34.1) v11(135.45,33.59) v11(135.45,33.15) 135.28,32.98 v11(135.12,32.98) v11(134.66,32.98) v11(134.18,32.98) 133.88,32.98 133.76,33.11 ; JEDP1.12 v11(36.35,72.91) ; DT18.2 v5(12.33,66.14) ; DT6.2 v11(12.42,65.56) ; RPD169.2 v11(23.25,27.13) ; v11(135.82,34.48) 136.39,35.06 UC1.CM1 136.39,35.75 136.07,36.07 UC1.CN2 ; v11(87.51,57.78) 87.85,57.44 UV1.B27 ; RC504.2 v11(130.8,38.7) ; RV2437.2 82.33,71.93 82.12,71.71 v6(82.12,71.38) ; PUV03.13 v11(55.41,66.99) ; JEDP1.38 v11(25.95,72.88) ; v11(131.91,48.08) RC216.2 ; v5(13.44,69.5) DT10.2 ; CV599.1 v11(22.05,42.93) ; RT508.2 v11(34.69,54.33) ; v11(24.3,41.15) 24.45,41.29 RM43.2 ; JEDP1.29 v11(29.55,72.83) ; CC1.1 v11(180.88,48.81) ; JEDP1.35 v11(27.15,72.87) ; RM17.1 v11(22.05,42.47)
  BOTTOM w0.254: v11(98.17,75.8) YV1.2 ; v11(98.17,75.8) 98.17,76.29 v11(97.99,76.48) 97.94,76.53 v11(96.7,76.53) 95.76,76.53 v11(95.75,76.54) 95.64,76.54 95.29,76.19 v11(95.29,76.09) v11(95.29,74.8) ; v11(98.17,75.8) 98.17,74.27 97.86,73.96 CV209.1 ; JSSD1.1 v11(118.81,16.52) ; UV1.AB17 v11(106.03,51.55) ; WL1.26 v11(134.17,66.25) ; WL1.20 v11(134.1,69.25) ; v11(153.43,62.45) CC42.2 153.43,61.89 153.33,61.79 CC39.2 CC38.2 154.59,61.56 CC81.2 v11(154.59,62.5) ; v11(136.64,67.1) 136.75,66.98 CD115.2 ; UV1.AF17 v11(107.71,48.7) ; UV1.E14 v11(97.7,63.31) ; v11(93.13,56.27) 93.18,56.21 UV1.H23 ; UV1.AE17 v11(107.14,49.22) ; CD42.2 v11(136.56,73.64) ; UC2.3 v11(183.01,53.18) ; v11(103.11,49.79) UV1.AB20 ; RC168.2 v11(161.64,33.04) ; UV1.AC22 v11(103.61,48.04) ; v11(92.49,59.21) 92.43,59.15 92.43,58.71 UV1.E22 ; v6(87.29,67.52) 88.03,67.52 CV615.2 ; CV764.2 87,64.92 v6(87.19,65.11) ; CV716.2 v11(86.38,43.97) ; v11(151.62,60.46) CD66.2 ; UV1.AD18 v11(106.56,49.79) ; v11(18.48,45.13) v11(17.29,45.13) 16.85,45.13 16.51,45.47 v11(16.51,46.07) v11(16.51,47.34) ; v11(18.48,45.13) 19.05,45.13 19.38,45.46 v11(19.38,45.78) v11(20.87,45.78) 20.88,45.79 v11(22.64,45.79) 24.62,45.79 v11(25.11,46.29) 25.14,46.31 v11(25.14,47.43) 24.99,47.57 v11(22.91,47.57) 21.64,47.57 21.64,47.58 v11(20.99,47.58) v11(19.38,47.58) 19.38,47.8 19.06,48.12 v11(18.62,48.12) v11(17.49,48.12) 16.85,48.12 16.51,47.78 v11(16.51,47.34) ; v11(18.48,45.13) YM1.4 ; UV1.AD15 v11(108.22,51.55) ; WL1.35 v11(129.7,63.87) ; CV765.2 91.12,71 90.81,71 v6(90.67,71.14) ; v11(149.89,61.65) CC78.2 ; UV1.AE20 v11(106,48.07) ; v6(88.34,74.16) CV610.2 ; WL1.41 v11(126.7,63.89) ; CD48.2 v11(136.56,74.25) ; v6(93.08,73.49) 93.08,73.42 93.37,73.12 CV766.2 ; UV1.E17 v11(95.4,61.03) ; UV1.L23 v11(96.03,54.46) ; v11(138.88,62.54) 140.83,62.54 v11(140.83,62.54) v11(141.97,62.54) v11(143.65,62.54) v11(144.71,62.54) v11(146.26,62.54) 146.75,62.54 CC6.2 ; UV1.K13 v5(100.34,62.24) ; v11(202.62,35.12) PCG07.2 v11(202.08,34.6) ; v6(84.46,42.32) 84.46,42.1 CV715.2 ; UV1.B5 v5(100.31,70.7) ; v11(117.61,57.44) UV1.AG2 ; v11(97.21,52.21) 97.14,52.28 97.14,52.69 UV1.P23 ; JSSD1.27 v11(118.71,23.03) ; WL1.32 v11(131.2,63.87) ; v6(87.78,65.67) 87.87,65.67 CV613.2 ; CV609.2 82.42,68.44 v5(82.51,68.44) ; v6(144.82,74.42) 144.93,74.3 144.93,73.85 UD43.K2 ; v11(131.12,56.58) 130.75,56.58 130.68,56.51 128.83,56.51 128.76,56.44 128.37,56.18 128.37,52.39 128.51,52.25 130.76,52.25 131.12,52.61 CC12.2 ; CV617.2 86.91,72.7 v6(86.66,72.45) ; UV1.AC2 v11(114.73,60.25) ; WL1.A15 v11(132.35,70.75) ; v6(105.17,61.52) 105.14,61.55 UV1.N10 ; CV711.2 v11(84.48,44.6) ; v11(95.29,74.8) 95.29,74.06 v11(95.38,73.97) CV210.1 ; v11(95.29,74.8) YV1.4 ; v6(94.02,42.87) 94.02,42.62 CV760.2 ; JSSD1.39 v11(118.71,26.03) ; v11(16.69,62.54) v11(17.77,62.54) v11(18.64,62.54) 18.67,62.52 CT21.2 ; v11(16.69,62.54) 16.19,62.54 15.93,62.28 v11(15.93,60.21) 15.93,59.73 16.18,59.48 v11(16.7,59.48) v11(17.79,59.48) ; v11(16.69,62.54) YT1.4 ; v11(155.88,62.6) CC36.2 155.88,60.86 CC35.2 156.29,59.91 156.95,59.25 v5(156.95,57.99) ; v11(94.16,54) 94.27,53.89 UV1.L25 ; UV1.B20 92.09,61.5 92.21,61.38 v11(92.62,61.38) ; UV1.U26 97.21,48.96 96.96,48.71 v11(96.82,48.71) ; CV712.2 85.94,45.03 v6(85.94,44.87) ; UC1.C1 178.35,35.58 v11(178.6,35.33) ; UV1.AA7 v11(111.17,58.01) ; QV8.1 v11(107.94,74.54) ; CN59.2 v11(48.77,61.8) ; WL1.A07 v6(132.41,74.75) ; v5(164.5,57.99) 164.33,58.17 164.33,58.59 164.16,58.75 164.16,59.54 163.83,59.87 CC83.2 v11(163.83,61.07) ; CV614.2 95.14,70.1 95.53,69.71 v6(95.57,69.71) ; CV709.2 92.99,43.89 v6(93.09,43.99) ; JSSD1.9 v11(118.73,18.52) ; v11(108.87,55.6) 108.87,55.11 UV1.AB11 ; WL1.23 v11(134.12,67.75) ; v11(149.47,76.2) 149.5,76.22 CD105.2 ; UC5.3 v11(121.31,52.84) ; JSSD1.57 v11(118.76,30.52) ; UV1.Y2 v11(113.5,61.5) ; UV1.AC26 100.79,45.8 v11(100.79,46.35) ; RC420.2 v11(183.38,56) ; UC1.AH33 v5(163.24,57.24) ; QV8.4 v11(108.62,75.84) ; UV1.AF1 v11(117.03,58.13) ; UC1.D1 177.7,35.53 v11(177.92,35.3) ; v11(158.93,62.47) CC40.2 CC47.2 158.93,58.93 159.47,58.4 v11(159.47,57.99) ; RD12.2 v11(183,61.85) ; CT20.2 18.67,59.83 18.33,59.49 17.8,59.49 v11(17.79,59.48) ; WL1.71 v6(121.63,76.25) ; UV1.AG26 v11(103.51,43.44) ; CD59.2 v11(182.92,54.57) ; v11(135.82,34.48) 135.45,34.11 v11(135.45,34.1) ; YM1.2 16.53,47.33 v11(16.51,47.34) ; v11(107.69,50.98) UV1.AD16 ; v11(92.3,12.48) ED11.3 v11(92.3,10.15) ; CC61.2 v11(128.79,44.59) ; CV710.2 v11(83.87,45.18) ; UV1.AB7 v11(111.68,57.58) ; UC1.F2 176.34,35.86 v11(176.34,35.55) ; QV147.1 v11(114.12,72.32) ; CD62.2 v11(183.01,62.41) ; CD143.2 v11(137.71,64.6) ; UV1.E8 v11(101.31,66.82) ; v6(87.17,49.77) 86.79,49.39 CV762.2 ; UV1.AB24 v11(101.26,46.92) ; CD75.2 160.68,62.99 v11(160.3,63.38) ; JSSD1.21 v11(118.71,21.52) ; CV713.2 81.19,43.48 v6(81.19,43.05) ; WL1.17 v11(134.17,70.75) ; JSSD1.3 v11(118.83,17.03) ; v5(158.21,57.24) v5(158.21,57.89) 158.21,59.02 157.15,60.08 CC37.2 ; PCG04.2 v11(198.15,35.6) ; CC64.2 v11(128.79,45.2) ; JSSD1.45 v11(118.73,27.52) ; RD24.2 v11(177.91,60.94) ; WL1.62 v6(121.71,71.75) ; JSSD1.15 v11(118.69,20.03) ; v11(17.79,59.48) YT1.2 ; PR509.2 v11(14.32,20.46) ; UC1.B2 178.81,35.98 v11(179.03,35.75) ; PR502.1 v11(10.27,20.64) ; v11(160.73,56.04) UC1.AM35 ; UC1.A3 179.27,36.28 v11(179.51,36.03) ; JSSD1.51 v11(118.71,29.03) ; UC1.V3 v5(168.77,36.67) ; CD126.2 136.67,71.86 v11(136.65,71.84) ; CV618.2 86.19,62.92 v6(86.09,62.82) ; UV1.AD19 v11(106.01,49.23) ; v5(100.34,60.13) v5(100.34,58.72) ; 96.22,71.16 96.51,70.86 v6(96.76,70.86) ; CD124.2 v11(137.64,69.42) ; UV1.AC5 v11(113.59,58.01) ; CD67.2 v11(136.56,71.25) ; UV1.B17 v11(93.71,63.77) ; UV1.B11 v5(97.21,66.29) ; RN199.2 v11(48.18,61.8) ; UV1.Y5 v11(111.8,59.81) ; UV12.3 v11(115.2,72.45) ; 90.55,75.87 90.59,75.87 90.87,75.6 v6(91.21,75.6) ; UV1.AD22 v11(104.23,47.47) ; CV717.2 82.78,43.83 v6(82.78,43.98) ; CZ22.2 v11(123.23,44.79) ; RD13.2 v11(180.82,60.87) ; UV1.AF14 v11(108.97,51.01) ; UV1.P26 v11(95.46,51.47) ; UV1.AF20 v11(106.45,47.5) ; UV1.A2 v5(101.89,73.05) ; CV718.2 86.02,48.41 v6(85.77,48.67) ; v11(147.28,60.99) 146.65,60.99 146.25,61.38 v11(146.25,61.41) v11(143.8,61.41) v11(142.22,61.41) v11(141.16,61.41) v11(139.15,61.41) ; v6(83.72,47.17) 83.72,47.19 CV759.2 ; v11(145.02,37.94) 144.76,37.67 UC1.BV4 ; UV1.AF23 v11(104.81,45.74) ; v11(152.26,62.47) CC43.2 ; QV147.4 v11(112.82,74.34) ; CD106.2 v11(150.06,76.19) ; PCV37.2 v11(57.66,66.95) ; v4(103.17,53.06) v6(103.17,52.49) ; WL1.G3 v11(122.45,63.86) ; 92.52,55.08 v11(92.52,55.58) ; UZ4.5 v11(122.77,44.84) ; UC1.AK36 161.98,59.55 162.25,59.81 CC34.2 v11(162.25,61.5) ; JSSD1.33 v11(118.78,24.52) ; v5(148.56,56.01) 148.54,56.01 148.5,56.04 UC1.BM33 ; WL1.38 v11(128.2,63.88) ; 107.17,53.3 v11(107.76,53.3) ; v11(181.68,38.35) PCG128.2 v11(182.61,38.97) ; UV1.L5 v11(106.59,65.07) ; 81.65,8.34 v11(81.65,8.97) ; UV1.E2 v11(104.59,70.67) ; UV1.E20 v11(93.65,59.21) ; UV1.E11 v11(99.45,65.07) ; UV1.B8 v11(98.97,69.08) ; UV1.AD21 v11(104.72,48.04) ; UV1.B1 v5(103.4,72.95) ; UV1.AC8 v11(111.27,56.76) ; CD123.2 v11(137.64,68.81) ; v11(103.03,68.55) UV1.E5 ; CD125.2 v11(137.05,76.62) ; v11(79.7,41.58) CV714.2 ; UV1.K15 v11(98.92,60.7) ; 98.92,55.89 v11(98.47,55.89) ; PCV10.2 v11(57.64,74.4)
  BOTTOM w0.305: CC35.2 CC37.2 157.15,60.56 157.57,60.98 CC82.2 v11(157.57,62.52) ; v6(134.19,76.11) 134.04,76.25 WL1.6
  BOTTOM w0.381: UV1.M17 v6(98.92,57.9) UV1.L16 ; UV1.R14 v6(102.45,57.3) UV1.P15 ; 100.34,55.89 v6(99.7,55.89) ; UV1.P13 v6(103.17,59.46) UV1.N12 ; UV1.V11 v6(107.41,57.86) ; UV1.R12 v6(104.58,59.46) UV1.P11 ; UV1.N16 UV1.P15 ; UV1.P15 v6(101.75,56.59) 101.75,55.89 ; UV1.P15 v6(101.75,58.03) UV1.N14 ; UV1.U12 v6(105.27,57.3) UV1.T13 v6(104.58,56.62) 104.58,55.89 ; UV1.L10 v6(103.17,62.18) UV1.M11 ; v5(103.17,55.89) v5(103.17,55.02) v5(103.17,54.47) ; v6(98.09,57.3) UV1.L18 ; UV1.U10 v6(107.84,59.15) ; UV1.L12 v6(101.75,60.85) UV1.M13 ; UV1.R10 v11(106,59.49) UV1.T11
  vias: v2(12.56,63.05) v2(12.62,61.66) v2(19.39,24.15) v2(19.39,23.63) v2(19.93,16.47) v2(21.26,19.05) v2(21.69,13.33) v2(21.69,12.81) v2(21.72,57.63) v2(21.78,19.06) v2(21.74,16.93) v2(21.74,16.41) v2(21.73,15.76) v2(21.73,15.24) v2(21.7,14.57) v2(21.71,14.05) v2(22.49,57.61) v2(22.48,55.19) v2(22.48,19.07) v2(23,19.08) v2(23.06,57.62) v2(23.06,55.19) v2(23.75,58.35) v2(23.74,19.07) v2(23.86,17.45) v2(24.26,19.07) v2(24.31,58.35) v2(24.42,17.45) v2(24.89,57.57) v2(24.81,56.9) v2(24.84,56.23) v2(24.88,55.57) v2(24.97,19.08) v2(24.99,17.45) v2(25.49,19.09) v2(26.09,57.58) v2(26.06,56.91) v2(26.11,56.24) v2(26.1,55.58) v2(26.25,53.83) v2(26.9,53.83) v2(27.27,57.59) v2(42.82,54.89) v2(46.24,62.49) v2(46.24,62.02) v2(46.23,61.57) v2(46.28,61.17) v2(46.27,60.78) v2(46.32,60.46) v2(52.99,77.03) v2(52.97,76.32) v2(53.01,75.49) v2(53.22,70.86) v2(53.2,70.47) v2(53.58,70.85) v2(53.63,70.45) v2(53.98,74.45) v2(53.99,70.46) v2(54.05,74.83) v2(54.01,70.83) v2(54.37,70.84) v2(54.35,70.46) v2(54.43,77.02) v2(54.41,76.31) v2(54.45,75.47) v2(54.46,74.83) v2(54.41,74.44) v2(54.59,62.18) v2(54.59,61.81) v2(54.6,61.27) v2(54.6,60.9) v2(54.66,66.63) v2(54.6,63.07) v2(54.6,62.7) v2(54.77,74.44) v2(54.86,74.85) v2(55,70.49) v2(55.08,72.13) v2(55.01,70.89) v2(55.03,66.63) v2(55.13,61.81) v2(55.13,61.44) v2(55.28,74.3) v2(55.28,73.96) v2(55.23,73.11) v2(55.29,71.86) v2(55.2,70.12) v2(55.32,74.86) v2(55.38,70.88) v2(55.42,70.48) v2(55.41,66.61) v2(55.43,66.24) v2(55.58,73.12) v2(55.56,70.13) v2(55.7,74.33) v2(55.65,71.87) v2(55.61,61.79) v2(55.61,61.42) v2(55.72,74.86) v2(55.71,73.96) v2(55.77,72.79) v2(55.78,70.48) v2(55.78,66.61) v2(55.81,72.3) v2(55.85,71.54) v2(55.85,71.16) v2(55.8,70.86) v2(56.09,73.17) v2(56.19,74.86) v2(56.11,74.33) v2(56.1,73.96) v2(56.11,71.84) v2(56.16,70.86) v2(56.14,70.49) v2(56.3,72.13) v2(56.45,74.34) v2(56.46,73.97) v2(56.44,73.18) v2(56.47,71.85) v2(56.68,66.14) v2(56.68,65.75) v2(57.68,74.24) v2(57.7,73.45) v2(57.69,68) v2(57.71,72.34) v2(57.73,71.55) v2(57.71,70.8) v2(57.72,69.36) v2(57.74,68.58) v2(57.71,67.22) v2(57.86,36.13) v2(58.08,74.3) v2(58.1,73.52) v2(58.08,72.8) v2(58.09,70.53) v2(58.1,72.01) v2(58.11,69.74) v2(58.12,68.83) v2(58.14,68.04) v2(68.03,56.8) v2(68.48,56.82) v2(73.85,75.36) v2(73.85,75) v2(73.85,73.73) v2(73.85,73.38) v2(73.85,72.11) v2(73.85,71.75) v2(73.85,70.48) v2(73.85,70.12) v2(73.85,68.85) v2(73.85,68.5) v2(73.85,67.23) v2(73.85,66.87) v2(73.85,65.6) v2(73.85,65.25) v2(73.85,63.98) v2(73.85,63.62) v2(73.85,62.35) v2(73.85,62) v2(73.85,60.73) v2(73.85,60.37) v2(73.85,59.1) v2(73.85,58.75) v2(73.85,57.48) v2(73.85,57.12) v2(73.85,55.85) v2(73.85,55.49) v2(73.85,54.22) v2(73.85,53.87) v2(73.85,52.6) v2(73.85,52.24) v2(73.85,50.97) v2(73.85,50.62) v2(73.85,42.84) v2(73.85,42.49) v2(73.85,41.22) v2(73.85,40.86) v2(73.85,39.59) v2(73.85,39.24) v2(73.85,37.97) v2(73.85,37.61) v2(73.85,36.34) v2(73.85,35.99) v2(73.85,34.72) v2(73.85,34.36) v2(73.85,33.09) v2(73.85,32.74) v2(73.85,31.47) v2(73.85,31.11) v2(74.65,76.95) v2(74.83,65.48) v2(74.84,64.78) v2(74.85,63.94) v2(74.83,61.5) v2(74.84,60.23) v2(74.84,59.53) v2(74.86,58.68) v2(74.84,56.43) v2(74.9,77.2) v2(75.02,63.34) v2(75.45,23.07) v2(75.53,63.59) v2(75.74,23.08) v2(75.8,78.1) v2(76.05,78.35) v2(76.03,23.08) v2(76.23,63.59) v2(76.62,23.09) v2(76.95,79.25) v2(77,62.35) v2(77.13,63.5) v2(77.2,79.5) v2(77.25,23.09) v2(77.33,61.81) v2(77.81,22.89) v2(78.1,80.4) v2(78.03,62.65) v2(78.35,80.65) v2(78.45,61.86) v2(78.44,23.27) v2(79.01,22.9) v2(79.61,23.17) v2(79.81,80.96) v2(80.17,80.96) v2(81.44,80.96) v2(81.79,80.96) v2(81.99,53.79) v2(83.06,80.96) v2(83.23,56.14) v2(83.42,80.96) v2(83.45,30.4) v2(83.54,48.7) v2(83.72,54.66) v2(83.8,30.4) v2(84.25,49.63) v2(84.69,80.96) v2(84.61,64.26) v2(85.04,80.96) v2(85.04,53.68) v2(85.07,30.4) v2(85.23,50.31) v2(85.43,30.4) v2(86.31,80.85) v2(86.59,62.34) v2(86.67,80.85) v2(87.72,63.51) v2(87.94,80.85) v2(88.3,80.85) v2(88.32,30.4) v2(88.68,30.4) v2(88.92,64.53) v2(89.57,80.85) v2(89.87,35.52) v2(89.92,80.85) v2(89.95,30.4) v2(90.3,30.4) v2(90.89,63.6) v2(91.19,80.85) v2(91.55,80.85) v2(91.57,30.4) v2(91.67,63.96) v2(91.93,30.4) v2(92.16,63.61) v2(92.82,80.85) v2(93.09,60.35) v2(93.05,58.22) v2(93.17,80.85) v2(93.2,30.4) v2(93.56,30.4) v2(93.84,59.32) v2(93.99,66.04) v2(94.03,28.19) v2(94.28,66.96) v2(94.44,80.85) v2(94.48,28.19) v2(94.8,80.85) v2(94.84,59.84) v2(94.84,52.66) v2(94.83,30.4) v2(94.98,66.51) v2(94.92,28.19) v2(95.18,30.4) v2(95.38,28.19) v2(95.43,62.67) v2(95.49,59.18) v2(95.71,60.91) v2(95.81,28.23) v2(96.07,80.96) v2(96.35,28.19) v2(96.42,80.96) v2(96.45,30.4) v2(96.6,60.48) v2(96.81,30.4) v2(97.24,52.15) v2(97.45,48.77) v2(97.69,80.96) v2(97.99,51.55) v2(98.05,80.96) v2(98.08,30.4) v2(98.29,53.81) v2(98.43,30.4) v2(98.82,50.27) v2(99.32,80.96) v2(99.67,80.96) v2(99.7,30.4) v2(100.06,30.4) v2(100.03,19.05) v2(100.09,18.33) v2(100.14,48.68) v2(100.75,79.71) v2(100.75,79.35) v2(100.94,19.07) v2(100.97,18.33) v2(103.01,53.64) v2(103.46,53.64) v2(104.44,53.67) v2(104.96,53.68) v2(105.65,53.56) v2(106.14,53.57) v2(106.97,53.44) v2(110.45,67.42) v2(110.45,66.92) v2(110.47,66.26) v2(110.47,65.76) v2(110.44,65.03) v2(110.44,64.53) v2(110.44,63.84) v2(110.44,63.34) v2(110.45,29.43) v2(110.58,25.1) v2(110.83,29.43) v2(111.39,66.29) v2(111.39,65.79) v2(111.37,65.11) v2(111.37,64.61) v2(111.41,67.5) v2(111.41,67) v2(111.41,63.89) v2(111.41,63.39) v2(111.59,29.43) v2(111.88,9.81) v2(111.98,29.43) v2(112.29,10.25) v2(112.22,9.93) v2(113.13,10.15) v2(113.13,9.82) v2(113.51,10.15) v2(113.51,9.82) v2(113.89,10.15) v2(113.89,9.82) v2(114.27,10.15) v2(114.27,9.82) v2(114.65,10.15) v2(114.65,9.82) v2(115.03,10.15) v2(115.03,9.82) v2(115.41,10.04) v2(121.35,67.55) v2(121.78,68.8) v2(137.07,24.73) v2(137.07,24.35) v2(137.05,23.43) v2(137.05,23.05) v2(138.86,37.66) v2(140.41,36.84) v2(140.66,35.14) v2(143.03,39.04) v2(143.4,37.43) v2(145.13,36.83) v2(145.3,34.31) v2(145.3,33.1) v2(145.67,36.86) v2(145.82,39.02) v2(147.43,44.46) v2(147.54,43.86) v2(148.1,44.65) v2(148.07,43.86) v2(148.68,44.65) v2(148.68,44.06) v2(148.71,43.61) v2(148.71,43.04) v2(150.73,50.59) v2(151.36,49.51) v2(151.36,47.56) v2(151.36,46.37) v2(151.36,45.17) v2(151.36,43.98) v2(151.36,42.79) v2(151.62,47.56) v2(151.62,46.37) v2(151.62,45.18) v2(151.62,43.98) v2(151.62,42.79) v2(151.92,50.07) v2(153.71,41.11) v2(153.71,37.53) v2(153.87,43.92) v2(153.88,43.67) v2(153.96,41.11) v2(153.96,37.53) v2(154.43,47.31) v2(154.43,47.06) v2(155.07,43.92) v2(155.07,43.67) v2(155.63,47.31) v2(155.63,47.06) v2(155.87,34.61) v2(156.26,43.92) v2(156.26,43.67) v2(156.82,47.31) v2(156.82,47.06) v2(156.81,45.66) v2(156.96,51.23) v2(156.92,50.71) v2(157.06,45.66) v2(157.46,43.92) v2(157.46,43.67) v2(157.69,51.24) v2(158.01,47.31) v2(158.02,47.06) v2(158.65,43.92) v2(158.65,43.67) v2(159.44,51.24) v2(159.44,50.67) v2(161.2,43.49) v2(161.13,42.33) v2(161.2,40.47) v2(161.19,39.82) v2(161.27,38.6) v2(161.27,38.19) v2(161.45,43.49) v2(161.45,42.34) v2(161.44,39.82) v2(161.64,40.5) v2(162.17,43.49) v2(162.18,42.36) v2(162.13,39.86) v2(162.3,38.59) v2(162.3,38.17) v2(162.38,39.87) v2(162.31,37.35) v2(162.31,36.93) v2(162.42,43.49) v2(162.43,42.36) v2(162.88,40.47) v2(163.4,40.45) v2(163.99,40.43) v2(164.52,43.49) v2(164.52,42.3) v2(164.56,40.44) v2(164.59,39.95) v2(164.65,39.55) v2(164.64,38.71) v2(164.64,38.29) v2(164.7,37.46) v2(164.7,37.04) v2(164.77,43.49) v2(164.77,42.3) v2(164.99,40.47) v2(165.73,40.43) v2(166.22,47.48) v2(166.39,47.08) v2(166.39,46.45) v2(166.39,45.81) v2(166.31,40.43) v2(166.47,47.48) v2(166.96,47.47) v2(167.03,47.08) v2(167.03,46.45) v2(167.03,45.81) v2(167.21,47.47) v2(167.54,47.49) v2(167.66,47.08) v2(167.66,46.45) v2(167.66,45.81) v2(167.79,47.49) v2(168.03,48.23) v2(168.08,46.01) v2(168.02,45.36) v2(168.04,44.44) v2(168.12,47.06) v2(168.28,48.23) v2(168.28,45.37) v2(168.3,44.44) v2(168.27,43.49) v2(168.27,42.3) v2(168.27,39.91) v2(168.34,46.01) v2(168.4,40.91) v2(168.57,47.02) v2(168.52,43.49) v2(168.52,42.3) v2(168.52,39.91) v2(169.28,49.44) v2(169.28,48.25) v2(169.28,47.05) v2(169.28,45.86) v2(169.28,44.67) v2(169.28,43.47) v2(169.53,49.44) v2(169.53,48.25) v2(169.53,47.06) v2(169.53,45.86) v2(169.53,44.67) v2(169.53,43.47) v2(169.74,39.61) v2(170.95,40.21) v2(171.74,47.05) v2(171.74,45.86) v2(171.74,44.67) v2(171.74,43.47) v2(171.86,40.22) v2(172,47.06) v2(172,45.86) v2(172,44.67) v2(172,43.47) v2(172.8,40.22) v2(173.71,40.22) v2(174.69,39.26) v2(174.79,39.56) v2(174.86,44.76) v2(174.86,43.11) v2(175.44,44.76) v2(175.49,43.11) v2(176.01,43.92) v2(176.5,39.8) v2(176.66,43.91) v2(176.76,39.57) v2(176.81,40.61) v2(177.05,40.88) v2(177.87,43.92) v2(178.32,40.73) v2(178.53,43.91) v2(178.63,40.88) v2(178.79,39.2) v2(178.91,40.15) v2(178.99,38.67) v2(179.53,44.13) v2(179.9,40.81) v2(180.17,43.93) v2(190.87,17.36) v2(191.04,25.81) v2(191.2,19.22) v2(191.18,18.04) v2(192.69,22.51) v2(195.1,46.24) v2(195.12,46.95) v2(195.14,45.4) v2(196.47,46.84) v2(196.45,46.13) v2(196.49,45.29) v2(196.54,59.7) v2(197.03,59.7) v2(197.56,41.03) v2(197.54,40.32) v2(197.58,39.48) v2(197.73,59.69) v2(197.72,37.2) v2(197.7,36.49) v2(197.74,35.66) v2(198.18,59.69) v2(200.15,49.28) v2(200.35,50.83) v2(200.33,50.11) v2(203.09,33.68) v2(203.11,34.39) v2(203.13,32.84) v2(204.73,34.33) v2(204.71,33.62) v2(204.75,32.79) v2(205.73,30.99) v2(205.71,30.28) v2(205.75,29.44) v2(206.35,34.23) v2(206.33,33.52) v2(206.37,32.68) v2(206.92,29.32) v3(1.93,18.12) v3(2.37,10.5) v3(2.76,29.17) v3(12.83,52.69) v3(18.86,58.78) v3(30.44,33.3) v3(30.95,6.19) v3(54.34,72.68) v3(63.64,11.34) v3(68.72,39.91) v3(68.83,11.97) v3(69.05,65.5) v3(72.48,74.58) v3(72.48,72.48) v3(72.42,70.45) v3(73.75,20.44) v3(79.01,64.78) v3(82.74,11.66) v3(85.78,9.67) v3(86.22,10.25) v3(90.13,8.74) v3(92.32,6.9) v3(98.06,18.52) v3(150.14,10.75) v3(154.52,11.14) v3(160.3,11.46) v3(161.32,9.17) v3(161.84,17.99) v3(170.4,68.61) v3(170.5,72.66) v3(170.52,63.08) v3(176.89,5.46) v3(184.49,46.32) v3(184.45,31.79) v3(184.94,5.81) v3(185.51,45.87) v3(185.69,30.15) v3(189.61,45.02) v3(197.8,44.74) v3(200.18,39.46) v4(5.54,29.85) v4(5.54,28.22) v4(5.54,26.6) v4(5.54,24.97) v4(5.54,23.34) v4(5.54,21.72) v4(5.54,20.09) v4(5.54,18.47) v4(5.54,16.84) v4(5.54,15.22) v4(5.54,13.59) v4(5.54,11.97) v4(7.73,10.52) v4(8.02,20.86) v4(8.02,19.97) v4(8.02,19.08) v4(8.02,18.19) v4(8.44,30.98) v4(8.77,29.21) v4(9.29,29.23) v4(9.24,28.69) v4(9.22,13.16) v4(9.26,12.57) v4(9.26,11.95) v4(9.35,10.52) v4(9.53,24.98) v4(9.8,29.2) v4(9.96,25.03) v4(10.06,30.98) v4(10.17,28.66) v4(10.35,29.21) v4(10.46,24.95) v4(10.94,29.23) v4(10.98,25.05) v4(10.98,10.52) v4(11.12,28.72) v4(11.69,30.98) v4(12.66,28.54) v4(12.66,28.03) v4(12.66,27.52) v4(12.66,27.01) v4(12.61,10.52) v4(13.17,28.54) v4(13.17,28.03) v4(13.17,27.52) v4(13.17,27.01) v4(13.31,30.98) v4(13.68,27.52) v4(13.68,27.01) v4(14.19,27.52) v4(14.19,27.01) v4(14.23,10.52) v4(15.07,60.84) v4(15.07,44.58) v4(15.07,42.96) v4(15.07,41.33) v4(15.07,39.71) v4(15.07,38.08) v4(15.07,36.46) v4(15.07,34.83) v4(15.07,33.21) v4(15.07,31.58) v4(15.86,10.52) v4(16.57,38.17) v4(16.73,16.73) v4(16.73,16.22) v4(16.73,15.71) v4(16.73,15.08) v4(16.82,22.03) v4(17.1,21.41) v4(17.23,16.73) v4(17.23,16.22) v4(17.23,15.71) v4(17.23,15.08) v4(17.48,10.52) v4(17.74,16.73) v4(17.74,16.22) v4(17.74,15.71) v4(17.74,15.08) v4(18.25,16.73) v4(18.25,16.22) v4(18.25,15.71) v4(18.25,15.08) v4(19.11,10.52) v4(20.2,24.02) v4(20.16,23.49) v4(20.24,20.76) v4(20.32,22.26) v4(20.52,19.59) v4(20.6,16.56) v4(20.73,10.47) v4(20.94,17.1) v4(20.92,16.06) v4(20.93,15.12) v4(20.92,14.39) v4(20.98,13.77) v4(21.57,19.86) v4(22.36,10.47) v4(22.82,19.9) v4(23.98,10.47) v4(24.33,19.85) v4(25.17,19.82) v4(26.31,63.98) v4(26.63,39.17) v4(26.63,31.04) v4(26.63,24.54) v4(26.63,22.91) v4(26.63,21.29) v4(26.63,19.66) v4(26.63,18.04) v4(26.63,16.41) v4(26.63,14.78) v4(26.63,12.95) v4(29.18,63.98) v4(30.81,63.98) v4(31.15,34.26) v4(36.07,63.98) v4(36.19,35.2) v4(38.03,59.34) v4(40.92,53.03) v4(44.15,59.23) v4(44.28,56.08) v4(44.28,54.45) v4(44.28,52.83) v4(45.72,62.43) v4(45.75,61.3) v4(45.77,59.23) v4(45.82,60.06) v4(47.4,59.23) v4(49.02,59.23) v4(50.63,77.38) v4(50.65,59.23) v4(50.77,75.86) v4(50.77,74.24) v4(50.77,72.61) v4(50.77,70.99) v4(50.77,69.36) v4(50.77,67.73) v4(50.77,66.11) v4(50.77,64.48) v4(50.77,62.86) v4(50.77,61.17) v4(52.01,71.74) v4(52.01,71.3) v4(52.01,70.84) v4(52.14,60.82) v4(52.26,77.38) v4(52.28,59.23) v4(52.51,71.74) v4(52.51,71.3) v4(52.51,70.84) v4(52.53,70.39) v4(53.05,72.48) v4(53.05,71.97) v4(53.05,71.46) v4(53.41,73.69) v4(53.43,73.12) v4(53.56,72.48) v4(53.56,71.97) v4(53.56,71.46) v4(53.8,64.64) v4(53.77,60.82) v4(53.88,77.38) v4(53.8,65.18) v4(53.92,73.69) v4(53.94,73.12) v4(53.9,59.23) v4(54.06,72.48) v4(54.06,71.97) v4(54.06,71.46) v4(54.38,65.2) v4(54.38,64.66) v4(54.42,73.69) v4(54.44,73.12) v4(54.57,72.48) v4(54.57,71.97) v4(54.57,71.46) v4(54.92,65.2) v4(54.92,64.67) v4(54.93,63.79) v4(55.32,73.54) v4(55.35,72.54) v4(55.39,60.82) v4(55.42,71.36) v4(55.47,65.2) v4(55.47,64.67) v4(55.47,64.12) v4(55.45,63.57) v4(55.46,62.98) v4(55.44,62.43) v4(55.51,77.38) v4(55.53,65.82) v4(55.93,66.19) v4(56.03,65.21) v4(56.03,64.67) v4(56.03,64.13) v4(56.02,63.57) v4(56.02,62.98) v4(56.01,62.43) v4(56.22,73.57) v4(56.24,72.58) v4(56.29,71.38) v4(56.28,66.5) v4(56.21,65.81) v4(56.58,65.2) v4(56.57,64.66) v4(56.58,64.11) v4(56.56,63.56) v4(56.56,62.97) v4(56.55,62.42) v4(57.02,60.82) v4(57.13,77.38) v4(57.15,59.23) v4(58.53,74.23) v4(58.52,73.31) v4(58.56,72.26) v4(58.67,69.67) v4(58.67,68.74) v4(58.65,67.54) v4(58.64,60.82) v4(58.76,77.38) v4(58.78,59.23) v4(60.27,60.82) v4(60.39,77.38) v4(60.4,59.23) v4(61.89,60.82) v4(62.01,77.38) v4(62.03,59.23) v4(63.52,60.82) v4(63.64,77.38) v4(63.65,59.23) v4(65.15,60.82) v4(65.26,77.38) v4(65.28,59.23) v4(66.77,60.82) v4(66.89,77.38) v4(66.91,59.23) v4(67.2,58) v4(67.55,57.57) v4(67.74,58.08) v4(67.74,56.46) v4(67.74,53.21) v4(68.52,58.05) v4(68.92,77.14) v4(68.92,75.52) v4(68.92,73.89) v4(68.92,72.27) v4(68.92,70.64) v4(68.92,69.02) v4(68.92,67.39) v4(68.92,65.77) v4(68.92,64.14) v4(68.92,62.51) v4(68.92,60.89) v4(69.49,53.03) v4(71.46,53.04) v4(72.63,51.61) v4(72.63,49.99) v4(72.63,48.36) v4(72.63,46.74) v4(72.63,45.17) v4(72.63,43.48) v4(72.63,41.86) v4(72.74,53.03) v4(74.17,75.18) v4(74.17,73.55) v4(74.17,71.93) v4(74.17,70.3) v4(74.17,68.68) v4(74.17,67.05) v4(74.17,65.43) v4(74.17,63.8) v4(74.17,62.17) v4(74.17,60.55) v4(74.17,58.92) v4(74.17,57.3) v4(74.17,55.67) v4(74.17,54.05) v4(74.17,52.42) v4(74.17,50.79) v4(74.17,42.67) v4(74.17,41.04) v4(74.17,39.42) v4(74.17,37.79) v4(74.17,36.16) v4(74.17,34.54) v4(74.17,32.91) v4(74.17,31.29) v4(75,76.85) v4(75.83,77.48) v4(75.97,75.96) v4(75.97,74.33) v4(75.97,72.71) v4(75.97,71.08) v4(75.97,69.46) v4(75.97,67.83) v4(75.97,66.21) v4(75.97,64.58) v4(75.97,59.7) v4(75.97,58.08) v4(75.97,56.45) v4(75.97,54.83) v4(75.97,53.2) v4(75.97,51.58) v4(75.97,49.95) v4(75.97,48.32) v4(75.97,46.7) v4(75.97,45.07) v4(75.97,43.45) v4(75.97,41.82) v4(75.97,40.2) v4(76.15,78) v4(77.3,79.15) v4(77.32,39.72) v4(77.46,77.48) v4(78.45,80.3) v4(78.95,39.72) v4(79.08,77.48) v4(79.99,80.64) v4(80.58,39.72) v4(80.71,77.48) v4(81.62,80.64) v4(82.33,77.48) v4(83.24,80.64) v4(83.62,30.72) v4(83.96,77.48) v4(84.87,80.64) v4(85.25,30.72) v4(86.49,80.54) v4(88.12,80.54) v4(88.5,30.72) v4(89.5,77.47) v4(89.74,80.54) v4(90.13,30.72) v4(90.46,77.48) v4(91.37,80.54) v4(91.75,30.72) v4(92.09,77.48) v4(92.99,80.54) v4(93.38,30.72) v4(93.71,77.48) v4(93.76,28.59) v4(94.37,28.6) v4(94.62,80.54) v4(94.88,28.6) v4(95,30.72) v4(95.34,77.48) v4(95.41,28.59) v4(95.91,28.61) v4(96.25,80.64) v4(96.42,28.61) v4(96.63,30.72) v4(96.96,77.48) v4(97.87,80.64) v4(98.08,18.84) v4(98.25,30.72) v4(98.59,77.48) v4(98.62,19.04) v4(99.12,18.81) v4(99.5,80.64) v4(99.61,19.07) v4(99.64,18.32) v4(99.88,30.72) v4(100.21,77.48) v4(100.43,79.53) v4(100.48,19.07) v4(100.57,18.32) v4(101.28,18.71) v4(101.49,18.2) v4(101.71,77.48) v4(103.47,77.48) v4(103.76,52.88) v4(104.31,53.23) v4(104.96,39.72) v4(105.09,77.48) v4(105.57,53.07) v4(106.28,53.08) v4(106.58,39.72) v4(106.72,77.48) v4(108.34,77.48) v4(109.09,18.79) v4(109.39,19.17) v4(109.97,77.48) v4(109.93,19.17) v4(110.22,30.14) v4(110.44,19.15) v4(110.89,66.69) v4(110.89,65.95) v4(110.87,65.37) v4(110.89,64.69) v4(110.86,30.14) v4(110.92,63.93) v4(110.92,63.29) v4(111.15,71.63) v4(111.46,39.72) v4(111.49,30.14) v4(111.59,77.48) v4(111.71,71.13) v4(111.99,11.05) v4(111.99,10.58) v4(112.13,30.14) v4(112.28,70.6) v4(112.53,11.04) v4(112.53,10.57) v4(112.8,70.07) v4(113.09,39.72) v4(113.08,11.04) v4(113.08,10.57) v4(113.22,77.48) v4(113.26,69.56) v4(113.63,11.04) v4(113.63,10.57) v4(113.71,69.14) v4(114.15,68.7) v4(114.17,11.04) v4(114.17,10.57) v4(114.59,68.25) v4(114.73,11.04) v4(114.73,10.57) v4(114.85,77.48) v4(115.07,67.79) v4(115.26,11.04) v4(115.26,10.57) v4(115.62,67.12) v4(115.8,11.04) v4(115.81,10.58) v4(116.09,65.99) v4(116.07,65.29) v4(116.08,64.6) v4(116.35,11.05) v4(116.35,10.58) v4(116.5,77.41) v4(119.99,77.54) v4(120.12,76.36) v4(120.12,74.74) v4(120.12,73.11) v4(120.12,71.49) v4(120.12,69.86) v4(120.12,68.24) v4(120.12,66.61) v4(120.12,64.99) v4(120.12,63.36) v4(122.39,62.68) v4(123.37,35.72) v4(123.37,29.83) v4(123.37,28.2) v4(123.37,26.57) v4(123.37,24.95) v4(123.37,23.32) v4(123.37,20.07) v4(124.01,62.68) v4(125.64,62.68) v4(127.26,62.68) v4(128.74,19.24) v4(129.35,19.24) v4(129.48,16.37) v4(129.86,15.89) v4(129.96,19.24) v4(130.06,16.37) v4(130.37,15.41) v4(131.08,15.43) v4(132.09,15.41) v4(132.23,7.33) v4(132.68,7.01) v4(134.01,7.33) v4(134.65,6.76) v4(135.9,77.65) v4(135.9,76.03) v4(135.9,74.4) v4(135.9,72.78) v4(135.9,71.15) v4(136.55,6.72) v4(136.79,25.31) v4(136.89,22.34) v4(137.38,25.29) v4(137.31,6.72) v4(137.5,22.34) v4(138.07,6.72) v4(138.26,28.11) v4(138.53,7.03) v4(138.67,28.49) v4(140.61,79.18) v4(142.23,79.18) v4(143.86,79.18) v4(144.38,15.22) v4(145.49,79.18) v4(145.88,18.51) v4(146.3,18.83) v4(146.74,18.53) v4(147.11,79.18) v4(147.29,18.71) v4(148.74,79.18) v4(150.36,79.18) v4(151.49,47.25) v4(151.49,46.06) v4(151.49,44.87) v4(151.49,43.67) v4(151.49,42.48) v4(151.99,79.18) v4(153.61,79.18) v4(153.84,40.8) v4(153.84,37.22) v4(154.18,43.79) v4(154.74,47.19) v4(155.24,79.18) v4(155.38,43.79) v4(155.93,47.19) v4(156.57,43.79) v4(156.87,79.18) v4(156.94,45.35) v4(157.13,47.19) v4(157.76,43.79) v4(158.32,47.19) v4(158.49,79.18) v4(158.96,43.79) v4(160.12,79.18) v4(161.33,43.19) v4(161.31,39.49) v4(161.74,79.18) v4(162.02,40.4) v4(162.11,39.5) v4(162.3,43.19) v4(162.3,40.8) v4(162.31,42.05) v4(162.63,49.77) v4(162.75,39.17) v4(163.13,38.68) v4(163.71,40.75) v4(164.29,40.79) v4(164.65,43.19) v4(164.65,41.99) v4(164.78,39.15) v4(164.93,39.98) v4(164.97,10.33) v4(164.97,8.7) v4(164.97,7.08) v4(165.71,40.02) v4(165.94,47.18) v4(165.93,46.66) v4(166.02,45.92) v4(166.12,45.29) v4(166.2,4.72) v4(166.62,79.18) v4(166.94,45.2) v4(167.56,45.29) v4(167.83,4.72) v4(168.17,47.8) v4(168.14,46.59) v4(168.19,44.9) v4(168.17,44.13) v4(168.21,45.7) v4(168.4,43.19) v4(168.4,41.99) v4(169.38,14.76) v4(169.38,13.73) v4(169.41,49.14) v4(169.41,47.94) v4(169.41,46.75) v4(169.41,45.55) v4(169.41,44.36) v4(169.41,43.17) v4(169.41,14.24) v4(169.45,4.72) v4(169.89,14.76) v4(169.89,13.73) v4(169.91,14.24) v4(170.39,14.76) v4(170.4,13.73) v4(170.42,14.24) v4(170.92,14.76) v4(170.92,14.26) v4(170.92,13.75) v4(170.92,13.24) v4(170.92,12.73) v4(170.92,12.22) v4(171.42,14.76) v4(171.42,14.26) v4(171.42,13.75) v4(171.42,13.24) v4(171.42,12.73) v4(171.42,12.22) v4(171.87,46.75) v4(171.87,45.55) v4(171.87,44.36) v4(171.87,43.17) v4(171.93,14.76) v4(171.93,14.26) v4(171.93,13.75) v4(171.93,13.24) v4(171.93,12.73) v4(171.93,12.22) v4(172.46,14.77) v4(172.96,14.77) v4(173.12,79.18) v4(173.47,14.77) v4(174.53,26.87) v4(174.75,79.18) v4(175.09,26.87) v4(175.51,40.79) v4(175.68,26.83) v4(176.24,26.79) v4(176.37,79.18) v4(176.71,26.76) v4(176.82,40.12) v4(177.27,26.76) v4(177.86,26.72) v4(178,79.18) v4(178.37,27) v4(178.39,14.8) v4(178.39,14.29) v4(178.39,13.78) v4(178.38,11.78) v4(178.41,13.29) v4(178.41,12.79) v4(178.41,12.28) v4(178.94,26.93) v4(178.9,14.82) v4(178.9,14.31) v4(178.9,13.81) v4(178.9,13.3) v4(178.9,12.79) v4(178.9,12.28) v4(178.9,11.77) v4(179.42,26.9) v4(179.41,14.82) v4(179.41,14.31) v4(179.41,13.81) v4(179.41,13.3) v4(179.41,12.79) v4(179.41,12.28) v4(179.41,11.77) v4(179.62,79.18) v4(179.98,26.9) v4(179.92,14.82) v4(179.92,14.31) v4(179.92,13.81) v4(179.92,13.3) v4(179.92,12.79) v4(179.92,12.28) v4(179.92,11.77) v4(180.07,44.29) v4(180.43,14.82) v4(180.57,26.87) v4(180.92,14.82) v4(181.25,79.18) v4(181.35,27) v4(182.02,27.05) v4(182.58,27.05) v4(182.87,79.18) v4(183.17,26.76) v4(184.5,79.18) v4(185.13,11.65) v4(185.13,11.14) v4(185.13,10.63) v4(185.64,11.65) v4(185.64,11.14) v4(185.64,10.63) v4(186.13,79.18) v4(186.14,11.65) v4(186.14,11.14) v4(186.14,10.63) v4(186.65,13.68) v4(186.65,13.17) v4(186.65,12.66) v4(186.65,12.16) v4(186.65,11.65) v4(186.65,11.14) v4(186.65,10.63) v4(187.16,13.68) v4(187.16,13.17) v4(187.16,12.66) v4(187.16,12.16) v4(187.16,11.65) v4(187.16,11.14) v4(187.16,10.63) v4(187.67,13.68) v4(187.67,13.17) v4(187.67,12.66) v4(187.67,12.16) v4(187.67,11.65) v4(187.67,11.14) v4(187.67,10.63) v4(187.75,79.18) v4(189.38,79.18) v4(190.72,69.31) v4(190.72,68.8) v4(191.03,69.64) v4(191.12,79.13) v4(191.22,68.8) v4(191.47,70.42) v4(191.46,69.94) v4(191.46,69.28) v4(191.56,72.19) v4(191.5,70.97) v4(191.73,68.8) v4(196.7,59.21) v4(196.86,31.94) v4(197.03,22.85) v4(197.15,58.95) v4(197.51,79.18) v4(198.08,74.61) v4(198.08,72.99) v4(198.08,71.36) v4(198.08,69.74) v4(198.68,66.52) v4(199.1,64.96) v4(199.23,52.59) v4(199.23,50.97) v4(199.23,49.34) v4(199.23,47.72) v4(199.23,46.09) v4(199.23,44.47) v4(199.53,63.39) v4(199.96,61.82) v4(200.57,60.27) v4(200.6,33.09) v4(200.53,32.59) v4(200.7,33.57) v4(200.77,53.66) v4(200.91,43.48) v4(202.12,9.26) v4(202.12,8.75) v4(202.12,8.24) v4(202.12,7.74) v4(202.53,43.48) v4(202.65,9.26) v4(202.65,8.75) v4(202.65,8.24) v4(202.65,7.74) v4(203.14,9.23) v4(203.14,8.73) v4(203.14,8.22) v4(203.14,7.71) v4(203.62,9.23) v4(203.62,8.73) v4(203.62,8.22) v4(203.62,7.71) v4(204.16,43.48) v4(204.1,9.23) v4(204.1,8.73) v4(204.1,8.22) v4(204.1,7.71) v4(205.85,40) v4(206.27,38.43) v4(206.69,36.86) v4(207.1,35.29) v4(207.52,33.72) v4(207.94,32.15) v4(208.36,30.58) v4(208.78,29.01) v4(209.2,27.44) v4(209.61,25.87) v4(210.03,24.29) v4(210.43,22.37) v4(210.43,20.75) v4(210.43,19.12) v4(210.43,17.5) v4(210.43,15.87) v4(210.43,14.24) v4(210.43,12.62) v4(210.43,10.99) v4(210.43,9.37) v5(5.23,30.02) v5(5.23,29.67) v5(5.23,28.4) v5(5.23,28.04) v5(5.23,26.77) v5(5.23,26.42) v5(5.23,25.15) v5(5.23,24.79) v5(5.23,23.52) v5(5.23,23.17) v5(5.23,21.9) v5(5.23,21.54) v5(5.23,20.27) v5(5.23,19.92) v5(5.23,18.65) v5(5.23,18.29) v5(5.23,17.02) v5(5.23,16.66) v5(5.23,15.39) v5(5.23,15.04) v5(5.23,13.77) v5(5.23,13.41) v5(5.23,12.14) v5(5.23,11.79) v5(7.55,10.21) v5(7.83,20.5) v5(7.83,19.61) v5(7.83,18.72) v5(7.83,17.83) v5(7.91,10.21) v5(8.05,13.4) v5(8.03,12.97) v5(8.05,12.18) v5(8.02,11.77) v5(8.26,31.29) v5(8.61,31.29) v5(8.76,29.63) v5(8.82,28.69) v5(9.18,10.21) v5(9.28,29.64) v5(9.53,10.21) v5(9.79,29.62) v5(9.76,28.65) v5(9.75,24.67) v5(9.88,31.29) v5(10.13,24.71) v5(10.24,31.29) v5(10.34,29.63) v5(10.7,28.71) v5(10.83,24.68) v5(10.8,10.21) v5(10.93,29.64) v5(11.16,15.24) v5(11.16,10.21) v5(11.2,24.74) v5(11.51,31.29) v5(11.75,15.21) v5(11.86,31.29) v5(12.43,10.21) v5(12.78,10.21) v5(13.13,31.29) v5(13.49,31.29) v5(13.78,15.5) v5(14.06,28.67) v5(14.05,10.21) v5(14.44,28.67) v5(14.41,10.21) v5(14.75,62.64) v5(14.75,62.29) v5(14.75,61.02) v5(14.75,60.66) v5(14.75,44.76) v5(14.75,44.41) v5(14.75,43.14) v5(14.75,39.89) v5(14.75,39.53) v5(14.75,38.26) v5(14.75,37.9) v5(14.75,36.63) v5(14.75,36.28) v5(14.75,35.01) v5(14.75,34.65) v5(14.75,33.38) v5(14.75,33.03) v5(14.75,31.76) v5(14.75,31.4) v5(14.88,38.92) v5(14.82,28.67) v5(14.82,28.28) v5(14.82,27.9) v5(14.82,27.52) v5(14.82,27.14) v5(15.05,63.32) v5(15.05,61.69) v5(15.03,59.49) v5(15.02,58.3) v5(15.01,57.25) v5(15.01,56.09) v5(15.2,28.67) v5(15.2,28.28) v5(15.2,27.9) v5(15.2,27.52) v5(15.2,27.14) v5(15.68,10.21) v5(15.84,17.31) v5(15.83,17.01) v5(15.83,16.63) v5(15.83,16.25) v5(15.83,15.87) v5(16.03,10.21) v5(16.22,17.36) v5(16.21,17.01) v5(16.21,16.63) v5(16.21,16.25) v5(16.21,15.87) v5(16.55,17.44) v5(16.55,17.09) v5(16.91,64.82) v5(16.95,17.82) v5(16.93,17.44) v5(16.93,17.09) v5(17.33,17.82) v5(17.31,17.44) v5(17.3,17.09) v5(17.3,10.21) v5(17.66,10.21) v5(18.93,10.21) v5(19.29,10.21) v5(20.56,10.15) v5(20.91,10.15) v5(22.18,10.15) v5(22.44,58.9) v5(22.44,58.25) v5(22.44,56.95) v5(22.54,10.15) v5(22.63,62) v5(23.09,57.6) v5(23.09,55.65) v5(23.56,55.38) v5(23.79,62.04) v5(23.74,60.2) v5(23.74,59.55) v5(23.74,53.7) v5(23.81,10.15) v5(24.16,10.15) v5(24.39,60.2) v5(24.39,58.9) v5(24.66,62.71) v5(25.04,60.2) v5(25.04,59.55) v5(25.04,58.9) v5(25.04,57.6) v5(25.04,56.95) v5(25.04,56.3) v5(25.04,55.65) v5(25.04,55) v5(25.43,10.15) v5(25.69,60.2) v5(25.69,59.55) v5(25.69,58.9) v5(25.79,10.15) v5(25.98,62.73) v5(26.13,64.29) v5(26.34,60.2) v5(26.34,59.55) v5(26.34,58.9) v5(26.34,57.6) v5(26.49,64.29) v5(26.99,60.2) v5(26.99,59.55) v5(26.99,58.9) v5(26.99,53.05) v5(26.94,40.97) v5(26.94,40.62) v5(26.94,39.35) v5(26.94,38.99) v5(26.94,37.72) v5(26.94,37.37) v5(26.94,31.22) v5(26.94,30.86) v5(26.94,24.72) v5(26.94,24.36) v5(26.94,23.09) v5(26.94,22.74) v5(26.94,21.47) v5(26.94,21.11) v5(26.94,19.84) v5(26.94,19.48) v5(26.94,18.21) v5(26.94,17.86) v5(26.94,16.59) v5(26.94,16.23) v5(26.94,14.96) v5(26.94,14.61) v5(26.94,13.13) v5(26.94,12.77) v5(27.32,41.87) v5(27.64,60.2) v5(27.64,56.95) v5(27.64,56.3) v5(27.64,55.65) v5(29,64.29) v5(29.01,44.44) v5(29.36,64.29) v5(29.59,60.2) v5(29.65,45.42) v5(30.24,59.55) v5(30.63,64.29) v5(30.99,64.29) v5(30.94,57.68) v5(32.64,64.29) v5(32.99,64.29) v5(33.94,64.07) v5(35.89,64.29) v5(36.24,64.29) v5(36.68,56.36) v5(36.86,56.66) v5(36.99,57.24) v5(37.53,57.74) v5(37.71,64.26) v5(37.72,58.04) v5(37.91,58.73) v5(38.07,64.26) v5(38.21,61.64) v5(38.35,59.52) v5(38.35,59.16) v5(39.12,53.34) v5(39.48,53.34) v5(40.75,53.34) v5(41.1,53.34) v5(42.37,53.34) v5(42.73,53.34) v5(43.97,59.55) v5(43.9,58.37) v5(43.97,56.25) v5(43.97,55.9) v5(43.97,54.63) v5(43.97,54.27) v5(43.97,53) v5(43.97,52.65) v5(44.3,58.32) v5(44.33,59.55) v5(44.83,59.51) v5(45.06,59.2) v5(45.6,59.55) v5(45.95,59.55) v5(46.54,59.52) v5(46.77,59.21) v5(47.22,59.55) v5(47.58,59.55) v5(48.19,59.51) v5(48.42,59.21) v5(48.85,59.55) v5(49.2,59.55) v5(50.45,77.7) v5(50.45,76.04) v5(50.45,75.69) v5(50.45,74.42) v5(50.45,74.06) v5(50.45,72.79) v5(50.45,72.43) v5(50.45,71.16) v5(50.45,70.81) v5(50.45,69.54) v5(50.45,69.18) v5(50.45,67.91) v5(50.45,67.56) v5(50.45,66.29) v5(50.45,65.93) v5(50.45,64.66) v5(50.45,64.31) v5(50.45,63.04) v5(50.45,62.68) v5(50.45,61.35) v5(50.45,60.99) v5(50.47,59.55) v5(50.81,77.7) v5(50.83,59.55) v5(51.38,59.51) v5(51.61,59.21) v5(51.79,62.53) v5(51.8,62.16) v5(51.9,70.07) v5(51.9,69.69) v5(51.9,69.31) v5(51.96,60.5) v5(52.08,77.7) v5(52.1,59.55) v5(52.17,62.53) v5(52.18,62.16) v5(52.25,70.07) v5(52.29,69.69) v5(52.29,69.31) v5(52.32,60.5) v5(52.44,77.7) v5(52.45,59.55) v5(52.55,62.53) v5(52.56,62.16) v5(52.63,70.07) v5(52.67,69.69) v5(52.67,69.31) v5(52.94,62.53) v5(52.94,62.16) v5(53.05,70.96) v5(53.05,70.58) v5(53,70.08) v5(53.05,69.69) v5(53.05,69.31) v5(53.05,63.54) v5(53.05,63.15) v5(53.11,64.13) v5(53.16,62.83) v5(53.11,6.63) v5(53.35,62.16) v5(53.43,70.96) v5(53.43,70.58) v5(53.43,70.07) v5(53.43,69.69) v5(53.43,69.31) v5(53.45,64.13) v5(53.47,63.41) v5(53.49,63.04) v5(53.59,60.5) v5(53.65,6.65) v5(53.71,77.7) v5(53.72,59.55) v5(53.81,70.96) v5(53.81,70.58) v5(53.83,64.13) v5(53.85,63.41) v5(53.88,63.04) v5(53.94,60.5) v5(54.06,77.7) v5(54.08,59.55) v5(54.19,70.96) v5(54.19,70.58) v5(54.21,64.13) v5(54.23,63.41) v5(54.26,63.04) v5(54.25,6.69) v5(54.57,70.96) v5(54.57,70.58) v5(54.59,64.13) v5(54.62,63.41) v5(54.64,63.04) v5(54.77,59.52) v5(55.12,59.52) v5(55.21,60.5) v5(55.33,77.7) v5(55.57,60.5) v5(55.69,77.7) v5(55.75,6.23) v5(56.29,6.25) v5(56.61,59.38) v5(56.84,60.5) v5(56.89,6.29) v5(56.96,77.7) v5(56.97,59.55) v5(57.2,60.5) v5(57.31,77.7) v5(57.33,59.55) v5(58.09,6.17) v5(58.47,60.5) v5(58.58,77.7) v5(58.6,59.55) v5(58.63,6.19) v5(58.65,4.42) v5(58.82,60.5) v5(58.94,77.7) v5(58.96,59.55) v5(59.24,4.46) v5(60.09,60.5) v5(60.17,4.48) v5(60.23,59.55) v5(60.2,5.22) v5(60.45,60.5) v5(60.56,77.7) v5(60.58,59.55) v5(60.77,6.19) v5(60.74,5.24) v5(60.71,4.51) v5(61.37,6.23) v5(61.34,5.28) v5(61.31,4.55) v5(61.72,60.5) v5(61.83,77.7) v5(61.85,59.55) v5(62.07,60.5) v5(62.19,77.7) v5(62.21,59.55) v5(62.28,6.19) v5(62.26,4.47) v5(62.33,5.28) v5(62.82,6.21) v5(62.87,5.3) v5(62.8,4.49) v5(63.34,60.5) v5(63.46,77.7) v5(63.48,59.55) v5(63.42,6.25) v5(63.47,5.34) v5(63.4,4.53) v5(63.7,60.5) v5(63.81,77.7) v5(63.83,59.55) v5(63.85,9.22) v5(63.99,9.87) v5(64.39,9.24) v5(64.59,9.91) v5(64.59,6.27) v5(64.52,5.33) v5(64.53,4.45) v5(64.87,10.55) v5(64.97,60.5) v5(64.99,9.28) v5(65.08,77.7) v5(65.06,5.35) v5(65.08,4.47) v5(65.1,59.55) v5(65.14,6.29) v5(65.32,60.5) v5(65.44,77.7) v5(65.46,59.55) v5(65.66,5.39) v5(65.68,4.51) v5(65.73,6.33) v5(66.34,10.54) v5(66.59,60.5) v5(66.71,77.7) v5(66.73,59.55) v5(66.75,5.38) v5(66.77,4.5) v5(66.88,10.56) v5(66.83,6.32) v5(66.95,60.5) v5(67.07,77.7) v5(67.08,59.55) v5(67.13,9.27) v5(67.29,5.4) v5(67.37,6.34) v5(67.31,4.52) v5(67.48,10.6) v5(67.67,9.29) v5(67.74,9.9) v5(67.89,5.44) v5(67.97,6.38) v5(67.91,4.56) v5(68.06,58.26) v5(68.06,57.9) v5(68.06,56.63) v5(68.06,56.28) v5(68.06,53.38) v5(68.06,53.03) v5(68.28,9.92) v5(68.27,9.33) v5(68.6,44.31) v5(68.6,43.96) v5(68.66,49.81) v5(68.66,49.45) v5(68.65,46.69) v5(68.65,46.33) v5(69.09,6.34) v5(69.01,5.4) v5(69.03,4.53) v5(69.23,77.32) v5(69.23,76.97) v5(69.23,75.7) v5(69.23,75.34) v5(69.23,74.07) v5(69.23,73.72) v5(69.23,72.45) v5(69.23,72.09) v5(69.23,70.82) v5(69.23,70.46) v5(69.23,69.19) v5(69.23,68.84) v5(69.23,67.57) v5(69.23,67.21) v5(69.23,65.94) v5(69.23,65.59) v5(69.23,64.32) v5(69.23,63.96) v5(69.23,62.69) v5(69.23,62.34) v5(69.23,61.07) v5(69.23,60.71) v5(69.31,53.34) v5(69.54,49.76) v5(69.54,49.4) v5(69.56,5.42) v5(69.57,4.55) v5(69.7,58.43) v5(69.7,58.07) v5(69.66,53.34) v5(69.63,6.36) v5(69.81,57.16) v5(69.81,56.81) v5(69.96,46.78) v5(69.96,46.43) v5(70.15,5.47) v5(70.17,4.59) v5(70.21,68.06) v5(70.21,67.7) v5(70.24,44.31) v5(70.24,43.96) v5(70.23,6.4) v5(70.41,66.74) v5(70.41,66.38) v5(70.84,49.76) v5(70.84,49.4) v5(70.94,5.43) v5(70.96,4.55) v5(71.02,6.37) v5(71.27,46.7) v5(71.27,46.35) v5(71.36,50.84) v5(71.49,5.45) v5(71.56,6.39) v5(71.5,4.57) v5(71.69,51.98) v5(71.73,64) v5(71.73,63.64) v5(71.7,44.42) v5(71.7,44.06) v5(72.08,5.49) v5(72.16,6.43) v5(72.1,4.62) v5(72.53,61.18) v5(72.53,60.82) v5(72.56,53.34) v5(72.61,4.57) v5(72.9,44.63) v5(72.9,44.23) v5(72.82,5.58) v5(72.91,53.34) v5(72.94,51.79) v5(72.94,51.43) v5(72.9,50.93) v5(72.91,50.58) v5(72.94,50.16) v5(72.94,49.81) v5(72.95,49.3) v5(72.97,48.92) v5(72.94,48.54) v5(72.94,48.18) v5(72.92,47.81) v5(72.94,47.4) v5(72.94,46.91) v5(72.94,46.56) v5(72.97,46.16) v5(72.96,45.78) v5(72.94,45.35) v5(72.94,45) v5(72.94,43.66) v5(72.94,43.31) v5(72.94,42.04) v5(72.94,41.68) v5(72.92,6.42) v5(73.15,4.59) v5(73.36,5.6) v5(73.46,6.44) v5(73.75,4.63) v5(73.96,5.65) v5(74.06,6.48) v5(74.75,4.57) v5(75,6.27) v5(75.29,4.59) v5(75.55,6.29) v5(75.65,77.79) v5(75.65,76.14) v5(75.65,75.78) v5(75.65,74.51) v5(75.65,74.16) v5(75.65,72.89) v5(75.65,72.53) v5(75.65,71.26) v5(75.65,70.9) v5(75.65,69.63) v5(75.65,69.28) v5(75.65,68.01) v5(75.65,67.65) v5(75.65,66.38) v5(75.65,66.03) v5(75.65,64.76) v5(75.65,64.4) v5(75.65,59.88) v5(75.65,59.53) v5(75.65,58.26) v5(75.65,57.9) v5(75.65,56.63) v5(75.65,56.27) v5(75.65,55) v5(75.65,54.65) v5(75.65,53.38) v5(75.65,53.02) v5(75.65,51.75) v5(75.65,51.4) v5(75.65,50.13) v5(75.65,49.77) v5(75.65,48.5) v5(75.65,48.15) v5(75.65,46.88) v5(75.65,46.52) v5(75.65,45.25) v5(75.65,44.9) v5(75.65,43.63) v5(75.65,43.27) v5(75.65,42) v5(75.65,41.64) v5(75.65,40.37) v5(75.65,40.02) v5(75.81,5.34) v5(75.89,4.63) v5(76.14,6.33) v5(76.35,5.36) v5(76.68,4.54) v5(76.95,5.41) v5(77.15,39.41) v5(77.28,77.79) v5(77.22,4.56) v5(77.36,6.32) v5(77.5,39.41) v5(77.63,77.79) v5(77.82,4.6) v5(77.91,6.34) v5(77.9,5.38) v5(78.44,5.4) v5(78.51,6.38) v5(78.77,39.41) v5(78.84,43.76) v5(78.9,77.79) v5(79.04,5.44) v5(79.13,39.41) v5(79.26,77.79) v5(79.34,44.39) v5(79.6,6.09) v5(79.98,44.97) v5(80.14,6.11) v5(80.23,68.01) v5(80.4,39.41) v5(80.53,77.79) v5(80.6,42.45) v5(80.75,39.41) v5(80.74,6.15) v5(80.89,77.79) v5(81.7,41.26) v5(82.16,77.79) v5(82.12,69.16) v5(82.3,40.95) v5(82.34,8.48) v5(82.42,70.45) v5(82.51,77.79) v5(83.68,73.07) v5(83.78,77.79) v5(83.72,70.86) v5(84.14,77.79) v5(85.45,77.61) v5(86.02,47.09) v5(86.2,77.61) v5(86.99,77.61) v5(87.72,77.59) v5(88.1,59.49) v5(88.15,60.23) v5(88.52,77.6) v5(88.89,59.01) v5(89.32,77.79) v5(89.67,77.79) v5(89.85,60.11) v5(90.17,41.63) v5(90.28,77.79) v5(90.64,77.79) v5(90.82,61.03) v5(91.36,41.32) v5(91.5,60.48) v5(91.91,77.79) v5(92.26,77.79) v5(93.32,41.76) v5(93.53,77.79) v5(93.69,71.78) v5(93.89,77.79) v5(94.08,39.75) v5(94.55,49.32) v5(95.04,41.59) v5(95.16,77.79) v5(95.21,48.85) v5(95.52,77.79) v5(95.98,62.83) v5(95.92,47.7) v5(96.06,65.07) v5(96.15,63.82) v5(96.44,46.63) v5(96.5,50.51) v5(96.79,77.79) v5(97.14,77.79) v5(97.12,62.69) v5(97.51,58.72) v5(97.59,50.23) v5(97.74,64.43) v5(98.41,77.79) v5(98.77,77.79) v5(98.91,51.49) v5(99.45,50.92) v5(99.89,52.03) v5(100.04,77.79) v5(100.39,77.79) v5(100.34,54.47) v5(100.53,50.83) v5(100.57,49.82) v5(100.57,47.35) v5(101.54,77.79) v5(101.53,39.41) v5(101.75,62.96) v5(101.89,77.79) v5(101.89,39.41) v5(103.29,77.79) v5(103.64,77.79) v5(104.78,39.41) v5(104.91,77.79) v5(105.14,39.41) v5(105.27,77.79) v5(106,55.89) v5(106.41,39.41) v5(106.54,77.79) v5(106.76,39.41) v5(106.9,77.79) v5(108.17,77.79) v5(108.52,77.79) v5(109.79,77.79) v5(110.15,77.79) v5(110.57,71.62) v5(110.8,71.39) v5(111.26,70.93) v5(111.28,39.41) v5(111.42,77.79) v5(111.62,70.63) v5(111.64,39.41) v5(111.77,77.79) v5(111.78,11.88) v5(111.78,11.5) v5(112.11,70.07) v5(112.16,11.88) v5(112.16,11.5) v5(112.46,69.73) v5(112.97,69.21) v5(112.91,39.41) v5(113.04,77.79) v5(113,11.88) v5(113,11.5) v5(113.26,39.41) v5(113.4,77.79) v5(113.31,68.89) v5(113.39,11.88) v5(113.39,11.5) v5(113.77,68.4) v5(114.07,77.81) v5(114.16,68.03) v5(114.28,11.89) v5(114.28,11.51) v5(114.53,39.41) v5(114.67,77.79) v5(114.65,67.53) v5(114.66,11.89) v5(114.66,11.51) v5(114.89,39.41) v5(115.02,77.79) v5(115,67.18) v5(115.1,21.23) v5(115.28,77.37) v5(115.3,22.35) v5(115.5,11.86) v5(115.5,11.48) v5(115.65,66.55) v5(115.73,66.19) v5(115.9,11.86) v5(115.9,11.48) v5(116.12,77.32) v5(116.22,23.26) v5(116.58,21.37) v5(116.62,24.31) v5(116.81,11.87) v5(116.81,11.49) v5(116.94,77.33) v5(117.28,77.33) v5(117.52,64.67) v5(119.67,77.38) v5(120.07,76.95) v5(120.08,75.63) v5(120.3,77.71) v5(120.3,77.36) v5(120.44,76.54) v5(120.44,76.19) v5(120.44,74.92) v5(120.44,74.56) v5(120.44,73.29) v5(120.44,72.94) v5(120.44,71.67) v5(120.44,71.31) v5(120.44,70.04) v5(120.44,68.41) v5(120.44,68.06) v5(120.44,66.79) v5(120.44,66.43) v5(120.44,65.16) v5(120.44,64.81) v5(120.44,63.54) v5(120.44,63.18) v5(122.21,63) v5(122.57,63) v5(123.06,38.13) v5(123.06,37.78) v5(123.06,35.9) v5(123.06,35.54) v5(123.06,30) v5(123.06,29.65) v5(123.06,28.38) v5(123.06,28.02) v5(123.06,26.75) v5(123.06,26.4) v5(123.06,25.13) v5(123.06,24.77) v5(123.06,23.5) v5(123.06,23.14) v5(123.06,20.25) v5(123.06,19.89) v5(123.84,63) v5(124.19,63) v5(125.46,63) v5(125.82,63) v5(127.09,63) v5(127.44,63) v5(129.08,19.58) v5(129.31,18.76) v5(129.63,19.58) v5(129.95,18.76) v5(130.18,19.58) v5(130.2,23.01) v5(130.57,22.7) v5(130.57,22.37) v5(130.54,22.01) v5(130.59,18.78) v5(130.72,16.55) v5(130.72,16.22) v5(130.85,22.54) v5(130.85,22.21) v5(131.03,24.4) v5(131.1,23.46) v5(131.15,23.1) v5(131.13,22.72) v5(131.13,22.39) v5(131.18,16.55) v5(131.18,16.22) v5(134.45,7.09) v5(134.82,7.09) v5(135.21,7.1) v5(135.58,77.83) v5(135.58,77.48) v5(135.58,76.21) v5(135.58,75.85) v5(135.58,74.58) v5(135.58,74.22) v5(135.58,72.95) v5(135.58,72.6) v5(135.58,71.33) v5(135.58,70.97) v5(135.58,7.11) v5(135.97,7.1) v5(136.33,7.11) v5(136.74,7.08) v5(137,7.52) v5(137.1,7.14) v5(137.37,7.52) v5(137.5,7.11) v5(137.86,7.12) v5(139.26,29.02) v5(139.26,28.69) v5(140.43,79.5) v5(140.79,79.5) v5(140.94,31.56) v5(141.55,32.46) v5(141.85,56.04) v5(142.06,79.5) v5(142.41,79.5) v5(142.65,32.46) v5(142.98,33.29) v5(143.11,57.89) v5(143.26,48.63) v5(143.26,46.11) v5(143.68,79.5) v5(144.04,79.5) v5(144.2,14.9) v5(144.37,56.04) v5(144.56,14.9) v5(145.21,47.79) v5(145.31,79.5) v5(145.66,79.5) v5(145.66,57.83) v5(145.62,57.24) v5(145.62,56.04) v5(145.83,14.9) v5(146.01,52.72) v5(146.18,14.9) v5(146.51,48.63) v5(146.51,46.95) v5(146.51,45.27) v5(146.65,19.53) v5(146.65,19.15) v5(146.88,56.04) v5(146.93,79.5) v5(147.02,19.53) v5(147.02,19.15) v5(147.16,51.14) v5(147.16,46.95) v5(147.16,44.43) v5(147.29,79.5) v5(147.38,19.53) v5(147.38,19.15) v5(147.74,19.53) v5(147.74,19.15) v5(148.15,29.81) v5(148.56,79.5) v5(148.64,39.68) v5(148.92,79.5) v5(149.39,33.77) v5(149.66,52.72) v5(149.97,38.97) v5(150.19,79.5) v5(150.48,39.68) v5(150.54,79.5) v5(150.9,39) v5(151.48,52.72) v5(151.81,79.5) v5(151.83,39.01) v5(152.17,79.5) v5(153.17,57.89) v5(153.17,57.24) v5(153.25,39.68) v5(153.3,52.72) v5(153.44,79.5) v5(153.79,79.5) v5(154.22,51.14) v5(155.06,79.5) v5(155.13,52.72) v5(155.1,41.25) v5(155.1,39.03) v5(155.42,79.5) v5(155.69,57.24) v5(156.04,54.67) v5(156.04,54.02) v5(156.04,53.37) v5(156.04,52.72) v5(156.69,79.5) v5(156.95,52.72) v5(156.95,51.14) v5(156.95,39.03) v5(157.04,79.5) v5(158.31,79.5) v5(158.67,79.5) v5(158.77,52.72) v5(159.68,51.14) v5(159.72,40.33) v5(159.72,39.68) v5(159.94,79.5) v5(160.29,79.5) v5(160.6,52.72) v5(161.56,79.5) v5(161.92,79.5) v5(162.42,51.14) v5(162.49,39.68) v5(163.33,52.72) v5(163.33,51.14) v5(164.34,39.68) v5(164.66,12.13) v5(164.66,11.78) v5(164.66,10.51) v5(164.66,10.15) v5(164.66,8.88) v5(164.66,8.53) v5(164.66,7.26) v5(164.66,6.9) v5(164.66,5.63) v5(164.66,5.28) v5(165.26,39.68) v5(165.39,33.21) v5(165.76,57.24) v5(165.93,33.86) v5(166.02,4.4) v5(166.38,4.4) v5(166.44,79.5) v5(166.45,34.33) v5(166.8,79.5) v5(166.71,37.67) v5(166.71,36.67) v5(167.11,39.68) v5(167.65,4.4) v5(168,4.4) v5(168.96,39.68) v5(169.15,37.67) v5(169.27,4.4) v5(169.63,4.4) v5(169.88,39.68) v5(170.17,50.68) v5(170.37,30.35) v5(170.37,29.97) v5(170.62,54.01) v5(170.75,30.35) v5(170.75,29.97) v5(170.9,4.4) v5(171.13,30.35) v5(171.13,29.97) v5(171.26,4.4) v5(171.53,54.02) v5(171.53,53.37) v5(171.53,52.72) v5(171.53,52.07) v5(171.6,37.67) v5(171.6,36.67) v5(172.05,56.04) v5(172.44,52.07) v5(172.44,51.14) v5(172.49,30.55) v5(172.4,29.53) v5(172.4,29.14) v5(172.53,4.4) v5(172.65,39.03) v5(172.61,14.31) v5(172.61,13.93) v5(172.61,13.55) v5(172.61,13.17) v5(172.61,12.79) v5(172.61,12.41) v5(172.61,12.03) v5(172.61,11.65) v5(172.61,11.27) v5(172.61,10.89) v5(172.87,30.55) v5(172.88,4.4) v5(172.94,79.5) v5(172.99,14.31) v5(172.99,13.93) v5(172.99,13.55) v5(172.99,13.17) v5(172.99,12.79) v5(172.99,12.41) v5(172.99,12.03) v5(172.99,11.65) v5(172.99,11.27) v5(172.99,10.89) v5(173.3,79.5) v5(173.31,57.89) v5(173.31,57.24) v5(173.31,56.04) v5(173.36,52.07) v5(173.38,14.31) v5(173.38,13.93) v5(173.38,13.55) v5(173.38,13.17) v5(173.38,12.79) v5(173.38,12.41) v5(173.38,12.03) v5(173.38,11.65) v5(173.38,11.27) v5(173.38,10.89) v5(173.58,39.03) v5(173.71,30.58) v5(174.07,48.15) v5(174.04,40.79) v5(174.04,37.67) v5(174.09,30.58) v5(174.15,4.4) v5(174.27,55.32) v5(174.27,54.67) v5(174.27,54.02) v5(174.27,53.37) v5(174.27,52.72) v5(174.27,52.07) v5(174.57,79.5) v5(174.5,39.03) v5(174.5,38.38) v5(174.51,4.4) v5(174.79,30.57) v5(174.92,79.5) v5(175.18,52.07) v5(175.17,30.57) v5(175.78,4.4) v5(175.83,57.89) v5(175.83,57.24) v5(176.09,52.07) v5(176.19,79.5) v5(176.13,4.4) v5(176.55,79.5) v5(176.78,28.29) v5(176.78,27.91) v5(176.78,27.52) v5(176.78,27.14) v5(176.86,57.06) v5(176.99,54.57) v5(176.99,53.31) v5(176.99,52.05) v5(176.99,49.62) v5(177.16,28.29) v5(177.16,27.91) v5(177.16,27.52) v5(177.16,27.14) v5(177.4,4.4) v5(177.55,50.79) v5(177.54,28.29) v5(177.54,27.91) v5(177.54,27.52) v5(177.54,27.14) v5(177.76,4.4) v5(177.82,79.5) v5(177.99,57.69) v5(178.18,79.5) v5(178.2,55.83) v5(178.2,53.31) v5(178.2,50.79) v5(178.53,56.4) v5(178.64,57.69) v5(178.85,53.31) v5(178.85,50.79) v5(178.94,54.57) v5(179.03,4.4) v5(179.27,55.23) v5(179.38,4.4) v5(179.45,79.5) v5(179.6,31) v5(179.8,79.5) v5(180.43,14.31) v5(180.43,13.93) v5(180.43,13.55) v5(180.43,13.17) v5(180.43,12.79) v5(180.43,12.41) v5(180.43,12.03) v5(180.43,11.65) v5(180.43,11.27) v5(180.43,10.89) v5(180.43,10.5) v5(180.52,30.97) v5(180.65,4.4) v5(180.81,13.93) v5(180.81,13.55) v5(180.81,13.17) v5(180.81,12.79) v5(180.81,12.41) v5(180.81,12.03) v5(180.81,11.65) v5(180.81,11.27) v5(180.81,10.89) v5(180.81,10.5) v5(181.07,79.5) v5(181.01,4.4) v5(181.17,31.08) v5(181.19,13.55) v5(181.19,13.17) v5(181.19,12.79) v5(181.19,12.41) v5(181.19,12.03) v5(181.19,11.65) v5(181.19,11.27) v5(181.19,10.89) v5(181.19,10.5) v5(181.43,79.5) v5(182.21,30.99) v5(182.28,4.4) v5(182.35,29.7) v5(182.35,29.32) v5(182.7,79.5) v5(182.64,4.4) v5(183,31) v5(182.95,28.38) v5(182.95,28) v5(182.95,27.62) v5(182.95,27.23) v5(183.05,79.5) v5(183.33,28.38) v5(183.33,28) v5(183.33,27.62) v5(183.33,27.23) v5(183.43,30.51) v5(183.68,30.19) v5(183.71,28.38) v5(183.71,28) v5(183.71,27.62) v5(183.71,27.23) v5(183.91,4.4) v5(184.08,29.74) v5(184.26,4.4) v5(184.32,79.5) v5(184.68,79.5) v5(184.66,29.09) v5(184.88,27.78) v5(185.14,34.33) v5(185.26,27.78) v5(185.51,32.38) v5(185.53,4.4) v5(185.83,31.25) v5(185.89,4.4) v5(185.95,79.5) v5(186.07,34.35) v5(186.08,27.77) v5(186.27,33.01) v5(186.29,32.24) v5(186.3,79.5) v5(186.36,31.57) v5(186.46,27.77) v5(186.83,30.57) v5(186.99,33.03) v5(187.08,32.16) v5(187.15,31.28) v5(187.16,4.4) v5(187.57,79.5) v5(187.51,4.4) v5(187.93,79.5) v5(188.18,13.93) v5(188.18,13.55) v5(188.18,13.17) v5(188.18,12.79) v5(188.18,12.41) v5(188.18,12.03) v5(188.18,11.65) v5(188.18,11.27) v5(188.18,10.89) v5(188.56,14.31) v5(188.56,13.93) v5(188.56,13.55) v5(188.56,13.17) v5(188.56,12.79) v5(188.56,12.41) v5(188.56,12.03) v5(188.56,11.65) v5(188.56,11.27) v5(188.56,10.89) v5(188.78,4.4) v5(188.94,14.31) v5(188.94,13.93) v5(188.94,13.55) v5(188.94,13.17) v5(188.94,12.79) v5(188.94,12.41) v5(188.94,12.03) v5(188.94,11.65) v5(188.94,11.27) v5(188.94,10.89) v5(189.2,79.5) v5(189.14,4.4) v5(189.56,79.5) v5(190.41,4.4) v5(190.76,4.4) v5(190.83,79.5) v5(191.18,79.5) v5(191.73,71.72) v5(191.73,71.34) v5(191.73,5.74) v5(191.73,5.38) v5(191.9,70.99) v5(191.88,70.62) v5(191.89,70.27) v5(191.86,69.87) v5(191.89,69.52) v5(191.83,69.14) v5(192.03,4.4) v5(192.11,5.74) v5(192.11,5.38) v5(192.39,4.4) v5(192.45,69.12) v5(192.49,5.74) v5(192.49,5.38) v5(192.78,6.25) v5(192.82,69.12) v5(192.87,5.74) v5(192.87,5.38) v5(193.25,5.74) v5(193.25,5.38) v5(193.63,5.74) v5(193.63,5.38) v5(193.66,4.4) v5(194.05,6.25) v5(194.01,5.74) v5(194.01,5.38) v5(194.01,4.4) v5(194.39,5.74) v5(194.39,5.38) v5(194.77,5.74) v5(194.77,5.38) v5(195.15,5.74) v5(195.15,5.38) v5(195.23,24.92) v5(195.23,24.16) v5(195.24,23.49) v5(195.24,22.73) v5(195.28,4.4) v5(195.64,4.4) v5(195.99,24.92) v5(195.99,24.16) v5(196.01,23.49) v5(196.01,22.73) v5(196.64,24.92) v5(196.64,24.16) v5(196.65,23.55) v5(196.65,22.78) v5(196.91,4.4) v5(197.27,4.4) v5(197.33,79.5) v5(197.4,24.92) v5(197.41,23.55) v5(197.41,22.78) v5(197.68,79.5) v5(198.39,74.79) v5(198.39,74.44) v5(198.39,73.17) v5(198.39,72.81) v5(198.39,71.54) v5(198.39,71.18) v5(198.39,69.91) v5(198.39,69.56) v5(198.54,4.4) v5(198.89,4.4) v5(198.93,66.78) v5(199.03,66.44) v5(199.36,65.21) v5(199.46,64.87) v5(199.54,52.77) v5(199.54,52.42) v5(199.54,51.15) v5(199.54,50.79) v5(199.54,49.52) v5(199.54,49.16) v5(199.54,47.89) v5(199.54,47.54) v5(199.54,46.27) v5(199.54,45.91) v5(199.54,44.64) v5(199.54,44.29) v5(199.79,63.64) v5(199.73,30.76) v5(199.71,7.99) v5(199.71,7.56) v5(199.88,63.3) v5(200.1,7.99) v5(200.1,7.56) v5(200.11,33.42) v5(200.11,32.96) v5(200.11,32.5) v5(200.16,4.4) v5(200.22,62.07) v5(200.26,33.7) v5(200.31,61.73) v5(200.48,7.99) v5(200.48,7.56) v5(200.52,4.4) v5(200.76,60.57) v5(200.71,53.31) v5(200.73,43.8) v5(200.89,60.11) v5(200.86,7.99) v5(200.86,7.56) v5(201.05,53.43) v5(201.08,43.8) v5(201.24,7.99) v5(201.24,7.56) v5(201.66,9.09) v5(201.66,8.71) v5(201.66,8.33) v5(201.66,7.95) v5(201.66,7.57) v5(201.79,4.4) v5(201.93,55.8) v5(202.02,55.46) v5(202.14,4.4) v5(202.35,43.8) v5(202.71,43.8) v5(203.41,4.4) v5(203.77,4.4) v5(203.98,43.8) v5(204.34,43.8) v5(205.04,4.4) v5(205.39,4.4) v5(205.71,41.48) v5(205.8,41.14) v5(206.11,40.26) v5(206.2,39.91) v5(206.53,38.68) v5(206.62,38.34) v5(206.66,4.4) v5(206.94,37.11) v5(207.04,36.77) v5(207.02,4.4) v5(207.36,35.54) v5(207.45,35.2) v5(207.78,33.97) v5(207.87,33.63) v5(208.2,32.4) v5(208.29,32.06) v5(208.29,4.4) v5(208.62,30.83) v5(208.64,4.4) v5(208.71,30.49) v5(209.04,29.26) v5(209.13,28.92) v5(209.46,27.69) v5(209.55,27.35) v5(209.87,26.12) v5(209.97,25.77) v5(209.91,4.4) v5(210.29,24.55) v5(210.27,4.4) v5(210.38,24.2) v5(210.75,22.55) v5(210.75,22.19) v5(210.75,20.92) v5(210.75,20.57) v5(210.75,19.3) v5(210.75,18.94) v5(210.75,17.67) v5(210.75,17.32) v5(210.75,16.05) v5(210.75,15.69) v5(210.75,14.42) v5(210.75,14.07) v5(210.75,12.8) v5(210.75,12.44) v5(210.75,11.17) v5(210.75,10.82) v5(210.75,9.55) v5(210.75,9.19) v6(0.43,28.79) v6(0.43,27.32) v6(0.43,25.84) v6(0.43,24.37) v6(0.43,22.9) v6(0.43,21.55) v6(0.43,19.95) v6(0.43,18.48) v6(0.43,17.01) v6(0.43,15.4) v6(0.53,59.59) v6(0.73,53.3) v6(0.7,29.99) v6(1.03,72.65) v6(1.03,71.17) v6(1.03,34.28) v6(1.03,32.8) v6(1.03,31.33) v6(1.03,14.31) v6(1.03,12.81) v6(1.03,1.05) v6(1.14,77.07) v6(1.14,75.59) v6(1.14,74.12) v6(1.14,11.36) v6(1.14,9.89) v6(1.14,8.41) v6(1.14,6.94) v6(1.14,5.47) v6(1.14,3.99) v6(1.46,35.32) v6(1.54,60.92) v6(1.54,59.54) v6(1.89,0.43) v6(1.93,51.69) v6(2,77.57) v6(2.18,57.93) v6(2.18,56.46) v6(2.18,54.99) v6(2.94,35.32) v6(3.26,2.12) v6(3.36,0.43) v6(3.48,77.57) v6(4.5,51.68) v6(4.73,2.12) v6(4.83,60.92) v6(4.83,0.55) v6(4.95,77.46) v6(4.99,75.72) v6(5.33,74.3) v6(5.34,71.09) v6(5.88,35.32) v6(5.98,51.68) v6(6.11,60.42) v6(6.2,3.23) v6(6.42,77.46) v6(6.57,71.58) v6(7.04,75.5) v6(7.04,56.5) v6(7.36,35.32) v6(7.45,51.68) v6(7.68,3.23) v6(8,77.15) v6(8,73.85) v6(8,58.15) v6(8,54.85) v6(8.4,68.83) v6(8.48,63.13) v6(8.83,35.32) v6(8.92,51.68) v6(9.74,0.54) v6(9.87,70.13) v6(9.9,77.15) v6(9.9,73.85) v6(9.9,58.15) v6(9.9,54.85) v6(10.05,1.5) v6(10.4,51.68) v6(10.3,35.32) v6(10.32,3.27) v6(10.57,62.64) v6(10.73,0.54) v6(11.24,50.65) v6(11.31,36.24) v6(11.52,1.5) v6(11.8,3.27) v6(12.2,0.54) v6(12.66,77.56) v6(13.67,0.54) v6(13.79,77.57) v6(13.91,41.42) v6(14.07,42.93) v6(14.4,1.53) v6(15.15,0.43) v6(15.26,77.57) v6(16.11,1.96) v6(16.31,0.83) v6(16.74,77.57) v6(17.2,1.99) v6(17.7,73.3) v6(17.7,72.06) v6(17.94,5) v6(18.19,2.44) v6(18.21,77.57) v6(18.95,73.3) v6(18.95,72.06) v6(18.95,6.74) v6(18.95,3.26) v6(19.68,77.57) v6(20.37,34.22) v6(20.37,32.96) v6(20.37,31.7) v6(20.97,77.75) v6(20.95,44.57) v6(20.95,42) v6(20.95,39.44) v6(20.95,6.74) v6(20.95,3.26) v6(21.7,78.49) v6(21.74,2.44) v6(21.84,32.96) v6(21.84,31.7) v6(21.84,30.43) v6(21.99,69.28) v6(21.96,5) v6(22.44,79.23) v6(22.8,78.03) v6(22.99,2.43) v6(23.06,70.47) v6(23.18,79.96) v6(23.51,44.57) v6(23.51,42) v6(23.51,39.44) v6(23.77,78.77) v6(23.95,80.74) v6(24.47,2.43) v6(24.55,73.69) v6(25.53,81.26) v6(25.79,73.88) v6(25.94,2.43) v6(26.07,80.74) v6(26.08,42) v6(26.08,39.44) v6(26.72,3.13) v6(26.87,74.3) v6(27,81.26) v6(27.64,80.74) v6(27.79,3.93) v6(28.48,81.26) v6(29.26,3.93) v6(29.49,77.52) v6(29.95,81.26) v6(30.08,80.72) v6(30.39,37.82) v6(30.39,35.68) v6(30.38,3.05) v6(31.43,81.26) v6(31.53,37.82) v6(31.53,35.68) v6(31.63,25.78) v6(31.97,58.89) v6(32.09,58.26) v6(32.14,4.16) v6(32.21,80.74) v6(32.52,58.82) v6(32.71,2.43) v6(32.86,27.92) v6(32.86,23.64) v6(32.91,81.26) v6(33.61,4.16) v6(34.15,80.76) v6(34.18,2.43) v6(34.38,81.26) v6(35.33,27.92) v6(35.33,23.64) v6(35.66,2.43) v6(35.85,81.26) v6(36.5,80.75) v6(36.56,25.78) v6(36.82,78.74) v6(37.33,81.26) v6(38.2,80.72) v6(38.8,81.26) v6(39.54,64.23) v6(39.54,63.09) v6(40.08,2.43) v6(40.11,63.66) v6(40.27,81.26) v6(40.68,64.23) v6(40.68,63.09) v6(40.73,80.74) v6(41.55,2.43) v6(41.71,81.27) v6(42.4,80.72) v6(43.02,2.43) v6(43.22,81.37) v6(43.71,25.68) v6(43.87,80.72) v6(44.21,2.43) v6(44.69,81.37) v6(44.77,14.71) v6(44.77,10.87) v6(45.23,25.68) v6(46.17,81.37) v6(46.43,3.91) v6(46.73,25.68) v6(46.88,80.48) v6(47.71,14.71) v6(47.71,10.87) v6(47.9,3.93) v6(48.25,80.07) v6(49.32,3.47) v6(49.72,80.11) v6(49.79,2.43) v6(50.38,81.36) v6(51.27,2.43) v6(51.85,81.37) v6(52.64,2.43) v6(53.32,81.37) v6(53.56,11.4) v6(54.21,2.54) v6(54.79,81.37) v6(54.79,13.54) v6(54.79,9.26) v6(55.69,2.54) v6(56.27,81.37) v6(57.16,2.54) v6(57.26,13.54) v6(57.26,9.26) v6(57.67,79.99) v6(57.74,81.37) v6(58.49,11.4) v6(58.63,2.54) v6(59.21,81.37) v6(59.44,80.01) v6(60.11,2.54) v6(60.69,81.37) v6(61.58,2.54) v6(62.16,81.37) v6(63.15,2.54) v6(63.63,81.37) v6(64.52,2.43) v6(65.11,81.37) v6(66,2.43) v6(66.41,80.01) v6(66.58,81.37) v6(66.69,50.74) v6(66.73,14.35) v6(67.17,52.26) v6(67.22,51.7) v6(67.25,51.12) v6(67.47,2.43) v6(67.79,52.26) v6(68.05,81.37) v6(68.03,55.08) v6(68.16,79.99) v6(68.76,57.43) v6(68.94,2.43) v6(69.53,81.37) v6(70.42,2.43) v6(71,81.37) v6(71.29,70.11) v6(71.87,60.29) v6(71.89,2.43) v6(72.22,81.12) v6(72.45,60.29) v6(72.59,56.69) v6(72.97,19.51) v6(73.04,80.07) v6(73.16,57.24) v6(73.16,56.67) v6(73.27,18.61) v6(73.3,17.4) v6(73.36,2.43) v6(73.58,19.48) v6(73.85,18.61) v6(73.93,17.4) v6(74.52,80.07) v6(74.83,62.77) v6(74.83,62) v6(74.83,60.99) v6(74.84,2.43) v6(75.81,80.57) v6(76.31,2.43) v6(76.57,81.37) v6(76.61,63.02) v6(76.61,62) v6(76.61,61.3) v6(76.84,43.51) v6(77.78,2.43) v6(78.04,81.37) v6(78.26,44.92) v6(78.69,45.37) v6(79.16,45.83) v6(79.26,2.43) v6(79.51,81.37) v6(79.65,46.27) v6(79.98,47.22) v6(80.73,2.43) v6(80.99,81.37) v6(80.96,70.25) v6(81.74,25.91) v6(82.2,2.43) v6(82.46,81.37) v6(82.56,27.64) v6(82.7,23.83) v6(83.68,2.43) v6(83.93,81.37) v6(85.15,2.43) v6(85.44,21.42) v6(85.59,27.65) v6(85.83,24.08) v6(86.03,21.41) v6(86.5,25.62) v6(86.64,21.47) v6(86.62,2.43) v6(88.1,2.43) v6(88.67,81.25) v6(89.57,2.43) v6(90.32,81.25) v6(91.04,2.43) v6(91.91,81.25) v6(92.52,2.43) v6(93.5,81.25) v6(93.69,61.51) v6(93.99,2.43) v6(95.15,81.25) v6(95.46,2.43) v6(96.4,72.93) v6(96.94,2.43) v6(97.19,81.37) v6(97.24,44.91) v6(97.25,43.7) v6(97.82,45.58) v6(98.47,44.94) v6(98.41,2.43) v6(98.66,81.37) v6(98.74,44.05) v6(99.88,42.87) v6(99.88,2.43) v6(100.14,81.37) v6(101.35,2.54) v6(101.66,81.37) v6(102.83,2.54) v6(103.08,81.37) v6(104.3,2.54) v6(104.56,81.37) v6(104.94,78.69) v6(105.66,78.72) v6(105.77,2.54) v6(106.03,81.37) v6(106.31,78.71) v6(107.5,81.37) v6(108.72,2.54) v6(108.98,81.37) v6(110.19,2.54) v6(110.45,81.37) v6(110.52,78.83) v6(111.14,80.7) v6(111.23,78.85) v6(111.67,2.43) v6(111.86,78.83) v6(111.92,81.37) v6(112.43,78.5) v6(112.61,80.7) v6(112.9,78.86) v6(113.14,2.43) v6(113.4,81.37) v6(114.61,2.43) v6(114.79,47.56) v6(114.87,81.37) v6(114.92,45.56) v6(116.16,2.43) v6(116.34,81.37) v6(117.56,2.43) v6(119.03,2.43) v6(119.27,29.14) v6(119.23,27.45) v6(119.38,26.11) v6(120.26,81.36) v6(120.51,27.45) v6(120.51,2.43) v6(120.91,29.23) v6(121.5,74.89) v6(121.57,25.72) v6(121.9,81.37) v6(121.98,2.43) v6(123.37,81.37) v6(123.35,65.1) v6(123.35,59.5) v6(123.45,2.43) v6(124.74,61.69) v6(124.74,57.31) v6(124.85,81.37) v6(124.93,2.43) v6(125.26,77.91) v6(125.26,75.94) v6(125.28,74.73) v6(125.25,73.72) v6(125.26,69.34) v6(125.27,66.1) v6(125.33,78.94) v6(125.3,71.43) v6(125.3,70.36) v6(125.31,68.18) v6(125.31,67.11) v6(125.49,30) v6(125.91,78.94) v6(126.3,73.71) v6(126.32,81.37) v6(126.31,77.91) v6(126.31,75.93) v6(126.33,74.72) v6(126.35,71.42) v6(126.35,70.35) v6(126.32,69.34) v6(126.36,68.18) v6(126.36,67.11) v6(126.32,66.1) v6(126.4,2.43) v6(126.5,78.94) v6(126.4,27.97) v6(126.72,32.14) v6(127.08,78.94) v6(127.12,68.17) v6(127.17,67.09) v6(127.13,66.08) v6(127.29,77.91) v6(127.29,75.93) v6(127.28,73.71) v6(127.26,61.69) v6(127.26,57.31) v6(127.32,74.72) v6(127.34,71.42) v6(127.34,70.35) v6(127.3,69.34) v6(127.66,78.94) v6(127.79,81.37) v6(127.87,2.43) v6(128.25,78.94) v6(128.57,68.14) v6(128.57,67.08) v6(128.53,66.06) v6(128.6,78) v6(128.61,75.93) v6(128.62,74.73) v6(128.64,71.43) v6(128.65,59.5) v6(128.83,78.94) v6(129.18,32.14) v6(129.18,27.86) v6(129.27,81.37) v6(129.35,2.43) v6(129.42,78.94) v6(129.65,77.99) v6(129.66,75.92) v6(129.68,74.73) v6(129.6,73.65) v6(129.69,71.43) v6(130,78.94) v6(130.41,30) v6(130.44,23.69) v6(130.58,78.94) v6(130.52,24.28) v6(130.64,77.99) v6(130.65,75.92) v6(130.66,74.72) v6(130.68,71.42) v6(130.7,23.18) v6(130.74,81.37) v6(130.82,2.43) v6(130.96,23.9) v6(132.21,81.37) v6(132.29,2.43) v6(133.68,81.37) v6(133.77,2.43) v6(135.16,81.37) v6(135.24,2.43) v6(135.66,79.34) v6(135.92,79.97) v6(135.92,78.7) v6(136.49,80.1) v6(136.49,78.51) v6(136.63,81.26) v6(136.71,2.43) v6(137.06,80.1) v6(137.06,78.51) v6(137.63,80.1) v6(137.63,78.51) v6(138.1,81.26) v6(138.18,2.43) v6(138.2,80.1) v6(138.2,78.51) v6(138.77,79.97) v6(138.77,78.7) v6(139.03,79.34) v6(139.58,81.26) v6(139.66,2.43) v6(141.05,81.26) v6(141.13,2.43) v6(142.52,81.26) v6(142.6,2.43) v6(143.82,33.86) v6(144,81.26) v6(144.08,2.43) v6(145.47,81.26) v6(145.55,2.43) v6(146.55,67.84) v6(146.94,81.37) v6(147.02,2.43) v6(147.2,67.84) v6(148.37,2.43) v6(148.42,81.37) v6(149.89,81.37) v6(150.17,2.56) v6(151.36,81.37) v6(151.44,2.56) v6(152.84,81.37) v6(152.92,2.56) v6(154.16,24.77) v6(154.16,22.68) v6(154.16,20.58) v6(154.31,81.37) v6(154.39,2.56) v6(155.69,80.09) v6(155.78,81.37) v6(155.86,2.56) v6(156.25,24.77) v6(156.25,22.68) v6(156.25,20.58) v6(157.13,2.56) v6(157.26,81.37) v6(157.52,80.08) v6(158.35,24.77) v6(158.35,22.68) v6(158.35,20.58) v6(158.73,81.37) v6(159.09,2.43) v6(159.42,80.1) v6(160.2,81.37) v6(160.28,2.43) v6(160.9,80.1) v6(161.68,81.37) v6(161.77,67.82) v6(161.76,2.43) v6(162.42,67.82) v6(162.78,80.07) v6(163.23,2.43) v6(164.17,80.06) v6(164.7,2.43) v6(165.21,80.14) v6(165.85,81.37) v6(166.18,2.43) v6(166.39,5.36) v6(166.97,5.36) v6(167.33,81.37) v6(167.56,5.36) v6(167.65,2.43) v6(168.17,79.34) v6(168.3,80.04) v6(168.49,78.7) v6(168.8,81.37) v6(168.94,80.1) v6(169.06,78.51) v6(169.12,2.43) v6(169.51,80.1) v6(169.63,78.51) v6(170.08,80.1) v6(170.27,81.37) v6(170.21,78.51) v6(170.6,2.43) v6(170.65,80.1) v6(170.78,78.51) v6(171.22,79.97) v6(171.24,5.77) v6(171.35,78.64) v6(171.54,79.34) v6(171.75,81.37) v6(171.82,5.77) v6(172.07,2.43) v6(172.16,80.11) v6(172.41,5.77) v6(172.99,5.77) v6(173.22,81.37) v6(173.58,5.77) v6(173.54,2.43) v6(173.79,80.14) v6(174.69,81.37) v6(175.01,2.43) v6(176.17,81.37) v6(176.49,2.43) v6(176.63,80.11) v6(177.64,81.37) v6(177.96,2.43) v6(178.31,80.14) v6(179.11,81.26) v6(179.43,2.43) v6(180.59,81.26) v6(180.91,2.43) v6(181.47,80.13) v6(182.06,81.26) v6(182.38,2.43) v6(183.31,80.09) v6(183.53,81.26) v6(183.9,44.88) v6(183.85,2.43) v6(184.58,80.08) v6(184.56,44.88) v6(185.01,81.26) v6(185.17,44.87) v6(185.33,2.43) v6(185.75,44.87) v6(185.8,80.1) v6(186.48,81.26) v6(186.78,35.94) v6(186.8,2.43) v6(187,44.87) v6(187.01,34.66) v6(187.19,80.14) v6(187.4,35.91) v6(187.37,35.21) v6(187.73,44.89) v6(187.72,34.65) v6(187.95,81.26) v6(187.99,35.23) v6(188.03,35.92) v6(188.27,2.43) v6(188.38,44.87) v6(188.95,80.1) v6(189.01,32.91) v6(189.43,81.37) v6(189.75,2.43) v6(190.22,35.09) v6(190.22,30.82) v6(190.63,78.92) v6(190.9,81.37) v6(191.22,2.43) v6(191.91,77.23) v6(191.91,74.79) v6(192.37,81.37) v6(192.62,80.06) v6(192.68,35.09) v6(192.68,30.82) v6(192.69,2.43) v6(193.84,81.37) v6(193.91,32.95) v6(194.14,78.66) v6(194.14,73.36) v6(194.17,2.43) v6(195.32,81.37) v6(195.64,2.43) v6(196.38,77.23) v6(196.38,74.79) v6(196.41,80.13) v6(196.53,33.62) v6(196.79,81.37) v6(197.17,33.59) v6(197.11,2.54) v6(197.64,78.39) v6(197.75,33.87) v6(198.26,81.37) v6(198.23,80.08) v6(198.27,78.58) v6(198.21,75.24) v6(198.46,7.96) v6(198.59,2.54) v6(198.97,75.34) v6(199.03,78.45) v6(199.03,77.75) v6(199.03,77.05) v6(199.03,76.16) v6(199.03,7.96) v6(199.39,42.95) v6(199.39,42.37) v6(199.48,30.38) v6(199.67,81.3) v6(199.67,79.82) v6(199.67,78.35) v6(199.67,76.88) v6(199.67,75.4) v6(199.67,73.93) v6(199.67,72.46) v6(199.67,70.99) v6(199.67,69.51) v6(199.97,67.99) v6(199.98,42.95) v6(199.99,42.28) v6(199.99,41.65) v6(200.05,30.19) v6(200.06,2.54) v6(200.31,66.6) v6(200.34,52.5) v6(200.3,30.7) v6(200.69,65.18) v6(200.62,42.95) v6(200.63,42.28) v6(200.62,41.65) v6(200.97,44.57) v6(201.06,63.96) v6(201.21,48.94) v6(201.25,42.95) v6(201.26,42.28) v6(201.26,41.65) v6(201.31,52.02) v6(201.44,62.53) v6(201.53,2.54) v6(201.65,50.42) v6(201.75,61.29) v6(201.75,47.44) v6(201.89,42.95) v6(201.9,42.28) v6(201.89,41.65) v6(201.88,40.01) v6(202.15,59.88) v6(202.54,58.46) v6(202.53,42.91) v6(202.54,42.28) v6(202.52,41.64) v6(202.52,40.01) v6(202.73,51.32) v6(202.73,44.53) v6(202.92,57.04) v6(203.07,46.55) v6(203.01,2.54) v6(203.16,42.92) v6(203.17,42.23) v6(203.17,41.64) v6(203.16,40.01) v6(203.3,55.61) v6(203.22,41.05) v6(203.6,54.48) v6(203.8,42.92) v6(203.78,41.62) v6(203.78,40.98) v6(203.8,42.23) v6(203.82,40.38) v6(203.82,39.75) v6(204.01,52.92) v6(204.47,51.54) v6(204.43,42.92) v6(204.44,42.23) v6(204.42,41.62) v6(204.42,40.98) v6(204.46,40.38) v6(204.46,39.75) v6(204.48,2.54) v6(204.61,46.46) v6(205.93,46.08) v6(205.95,2.54) v6(206.31,44.38) v6(206.69,42.95) v6(207.07,41.53) v6(207.35,27.52) v6(207.35,26.89) v6(207.35,26.25) v6(207.35,25.62) v6(207.35,24.98) v6(207.35,24.35) v6(207.35,23.71) v6(207.45,40.11) v6(207.43,2.43) v6(207.83,38.68) v6(207.83,27.9) v6(208.03,27.24) v6(208.05,26.62) v6(208.05,25.84) v6(208.06,25.2) v6(208.08,24.51) v6(208.11,23.71) v6(208.22,37.26) v6(208.44,27.64) v6(208.6,35.84) v6(208.63,26.63) v6(208.69,25.92) v6(208.74,25.08) v6(208.77,24.44) v6(208.86,23.76) v6(208.9,2.43) v6(208.98,34.41) v6(209.36,32.99) v6(209.74,31.57) v6(210.12,30.15) v6(210.37,2.43) v6(210.51,28.71) v6(210.88,27.3) v6(211.03,3.53) v6(211.27,25.88) v6(211.52,19.01) v6(211.69,24.47) v6(211.88,16.07) v6(211.83,11.82) v6(211.84,2.43) v6(212.03,20.41) v6(212,11.19) v6(212.18,23.08) v6(212.1,15.25) v6(212.59,19.19) v6(212.54,7) v6(212.73,21.71) v6(213.22,11.22) v6(213.34,20.37) v6(213.37,15.61) v6(213.32,2.43) v6(213.74,9.09) v6(213.74,4.91) v6(214,19.05) v6(214.35,15.67) v6(214.79,2.43) v6(215.23,15.33) v8(1.63,16.25) v8(2,13.53) v8(2,2.91) v8(2.77,32.34) v8(2.71,31.62) v8(2.71,31.14) v8(2.71,30.72) v8(2.7,30.06) v8(2.8,29) v8(3.08,31.62) v8(3.08,31.14) v8(3.09,30.05) v8(3.18,32.86) v8(3.2,32.34) v8(3.11,30.72) v8(3.24,76.05) v8(3.43,15.12) v8(3.51,12.66) v8(3.51,12.28) v8(3.54,3.62) v8(3.53,3.24) v8(3.61,32.86) v8(3.78,56.03) v8(3.78,55.55) v8(3.78,55.13) v8(3.77,54.46) v8(3.9,57.28) v8(3.86,15.12) v8(3.9,58.85) v8(3.91,58.37) v8(3.91,57.95) v8(4.15,56.03) v8(4.14,55.55) v8(4.18,55.13) v8(4.16,54.46) v8(4.2,27.36) v8(4.17,12.66) v8(4.18,12.26) v8(4.17,5.01) v8(4.17,4.64) v8(4.2,3.61) v8(4.28,58.85) v8(4.27,58.37) v8(4.28,57.28) v8(4.2,3.22) v8(4.3,57.95) v8(4.34,20.62) v8(4.5,14.04) v8(4.6,12.66) v8(4.59,12.29) v8(4.63,27.36) v8(4.65,5.01) v8(4.65,4.65) v8(4.62,3.61) v8(4.62,3.25) v8(4.76,20.62) v8(4.81,22.9) v8(4.81,21.56) v8(4.92,25.52) v8(5.07,12.66) v8(5.08,12.29) v8(5.07,5.04) v8(5.07,4.65) v8(5.1,3.62) v8(5.1,3.24) v8(5.23,22.9) v8(5.23,21.56) v8(5.34,25.52) v8(5.56,31.13) v8(5.56,30.56) v8(5.56,29.99) v8(5.74,5.02) v8(5.74,4.64) v8(6.23,1.63) v8(6.43,14.9) v8(6.43,14.51) v8(6.45,12.86) v8(6.88,12.86) v8(6.93,5.5) v8(7.09,14.89) v8(7.1,14.5) v8(7.52,14.89) v8(7.51,14.53) v8(7.72,2.35) v8(7.73,1.97) v8(7.99,14.9) v8(8,14.52) v8(8.13,34.29) v8(8.21,2.34) v8(8.2,1.98) v8(8.56,34.29) v8(8.62,2.37) v8(8.63,1.98) v8(8.79,12.78) v8(9.17,33.68) v8(9.21,12.78) v8(9.3,2.35) v8(9.29,1.97) v8(9.34,34.27) v8(9.42,14.9) v8(9.77,34.27) v8(9.85,14.9) v8(9.91,14.14) v8(9.91,13.75) v8(10.21,2.55) v8(10.22,2.18) v8(10.57,14.13) v8(10.58,13.73) v8(10.7,2.55) v8(10.69,2.18) v8(11,14.13) v8(10.99,13.77) v8(11.11,2.58) v8(11.12,2.18) v8(11.47,14.13) v8(11.48,13.76) v8(11.79,2.56) v8(11.78,2.17) v8(12.06,12.59) v8(12.26,20.46) v8(12.37,6.72) v8(12.38,6.34) v8(12.45,34.51) v8(12.45,22.24) v8(12.49,12.59) v8(12.56,24.86) v8(12.69,20.46) v8(12.67,14.73) v8(12.63,11.22) v8(12.62,10.83) v8(12.71,16.19) v8(12.88,34.51) v8(12.88,22.24) v8(12.8,8.75) v8(12.81,8.37) v8(12.86,6.71) v8(12.85,6.35) v8(12.81,3.19) v8(12.8,2.81) v8(12.97,70.04) v8(12.97,69.48) v8(12.98,29.11) v8(12.95,27.53) v8(12.99,24.86) v8(13,71.18) v8(13,70.62) v8(13.09,14.73) v8(13.02,7.5) v8(13.13,9.51) v8(13.12,1.63) v8(13.29,11.21) v8(13.3,10.81) v8(13.29,8.74) v8(13.28,8.38) v8(13.27,6.74) v8(13.28,6.35) v8(13.39,74.04) v8(13.39,73.48) v8(13.39,72.92) v8(13.39,72.36) v8(13.37,27.53) v8(13.45,7.5) v8(13.47,3.18) v8(13.47,2.79) v8(13.56,9.51) v8(13.66,12.4) v8(13.72,11.21) v8(13.71,10.84) v8(13.7,8.77) v8(13.71,8.38) v8(13.9,3.18) v8(13.89,2.82) v8(13.94,6.72) v8(13.94,6.34) v8(14.09,12.4) v8(14.19,11.21) v8(14.2,10.84) v8(14.38,8.76) v8(14.37,8.37) v8(14.37,3.19) v8(14.37,2.81) v8(14.9,74.28) v8(14.83,55.88) v8(14.97,61.03) v8(14.97,60.47) v8(15,15.12) v8(15.08,19.25) v8(15.08,18.77) v8(15.08,18.35) v8(15.07,17.69) v8(15,16.68) v8(15.01,16.21) v8(15.01,15.78) v8(15.1,14.04) v8(15.32,46.29) v8(15.38,16.69) v8(15.37,16.2) v8(15.38,15.12) v8(15.41,52.09) v8(15.41,51.62) v8(15.41,51.19) v8(15.4,50.53) v8(15.45,19.25) v8(15.45,18.77) v8(15.48,18.35) v8(15.46,17.68) v8(15.4,15.79) v8(15.55,61) v8(15.55,60.44) v8(15.78,52.09) v8(15.78,51.61) v8(15.79,50.52) v8(15.75,10.31) v8(15.75,3.85) v8(15.81,51.2) v8(16.21,45.95) v8(16.34,33.82) v8(16.34,32.81) v8(16.47,58.2) v8(16.54,9.81) v8(16.66,59.13) v8(16.79,62.63) v8(17.04,9.62) v8(17.22,59.13) v8(17.35,62.63) v8(17.35,33.82) v8(17.35,32.81) v8(17.35,31.79) v8(17.49,9.62) v8(17.61,53.03) v8(17.61,52.01) v8(17.61,50.99) v8(17.91,57.37) v8(17.91,56.81) v8(18,9.62) v8(18.17,58.99) v8(18.17,58.43) v8(18.32,72.68) v8(18.37,33.82) v8(18.4,32.8) v8(18.37,31.79) v8(18.57,9.62) v8(18.62,53.03) v8(18.62,50.99) v8(19.08,60.04) v8(19.08,59.49) v8(19.08,9.62) v8(19.12,58.24) v8(19.12,57.68) v8(19.37,60.73) v8(19.39,33.82) v8(19.39,32.81) v8(19.39,31.79) v8(19.64,53.03) v8(19.64,52.01) v8(19.64,50.99) v8(19.65,9.81) v8(19.78,29.21) v8(20.15,60.63) v8(20.15,60.07) v8(20.4,57.75) v8(20.4,57.2) v8(20.69,59.05) v8(20.64,48.94) v8(20.71,58.47) v8(20.7,57.52) v8(20.87,41.14) v8(20.83,10.57) v8(20.84,10.2) v8(21.31,10.57) v8(21.31,10.2) v8(21.73,10.6) v8(21.74,10.2) v8(22.16,53.78) v8(22.4,65.63) v8(22.3,65.01) v8(22.38,27.09) v8(22.4,10.2) v8(22.46,64.14) v8(22.4,10.58) v8(22.51,63.31) v8(22.57,62.81) v8(22.58,44.58) v8(22.59,42.85) v8(22.58,41.14) v8(22.59,39.44) v8(22.65,64.85) v8(22.73,65.31) v8(22.73,53.78) v8(22.83,34.89) v8(22.98,64.14) v8(22.95,27.08) v8(23.02,63.31) v8(23.09,62.81) v8(23.18,65.17) v8(23.3,64.83) v8(23.3,53.78) v8(23.59,52.26) v8(23.67,64.15) v8(23.61,27.06) v8(23.75,64.87) v8(23.71,63.32) v8(23.78,62.82) v8(23.83,62.38) v8(23.89,61.49) v8(23.85,55.01) v8(23.88,53.78) v8(24.19,64.15) v8(24.19,27.06) v8(24.23,63.32) v8(24.3,62.82) v8(24.24,56.68) v8(24.24,56.11) v8(24.33,77.53) v8(24.35,62.38) v8(24.5,76.68) v8(24.4,61.49) v8(24.45,53.78) v8(24.41,8.14) v8(24.54,79.8) v8(24.54,79.41) v8(24.96,26.38) v8(25.04,62.39) v8(25.1,61.5) v8(25.07,58.28) v8(25.03,53.78) v8(25.14,64.12) v8(25.14,63.6) v8(25.2,79.79) v8(25.21,79.39) v8(25.22,9.08) v8(25.23,8.7) v8(25.56,62.39) v8(25.6,53.81) v8(25.63,79.79) v8(25.63,79.42) v8(25.61,61.5) v8(25.71,9.07) v8(25.7,8.71) v8(25.96,58.28) v8(26.01,44.57) v8(26.1,79.79) v8(26.11,79.42) v8(26.15,19.6) v8(26.12,9.1) v8(26.13,8.71) v8(26.26,60.59) v8(26.36,74.26) v8(26.37,6.92) v8(26.69,61.37) v8(26.8,9.09) v8(26.79,8.7) v8(26.82,60.59) v8(26.84,58.28) v8(26.81,19.6) v8(26.88,5.15) v8(26.96,37.14) v8(27.01,79.8) v8(27,79.41) v8(27.2,61.37) v8(27.38,60.61) v8(27.56,53.82) v8(27.67,79.79) v8(27.67,79.39) v8(27.68,56.13) v8(27.66,55.24) v8(27.76,58.29) v8(27.9,10.65) v8(27.92,61.38) v8(27.92,56.87) v8(27.97,9.13) v8(27.97,8.76) v8(28.09,79.79) v8(28.09,79.42) v8(28.14,54.49) v8(28.25,35.06) v8(28.31,29.92) v8(28.44,61.38) v8(28.47,58.52) v8(28.45,9.12) v8(28.45,8.76) v8(28.57,79.79) v8(28.57,79.42) v8(28.87,9.16) v8(28.87,8.76) v8(29.07,58.05) v8(29.04,29.88) v8(29.18,34.42) v8(29.42,59.71) v8(29.56,27.85) v8(29.54,9.14) v8(29.54,8.75) v8(29.66,60.51) v8(29.71,28.39) v8(29.75,6.61) v8(29.94,59.71) v8(29.9,34.59) v8(29.93,29.88) v8(30.08,28.79) v8(30.13,79.75) v8(30.12,79.36) v8(30.17,60.51) v8(30.22,56.54) v8(30.41,74.25) v8(30.65,57.13) v8(30.79,79.74) v8(30.8,79.34) v8(30.78,60.42) v8(30.78,59.9) v8(30.71,56.56) v8(30.81,58.33) v8(30.81,57.81) v8(30.9,8.18) v8(30.97,74.25) v8(30.95,2.99) v8(31.07,41.11) v8(31.22,79.74) v8(31.21,79.37) v8(31.32,75.44) v8(31.31,19.36) v8(31.52,74.25) v8(31.56,34.01) v8(31.58,26.82) v8(31.52,24.67) v8(31.69,79.74) v8(31.7,79.37) v8(31.73,34.74) v8(32.08,74.25) v8(32.08,71.84) v8(32.09,71.24) v8(32.04,8.33) v8(32.26,3.25) v8(32.77,61.61) v8(32.93,3.24) v8(33.05,23.14) v8(33.11,28.48) v8(33.35,3.24) v8(33.46,79.77) v8(33.45,79.39) v8(33.41,54.42) v8(33.58,20.8) v8(33.63,34.77) v8(33.85,35.46) v8(33.83,3.24) v8(34.12,79.76) v8(34.12,79.37) v8(34.28,75.32) v8(34.48,77.46) v8(34.55,79.76) v8(34.54,79.4) v8(34.75,7.32) v8(34.93,3.8) v8(35.02,79.77) v8(35.02,79.39) v8(35.08,28.48) v8(35.17,11.14) v8(35.27,23.14) v8(35.46,77.15) v8(35.46,76.6) v8(35.45,13.44) v8(35.45,8.31) v8(35.6,3.79) v8(35.96,20.74) v8(36.02,3.79) v8(36.39,65.42) v8(36.35,57.71) v8(36.35,57.03) v8(36.36,56.32) v8(36.36,55.63) v8(36.36,54.89) v8(36.38,43.05) v8(36.49,3.79) v8(36.78,77.15) v8(36.78,76.6) v8(36.79,26.82) v8(36.73,24.67) v8(36.81,9.28) v8(36.85,5.49) v8(37.11,68.02) v8(37.16,4.1) v8(37.17,3.73) v8(37.29,71.21) v8(37.29,70.65) v8(37.29,70.09) v8(37.23,65.43) v8(37.45,2.99) v8(37.65,4.1) v8(37.64,3.73) v8(37.72,59.8) v8(37.84,22.17) v8(38.05,79.44) v8(38.05,79.06) v8(38.06,4.13) v8(38.07,3.73) v8(38.42,20.2) v8(38.55,59.8) v8(38.72,79.43) v8(38.72,79.04) v8(38.78,22.14) v8(38.74,4.11) v8(38.73,3.72) v8(38.75,2.99) v8(39.04,71.21) v8(39.04,70.65) v8(39.04,70.09) v8(39.14,79.43) v8(39.14,79.07) v8(39.19,45.98) v8(39.29,50.47) v8(39.3,4.18) v8(39.37,25.99) v8(39.3,3.8) v8(39.62,79.44) v8(39.62,79.06) v8(39.63,71.46) v8(39.63,70.91) v8(39.63,70.35) v8(39.61,18.41) v8(39.78,4.17) v8(39.77,3.81) v8(40.06,32.94) v8(40.16,68.76) v8(40.2,4.2) v8(40.2,59.44) v8(40.2,3.81) v8(40.53,68.75) v8(40.8,79.31) v8(40.79,78.93) v8(40.87,4.18) v8(40.86,3.8) v8(41.09,59.42) v8(41.09,44.68) v8(41.01,18.41) v8(41.26,11.58) v8(41.38,71.46) v8(41.38,70.91) v8(41.38,70.35) v8(41.37,3.44) v8(41.46,79.31) v8(41.47,78.91) v8(41.63,53.61) v8(41.67,49.8) v8(41.63,4.25) v8(41.64,3.88) v8(41.89,79.31) v8(41.88,78.94) v8(41.91,59.42) v8(42.03,3.43) v8(42.12,4.25) v8(42.11,3.88) v8(42.36,79.31) v8(42.36,78.94) v8(42.46,3.43) v8(42.57,69.52) v8(42.57,68.64) v8(42.53,4.28) v8(42.54,3.88) v8(42.99,48.86) v8(42.93,3.43) v8(43.21,4.26) v8(43.2,3.88) v8(43.36,49.34) v8(43.4,48.86) v8(43.38,16.58) v8(43.45,60.57) v8(43.71,27.21) v8(43.71,22.66) v8(43.75,5.49) v8(43.86,49.69) v8(43.86,49.31) v8(43.88,48.86) v8(43.98,45.32) v8(43.91,34.37) v8(44.1,18.23) v8(44.14,17.05) v8(44.39,35.55) v8(44.32,32.47) v8(45.23,24.18) v8(45.25,2.99) v8(45.43,57.56) v8(45.47,34.17) v8(45.45,32.22) v8(45.88,17.57) v8(46.14,66.51) v8(46.14,66.13) v8(46.14,65.72) v8(46.14,65.32) v8(46.14,64.76) v8(46.14,64.38) v8(46.14,63.97) v8(46.14,63.57) v8(46.14,63.13) v8(46.13,54.13) v8(46.13,32.34) v8(46.23,43.4) v8(46.63,17.58) v8(46.74,43.4) v8(46.83,40.43) v8(47.25,43.4) v8(47.4,17.56) v8(47.49,44.5) v8(47.41,40.43) v8(47.66,32.67) v8(48.09,17.49) v8(48.14,16.32) v8(48.26,27.21) v8(48.26,24.18) v8(48.26,22.66) v8(48.46,34.41) v8(48.5,49.06) v8(48.53,48.66) v8(48.53,48.33) v8(48.59,40.63) v8(48.79,49) v8(48.78,42.3) v8(48.78,41.2) v8(48.79,16.3) v8(48.88,48.66) v8(48.88,48.33) v8(49.03,43.4) v8(49.17,34.24) v8(49.17,17.84) v8(49.2,7.63) v8(49.53,43.4) v8(49.73,17.84) v8(50.04,43.4) v8(50.38,77.73) v8(50.39,77.35) v8(50.31,17.76) v8(50.53,76.39) v8(50.52,76.01) v8(50.87,77.72) v8(50.86,77.36) v8(51.07,79.3) v8(51.08,78.92) v8(51.19,76.38) v8(51.19,75.99) v8(51.28,77.75) v8(51.29,77.36) v8(51.56,79.29) v8(51.55,78.93) v8(51.61,76.38) v8(51.61,76.02) v8(51.81,7.64) v8(51.97,79.32) v8(51.98,78.93) v8(51.96,77.73) v8(51.95,77.35) v8(52.09,76.39) v8(52.09,76.02) v8(52.52,16.57) v8(52.64,79.3) v8(52.64,78.92) v8(52.83,49.74) v8(53.15,48.2) v8(53.16,19.85) v8(53.24,5.05) v8(53.66,79.52) v8(53.66,79.14) v8(53.67,32.3) v8(53.66,31.68) v8(53.9,48.2) v8(53.98,42.08) v8(53.93,24.81) v8(53.9,5.04) v8(54.08,33.96) v8(54.14,79.51) v8(54.14,79.15) v8(54.33,5.04) v8(54.46,25.41) v8(54.44,19.47) v8(54.56,79.54) v8(54.56,79.15) v8(54.75,22.7) v8(54.86,49.15) v8(54.86,43.41) v8(54.8,5.04) v8(55.04,26.25) v8(55.02,20.06) v8(55.23,79.52) v8(55.22,79.14) v8(55.25,4.87) v8(55.45,49.15) v8(55.91,4.86) v8(56,47.17) v8(56.34,4.86) v8(56.45,41.03) v8(56.6,23.44) v8(56.83,7.08) v8(56.81,4.87) v8(57.07,43.13) v8(57.84,49.15) v8(58.11,79.19) v8(58.12,78.81) v8(58.14,7.1) v8(58.21,18.04) v8(58.45,47.87) v8(58.6,79.18) v8(58.59,78.82) v8(58.88,7.12) v8(58.97,21.84) v8(59.01,79.21) v8(59.02,78.82) v8(59.03,47.88) v8(59.03,4.87) v8(59.69,79.19) v8(59.68,78.81) v8(59.66,46.45) v8(59.66,45.86) v8(59.69,41.02) v8(59.7,4.86) v8(59.86,22.05) v8(59.85,7.17) v8(60.05,26.08) v8(60.13,74.17) v8(60.11,73.5) v8(60.14,73.08) v8(60.14,72.6) v8(60.12,4.86) v8(60.22,70.95) v8(60.21,70.28) v8(60.24,69.86) v8(60.23,69.38) v8(60.24,25.17) v8(60.49,12.31) v8(60.49,11.83) v8(60.5,10.74) v8(60.51,74.17) v8(60.5,73.5) v8(60.5,73.08) v8(60.51,72.6) v8(60.52,11.41) v8(60.56,7.72) v8(60.6,4.87) v8(60.61,70.95) v8(60.6,70.28) v8(60.6,69.86) v8(60.61,69.39) v8(60.94,77.22) v8(61.31,16.8) v8(61.5,79.57) v8(61.49,58.61) v8(61.46,26.18) v8(61.5,79.2) v8(61.74,32.04) v8(61.98,79.57) v8(61.98,79.2) v8(62.4,79.6) v8(62.33,44.6) v8(62.33,44.04) v8(62.38,30.21) v8(62.31,18.4) v8(62.4,79.2) v8(62.46,29) v8(62.51,58.61) v8(62.75,65.55) v8(62.76,53.04) v8(62.71,12.39) v8(62.96,26.18) v8(63.07,79.58) v8(63.07,79.19) v8(63.02,4.92) v8(63.39,58.64) v8(63.37,56.75) v8(63.31,43.47) v8(63.35,11.81) v8(63.69,4.92) v8(63.85,23.25) v8(64,43.47) v8(64.02,25.1) v8(64.1,11.02) v8(64.11,4.92) v8(64.25,50.8) v8(64.25,50.24) v8(64.25,49.68) v8(64.25,49.13) v8(64.25,48.57) v8(64.25,48.01) v8(64.25,47.45) v8(64.27,20.32) v8(64.34,31.17) v8(64.59,79.21) v8(64.58,4.92) v8(64.6,78.84) v8(64.83,51.98) v8(65.08,79.21) v8(65.07,78.84) v8(65.28,44.52) v8(65.49,79.24) v8(65.5,78.84) v8(66.17,79.22) v8(66.16,78.84) v8(66.11,59.81) v8(66.15,38.6) v8(66.14,38.21) v8(66.25,40.55) v8(66.24,40.17) v8(66.43,41.09) v8(66.81,38.59) v8(66.81,38.19) v8(66.91,40.54) v8(66.92,40.15) v8(66.97,36.21) v8(66.98,35.74) v8(66.98,35.32) v8(66.97,34.65) v8(67.01,39.49) v8(67.09,37.32) v8(67.12,59.81) v8(67.17,34) v8(67.18,33.53) v8(67.18,33.11) v8(67.17,32.44) v8(67.19,4.88) v8(67.24,38.59) v8(67.23,38.23) v8(67.34,40.54) v8(67.33,40.18) v8(67.34,36.22) v8(67.34,35.74) v8(67.37,35.32) v8(67.35,34.65) v8(67.53,41.09) v8(67.55,34.01) v8(67.54,33.53) v8(67.57,33.11) v8(67.55,32.44) v8(67.71,38.59) v8(67.71,38.22) v8(67.81,40.55) v8(67.82,40.18) v8(67.85,4.87) v8(67.98,18.67) v8(68.03,53.53) v8(68.11,39.49) v8(68.19,37.32) v8(68.1,32.65) v8(68.11,32.28) v8(68.28,4.87) v8(68.58,32.64) v8(68.58,32.28) v8(68.69,59.48) v8(68.69,59.02) v8(68.75,4.88) v8(68.83,79.02) v8(68.84,78.65) v8(68.81,21.1) v8(69,32.68) v8(69,32.28) v8(69.18,58.05) v8(69.11,14.9) v8(69.12,14.43) v8(69.12,14) v8(69.11,13.34) v8(69.32,79.02) v8(69.31,78.65) v8(69.4,21.22) v8(69.49,14.91) v8(69.48,14.43) v8(69.49,13.34) v8(69.51,40.41) v8(69.52,39.93) v8(69.52,39.51) v8(69.51,38.84) v8(69.51,14.01) v8(69.53,12.7) v8(69.51,12.03) v8(69.54,11.61) v8(69.54,11.13) v8(69.63,66.43) v8(69.62,66.04) v8(69.66,41.29) v8(69.67,32.66) v8(69.67,32.27) v8(69.73,79.05) v8(69.74,78.65) v8(69.71,64.83) v8(69.7,64.45) v8(69.85,75.87) v8(69.85,63.62) v8(69.84,63.24) v8(69.88,40.41) v8(69.88,39.93) v8(69.89,38.84) v8(69.86,18.76) v8(69.8,9.65) v8(69.81,9.18) v8(69.81,8.75) v8(69.91,39.51) v8(69.91,12.7) v8(69.91,12.03) v8(69.91,11.61) v8(69.91,11.14) v8(70.17,32.48) v8(70.18,9.65) v8(70.17,9.17) v8(70.29,66.42) v8(70.29,66.02) v8(70.2,8.75) v8(70.4,78.64) v8(70.37,64.82) v8(70.38,64.43) v8(70.4,79.03) v8(70.41,75.87) v8(70.51,63.61) v8(70.51,63.22) v8(70.71,66.42) v8(70.71,66.06) v8(70.8,64.82) v8(70.79,64.46) v8(70.77,41.29) v8(70.85,4.9) v8(70.93,63.61) v8(70.93,63.25) v8(71,8.1) v8(71.02,75.87) v8(71,8.49) v8(71.19,66.42) v8(71.19,66.05) v8(71.27,64.83) v8(71.27,64.45) v8(71.3,33.91) v8(71.27,32.48) v8(71.41,63.62) v8(71.41,63.24) v8(71.51,4.89) v8(71.66,8.48) v8(71.67,8.08) v8(71.88,41.33) v8(71.83,35.3) v8(71.84,34.93) v8(72,58.76) v8(71.93,56.33) v8(71.91,9.76) v8(71.92,9.39) v8(71.94,4.89) v8(72.09,8.48) v8(72.08,8.11) v8(72.38,55.39) v8(72.38,54.93) v8(72.32,35.3) v8(72.31,34.94) v8(72.39,9.76) v8(72.39,9.4) v8(72.48,57.77) v8(72.48,57.32) v8(72.4,33.91) v8(72.41,4.89) v8(72.55,29.43) v8(72.56,8.48) v8(72.57,8.11) v8(72.73,35.33) v8(72.74,34.94) v8(72.81,9.79) v8(72.81,9.4) v8(72.98,41.33) v8(73.27,35.32) v8(73.26,34.94) v8(73.27,15.95) v8(73.27,15.48) v8(73.27,15.05) v8(73.26,14.39) v8(73.47,28.44) v8(73.48,9.77) v8(73.48,9.39) v8(73.64,15.95) v8(73.64,15.47) v8(73.65,14.38) v8(74.07,28.44) v8(74.07,4.85) v8(74.47,10.03) v8(74.46,9.64) v8(74.41,8.6) v8(74.41,8.21) v8(74.73,4.85) v8(75.04,69.74) v8(75.03,69.35) v8(75.08,8.59) v8(75.08,8.19) v8(75.17,73.12) v8(75.18,72.65) v8(75.18,72.22) v8(75.17,71.56) v8(75.13,10.02) v8(75.14,9.62) v8(75.16,4.85) v8(75.35,76.08) v8(75.36,75.7) v8(75.48,49.94) v8(75.47,40.69) v8(75.5,8.22) v8(75.55,73.12) v8(75.54,72.64) v8(75.57,72.23) v8(75.56,71.55) v8(75.51,54.75) v8(75.55,53.75) v8(75.56,10.02) v8(75.55,9.66) v8(75.5,8.59) v8(75.7,69.73) v8(75.69,50.16) v8(75.63,4.85) v8(75.7,69.33) v8(75.71,49.71) v8(75.84,76.07) v8(75.83,75.71) v8(75.89,55.11) v8(75.93,49.93) v8(75.96,40.15) v8(75.97,8.59) v8(75.98,8.22) v8(76.03,10.02) v8(76.03,9.65) v8(76.13,69.73) v8(76.12,69.37) v8(76.25,76.1) v8(76.26,75.71) v8(76.26,68.19) v8(76.25,67.8) v8(76.29,39.87) v8(76.46,14) v8(76.46,13.52) v8(76.46,13.1) v8(76.46,12.43) v8(76.6,69.73) v8(76.56,66.15) v8(76.55,65.77) v8(76.56,64.58) v8(76.55,64.2) v8(76.6,69.36) v8(76.76,39.31) v8(76.83,14) v8(76.83,13.52) v8(76.86,13.1) v8(76.84,12.43) v8(76.92,76.08) v8(76.92,75.7) v8(76.92,68.18) v8(76.92,67.78) v8(77.18,73.37) v8(77.17,38.96) v8(77.22,66.14) v8(77.23,65.75) v8(77.22,64.58) v8(77.23,64.18) v8(77.31,77.78) v8(77.31,77.41) v8(77.34,68.18) v8(77.34,67.82) v8(77.31,9.04) v8(77.31,8.56) v8(77.31,8.14) v8(77.41,4.91) v8(77.56,73.75) v8(77.65,66.14) v8(77.64,65.78) v8(77.65,64.58) v8(77.64,64.21) v8(77.63,38.54) v8(77.68,9.04) v8(77.68,8.56) v8(77.79,77.78) v8(77.78,77.41) v8(77.71,8.14) v8(77.82,68.19) v8(77.82,67.81) v8(78.07,74.26) v8(78.07,4.9) v8(78.12,66.15) v8(78.13,65.77) v8(78.12,64.58) v8(78.13,64.21) v8(78.2,77.81) v8(78.21,77.41) v8(78.27,38.1) v8(78.45,74.64) v8(78.56,37.62) v8(78.5,4.9) v8(78.88,77.79) v8(78.87,77.4) v8(78.9,11.33) v8(78.89,10.95) v8(78.9,79.32) v8(78.91,78.95) v8(78.96,75.02) v8(78.97,4.91) v8(79.38,79.32) v8(79.38,78.95) v8(79.34,75.4) v8(79.59,30.53) v8(79.72,75.78) v8(79.8,79.35) v8(79.81,78.95) v8(79.81,9.99) v8(79.8,9.6) v8(80.1,76.16) v8(80.02,21.96) v8(80.01,21.58) v8(80.47,79.33) v8(80.47,78.95) v8(80.48,76.54) v8(80.47,9.98) v8(80.47,9.58) v8(80.7,30.53) v8(80.68,21.95) v8(80.68,21.56) v8(80.6,6.08) v8(80.86,76.93) v8(80.86,76.04) v8(80.89,9.98) v8(80.89,9.61) v8(81.1,21.59) v8(81.1,21.95) v8(81.24,77.31) v8(81.27,6.07) v8(81.37,9.98) v8(81.37,9.61) v8(81.58,21.96) v8(81.58,21.58) v8(81.62,77.69) v8(81.69,6.07) v8(81.78,30.53) v8(82,78.07) v8(82.16,6.08) v8(82.38,78.45) v8(82.6,30.48) v8(82.77,78.83) v8(82.91,9.55) v8(82.91,9.16) v8(83.15,79.21) v8(83.26,70.76) v8(83.53,79.59) v8(83.58,9.54) v8(83.58,9.14) v8(84,9.17) v8(84,9.54) v8(84.01,7.81) v8(84.01,7.43) v8(84.17,4.95) v8(84.48,9.54) v8(84.48,9.17) v8(84.62,40.62) v8(84.68,7.8) v8(84.68,7.41) v8(84.83,4.94) v8(84.96,70.2) v8(85.08,40.05) v8(85.1,7.44) v8(85.1,7.8) v8(85.25,4.94) v8(85.54,72.39) v8(85.58,7.81) v8(85.58,7.43) v8(85.73,4.95) v8(87.23,62.29) v8(87.78,75.29) v8(88.02,45.17) v8(88.6,35.1) v8(88.63,43.54) v8(88.96,23.41) v8(89.4,28.19) v8(89.41,67.47) v8(89.47,64.53) v8(89.96,28.19) v8(90.17,25.47) v8(90.18,8.03) v8(90.17,7.65) v8(90.15,6.6) v8(90.15,6.22) v8(90.21,57.38) v8(90.47,68.36) v8(90.52,28.19) v8(90.84,8.02) v8(90.85,7.63) v8(90.81,6.59) v8(90.82,6.2) v8(91.07,28.19) v8(91.19,25.47) v8(91.27,8.02) v8(91.26,7.66) v8(91.24,6.59) v8(91.23,6.23) v8(91.45,57.86) v8(91.79,62.77) v8(91.74,8.03) v8(91.74,7.65) v8(91.71,6.6) v8(91.72,6.22) v8(91.82,28.56) v8(91.94,22.13) v8(92.03,9.56) v8(92.02,9.17) v8(92.2,25.47) v8(92.49,57.37) v8(92.57,28.21) v8(92.69,9.55) v8(92.7,9.16) v8(92.9,7.61) v8(92.9,7.99) v8(92.96,6.63) v8(92.95,6.24) v8(93.03,56.87) v8(93.12,9.55) v8(93.11,9.19) v8(93.53,80.01) v8(93.52,79.63) v8(93.59,9.56) v8(93.59,9.18) v8(93.56,7.98) v8(93.57,7.59) v8(93.62,6.62) v8(93.62,6.23) v8(93.74,53.95) v8(93.97,33.48) v8(93.99,7.98) v8(93.98,7.62) v8(94.05,6.62) v8(94.04,6.26) v8(94.19,80) v8(94.2,79.61) v8(94.46,7.99) v8(94.47,7.61) v8(94.52,6.63) v8(94.52,6.25) v8(94.62,80) v8(94.61,79.64) v8(94.65,78.86) v8(94.64,78.47) v8(94.85,56.13) v8(94.81,18.51) v8(94.83,17.85) v8(95.09,80.01) v8(95.09,79.63) v8(95.14,72.46) v8(95.18,6.47) v8(95.19,6.1) v8(95.27,35.38) v8(95.31,78.85) v8(95.31,78.45) v8(95.31,18.51) v8(95.34,17.9) v8(95.45,53.35) v8(95.58,55.45) v8(95.66,77.84) v8(95.66,77.46) v8(95.73,78.85) v8(95.73,78.48) v8(95.92,79.99) v8(95.91,79.6) v8(95.9,18.53) v8(95.9,17.89) v8(96.21,78.85) v8(96.21,78.48) v8(96.29,6.42) v8(96.29,6.05) v8(96.32,77.83) v8(96.33,77.44) v8(96.46,18.51) v8(96.48,17.9) v8(96.58,79.98) v8(96.58,79.58) v8(96.75,77.83) v8(96.75,77.47) v8(96.72,56.18) v8(97,79.61) v8(96.92,28.84) v8(96.96,18.51) v8(96.96,17.9) v8(97,79.98) v8(97.22,77.84) v8(97.23,77.46) v8(97.48,79.98) v8(97.48,79.61) v8(97.62,63.5) v8(97.65,54.98) v8(97.69,37.83) v8(97.65,36.1) v8(97.65,35.58) v8(97.65,34.88) v8(97.64,34.39) v8(97.62,29.05) v8(97.74,78.91) v8(97.74,78.52) v8(97.94,39.79) v8(97.93,38.87) v8(98.19,79.99) v8(98.18,79.6) v8(98.11,64.35) v8(98.18,41.1) v8(98.18,40.54) v8(98.26,29.05) v8(98.41,78.9) v8(98.41,78.5) v8(98.44,26.71) v8(98.54,63.95) v8(98.76,53.67) v8(98.85,79.98) v8(98.86,79.58) v8(98.83,78.9) v8(98.83,78.54) v8(98.81,77.82) v8(98.81,77.43) v8(98.81,55.01) v8(98.87,51.38) v8(98.89,29.05) v8(99.28,79.98) v8(99.27,79.61) v8(99.24,51.36) v8(99.3,7.41) v8(99.31,78.9) v8(99.31,78.53) v8(99.33,77.83) v8(99.34,77.44) v8(99.37,55.01) v8(99.53,29.05) v8(99.75,79.98) v8(99.76,79.61) v8(99.77,77.83) v8(99.77,77.44) v8(100.04,29.05) v8(100.19,7.41) v8(100.37,77.81) v8(100.38,77.44) v8(100.5,45.91) v8(100.48,30.99) v8(100.53,72.84) v8(100.52,72.11) v8(100.54,71.11) v8(100.6,62.24) v8(100.59,59.51) v8(100.59,58.67) v8(100.56,57.43) v8(100.59,56.7) v8(100.59,54.66) v8(100.58,53.53) v8(100.58,52.62) v8(100.57,51.35) v8(100.56,50.08) v8(100.52,47.09) v8(100.52,46.58) v8(100.53,45.27) v8(100.55,41.27) v8(100.53,39.09) v8(100.53,36.84) v8(100.53,34.56) v8(100.53,32.26) v8(100.6,60.95) v8(100.61,55.6) v8(100.67,29.05) v8(100.67,17.87) v8(100.67,17.49) v8(101.05,17.87) v8(101.05,17.49) v8(101.24,27.35) v8(101.56,16.73) v8(101.56,16.09) v8(101.98,70.66) v8(101.98,70) v8(101.95,69.46) v8(102.01,71.19) v8(102.26,20.86) v8(102.32,16.73) v8(102.32,16.09) v8(102.48,64.73) v8(102.68,62.81) v8(102.81,65.25) v8(102.84,26.05) v8(103.09,16.73) v8(103.09,16.09) v8(103.15,64.63) v8(103.25,62.84) v8(103.32,51.93) v8(103.32,51.43) v8(103.43,49.45) v8(103.67,52.87) v8(103.8,65.59) v8(103.82,62.86) v8(103.83,50.73) v8(103.83,50.22) v8(103.84,49.03) v8(104.01,37.09) v8(104.25,48.63) v8(104.35,64.05) v8(104.39,62.88) v8(104.37,37.1) v8(104.6,67.91) v8(104.66,48.19) v8(104.76,26.7) v8(104.83,37.1) v8(104.96,62.91) v8(105.01,67.48) v8(105.4,67.08) v8(105.8,66.66) v8(105.99,36.68) v8(106.05,37.17) v8(106.19,66.26) v8(106.18,6.01) v8(106.5,36.67) v8(106.54,63.86) v8(106.55,49.48) v8(106.7,67.47) v8(106.71,67.92) v8(106.85,66.05) v8(106.82,36.92) v8(106.89,10.71) v8(107.19,37.15) v8(107.13,36.66) v8(107.26,65.72) v8(107.25,63.36) v8(107.2,50.15) v8(107.38,46.65) v8(107.41,51.07) v8(107.69,64.09) v8(107.68,36.66) v8(107.79,47.05) v8(107.74,37.15) v8(107.78,10.71) v8(107.75,6.21) v8(107.86,53.44) v8(107.86,51.46) v8(108.2,50.95) v8(108.22,47.46) v8(108.27,37.15) v8(108.21,36.66) v8(108.61,50.53) v8(108.63,47.87) v8(108.78,53.45) v8(108.77,37.13) v8(108.71,36.64) v8(108.93,48.67) v8(109.02,50.1) v8(109.25,48.92) v8(109.72,55.25) v8(109.82,49.49) v8(110.07,49.75) v8(110.19,18.39) v8(110.71,50.32) v8(110.71,5.72) v8(110.99,54.54) v8(110.96,50.57) v8(111.29,51.32) v8(111.43,54.54) v8(111.8,51.83) v8(111.85,10.44) v8(112.64,29.49) v8(112.62,19.27) v8(112.85,48.15) v8(113.06,54) v8(113.06,53.56) v8(113.08,18.51) v8(113.06,17.63) v8(113.24,50.95) v8(113.63,51.37) v8(114.05,51.78) v8(114.22,45.19) v8(114.26,5.51) v8(114.46,52.2) v8(115.13,71.21) v8(115.12,70.58) v8(115.13,70.03) v8(115.14,69.39) v8(115.12,68.83) v8(115.12,68.19) v8(115.14,67.64) v8(115.15,67) v8(115.14,66.43) v8(115.14,65.78) v8(115.14,65.22) v8(115.14,64.58) v8(115.14,64.03) v8(115.14,63.39) v8(115.56,51.35) v8(116.08,69) v8(116.17,49.62) v8(116.12,9.55) v8(116.61,69.03) v8(117.13,41.37) v8(118.33,51.06) v8(118.74,51.06) v8(119.47,51.04) v8(119.59,53.18) v8(119.79,9.39) v8(119.83,48.74) v8(119.97,45.54) v8(119.94,39.62) v8(120.12,13.57) v8(120.44,12.51) v8(120.65,55.54) v8(120.65,54.96) v8(120.78,60.35) v8(120.76,59.26) v8(120.78,52.23) v8(120.78,51.04) v8(121.16,61.2) v8(121.35,52.23) v8(121.44,72.47) v8(121.49,58.86) v8(121.5,60.04) v8(121.6,74.39) v8(121.6,73.8) v8(121.6,73.22) v8(122.14,44.06) v8(122.24,61.68) v8(122.46,79.75) v8(122.45,79.36) v8(122.56,38.04) v8(123.08,7.15) v8(123.12,79.74) v8(123.13,79.34) v8(123.42,77.24) v8(123.55,79.74) v8(123.54,79.37) v8(123.79,77.24) v8(123.79,55.47) v8(123.95,54.7) v8(124.02,79.74) v8(124.03,79.37) v8(124.03,9.65) v8(124.15,77.25) v8(124.18,48.64) v8(124.2,45.88) v8(124.26,53.85) v8(124.21,50.19) v8(124.22,46.96) v8(124.21,44.56) v8(124.97,50.41) v8(124.98,48.28) v8(124.97,46.86) v8(124.99,44.62) v8(124.99,19.55) v8(125.05,49.61) v8(125.03,45.8) v8(125.01,42.97) v8(125.07,18.16) v8(125.01,14.15) v8(125.19,21.59) v8(125.23,23.25) v8(125.53,6.77) v8(125.69,26.68) v8(125.83,9.65) v8(126.1,41.85) v8(126.05,22.27) v8(126.05,19.56) v8(126.15,24.93) v8(126.14,18.17) v8(126.3,23.26) v8(126.42,40.76) v8(126.48,38.32) v8(126.46,37.05) v8(126.51,39.39) v8(126.55,35.95) v8(126.5,15.97) v8(126.63,21.4) v8(127,34.28) v8(127.19,38.16) v8(127.16,36.74) v8(127.28,41.66) v8(127.23,40.47) v8(127.23,39.19) v8(127.2,35.24) v8(127.22,26.02) v8(127.33,19.58) v8(127.33,6.77) v8(127.45,72.83) v8(127.41,18.19) v8(127.68,20.65) v8(127.63,9.65) v8(128.45,72.83) v8(129.13,6.77) v8(129.45,72.83) v8(129.43,9.65) v8(130.33,14.08) v8(130.45,72.83) v8(130.93,6.77) v8(131.23,9.65) v8(131.86,79.86) v8(131.84,79.19) v8(131.87,78.77) v8(131.87,78.29) v8(131.87,44.7) v8(131.94,77.12) v8(131.92,76.44) v8(131.95,76.03) v8(131.94,75.54) v8(132.25,79.85) v8(132.24,79.19) v8(132.24,78.77) v8(132.24,78.29) v8(132.32,77.11) v8(132.31,76.45) v8(132.31,76.02) v8(132.32,75.55) v8(132.79,71.68) v8(132.73,6.77) v8(133.06,13.15) v8(133.03,9.65) v8(133.77,28.33) v8(133.98,71.68) v8(133.95,27.4) v8(134.43,27.5) v8(134.53,6.77) v8(134.8,50.41) v8(134.84,28.33) v8(134.83,9.65) v8(135.12,21.3) v8(135.37,50.41) v8(135.45,74.23) v8(135.45,73.75) v8(135.45,73.22) v8(135.5,27.51) v8(135.79,27.9) v8(136.04,74.66) v8(136.11,28.36) v8(136.4,74.67) v8(136.79,71.68) v8(136.77,27.53) v8(137.21,76.44) v8(137.33,12.25) v8(137.33,11.69) v8(137.46,56.62) v8(137.4,52.72) v8(137.79,76.44) v8(137.87,21.72) v8(138.14,74.84) v8(138.13,6.77) v8(138.38,76.44) v8(138.42,67.3) v8(138.44,21.72) v8(138.43,9.65) v8(138.7,74.83) v8(138.8,12) v8(139.01,21.72) v8(139.13,76.27) v8(139.27,45.42) v8(139.59,71.43) v8(139.81,73.65) v8(140.84,39.71) v8(141.13,6.77) v8(141.73,6.77) v8(142.08,49.16) v8(142.33,35.63) v8(142.38,7.15) v8(142.92,35.63) v8(143.21,74.92) v8(143.27,46) v8(143.51,36.06) v8(143.66,18.65) v8(143.77,74.93) v8(144.06,49.58) v8(144.07,36.06) v8(144.22,10.7) v8(144.39,11.6) v8(144.57,35.41) v8(144.59,18.66) v8(145.08,14) v8(145.17,41.14) v8(145.23,49.31) v8(145.34,39.7) v8(145.46,11.6) v8(145.62,43.17) v8(145.73,41.13) v8(145.81,47.11) v8(145.81,46.3) v8(146.05,49.35) v8(146.05,48.08) v8(146.15,14) v8(146.26,43.06) v8(146.63,50.56) v8(146.63,49.35) v8(146.63,48.08) v8(146.67,45.83) v8(146.77,15.27) v8(146.73,11.63) v8(146.84,43.07) v8(146.89,40.73) v8(146.84,14.76) v8(146.9,39.94) v8(147.1,38.74) v8(147.09,15.65) v8(147.1,38.21) v8(147.17,23.88) v8(147.11,18.43) v8(147.15,14.51) v8(147.45,50.59) v8(147.44,48.88) v8(147.44,47.99) v8(147.43,41.37) v8(147.47,40.29) v8(147.47,39.82) v8(147.42,14.02) v8(147.6,15.78) v8(147.66,14.44) v8(147.8,11.63) v8(148.02,47.04) v8(148.08,16.75) v8(148.08,5.15) v8(148.18,18.43) v8(148.17,15.78) v8(148.17,14.44) v8(148.28,73.29) v8(148.21,7.02) v8(148.48,14.03) v8(148.43,9.69) v8(148.68,14.44) v8(148.74,15.78) v8(148.84,73.3) v8(149.15,16.75) v8(149.19,14.44) v8(149.15,5.15) v8(149.27,44.65) v8(149.25,15.78) v8(149.28,7.02) v8(149.45,18.45) v8(149.52,51.23) v8(149.52,50.66) v8(149.5,9.69) v8(149.69,14.63) v8(149.76,15.52) v8(149.89,15.01) v8(150.06,8.51) v8(150.42,16.77) v8(150.42,5.18) v8(150.52,18.45) v8(150.55,7.05) v8(150.73,51.23) v8(150.77,9.72) v8(150.94,60.45) v8(150.99,37.33) v8(150.96,36.84) v8(150.96,36.11) v8(150.96,35.6) v8(151.2,70.81) v8(151.13,8.51) v8(151.21,70.25) v8(151.28,15.27) v8(151.35,14.76) v8(151.48,16.78) v8(151.48,5.18) v8(151.57,13.47) v8(151.6,15.65) v8(151.66,14.51) v8(151.62,7.05) v8(151.74,22.33) v8(151.84,9.72) v8(152.11,15.78) v8(152.17,14.44) v8(152.37,22.31) v8(152.4,8.54) v8(152.44,51.25) v8(152.44,50.7) v8(152.62,57.78) v8(152.68,15.78) v8(152.68,14.44) v8(152.64,13.48) v8(152.76,54.48) v8(152.93,22.31) v8(153.19,14.44) v8(153.29,36.05) v8(153.25,15.78) v8(153.35,9.06) v8(153.7,14.44) v8(153.78,61.58) v8(153.76,15.78) v8(153.88,36.31) v8(153.82,20.1) v8(153.91,13.5) v8(154.27,15.52) v8(154.2,14.63) v8(154.38,61.6) v8(154.39,15.01) v8(154.45,36.35) v8(154.45,20.09) v8(154.85,51.25) v8(154.94,50.7) v8(154.98,13.5) v8(155.01,20.09) v8(155.36,10.5) v8(155.73,14.35) v8(156.17,13.42) v8(156.62,37.63) v8(156.62,37.07) v8(156.65,10.68) v8(156.79,14.36) v8(157.22,37.62) v8(157.24,37.05) v8(157.23,13.42) v8(157.68,50.66) v8(157.63,41.17) v8(157.63,40.61) v8(157.62,39.97) v8(157.62,39.41) v8(157.64,38.76) v8(157.64,38.21) v8(157.66,36.05) v8(157.79,19.29) v8(157.98,10.56) v8(158.06,14.38) v8(158.37,41.21) v8(158.37,40.65) v8(158.37,40.09) v8(158.37,39.53) v8(158.4,38.16) v8(158.47,36.02) v8(158.43,19.27) v8(158.54,75.55) v8(158.5,13.45) v8(158.99,19.27) v8(158.97,10.46) v8(159.01,36.99) v8(159.1,75.56) v8(159.13,14.38) v8(159.52,40.47) v8(159.57,13.45) v8(159.65,19.26) v8(160.08,40.47) v8(160.16,49.57) v8(160.21,19.26) v8(160.49,51.23) v8(160.49,50.48) v8(160.49,37.11) v8(160.6,35.98) v8(160.64,40.47) v8(160.86,19.27) v8(161.42,19.27) v8(162.32,40.47) v8(162.58,51.23) v8(162.5,36.04) v8(162.6,50.47) v8(162.88,49.54) v8(163.08,18.04) v8(163.53,17.3) v8(163.55,16.3) v8(163.64,18.04) v8(163.92,6.44) v8(164.17,17.28) v8(164.19,16.28) v8(164.27,18.02) v8(164.43,36.14) v8(164.72,17.28) v8(164.75,16.28) v8(164.83,18.02) v8(164.99,6.44) v8(165.39,17.27) v8(165.5,18.01) v8(165.41,16.27) v8(165.95,17.27) v8(165.97,16.27) v8(165.92,6.38) v8(166.05,18.01) v8(166.66,18.02) v8(166.6,17.28) v8(166.63,16.28) v8(166.87,38.79) v8(167.02,6.39) v8(167.16,17.28) v8(167.18,16.28) v8(167.22,18.02) v8(167.64,36.92) v8(168.02,6.39) v8(168.76,7.13) v8(169,6.4) v8(169.77,7.13) v8(170.02,6.53) v8(170.39,38.85) v8(170.77,7.13) v8(171.03,6.53) v8(171.24,8.29) v8(171.24,7.54) v8(171.41,19.85) v8(171.53,37.39) v8(172.05,6.41) v8(173,6.36) v8(173.99,6.36) v8(174.88,47.43) v8(174.99,6.36) v8(174.96,5.47) v8(175.52,22.47) v8(175.61,24.62) v8(175.6,23.59) v8(175.65,7.19) v8(176,48.89) v8(176.02,6.53) v8(176.04,5.5) v8(176.48,24.62) v8(176.48,23.6) v8(176.48,22.45) v8(176.56,77.24) v8(176.57,76.68) v8(176.53,48.89) v8(176.76,7.22) v8(177.01,6.53) v8(177.1,48.88) v8(177.41,24.63) v8(177.44,23.59) v8(177.45,22.46) v8(177.6,7.33) v8(177.63,48.88) v8(177.69,19.78) v8(178.37,48.88) v8(178.3,5.38) v8(178.71,6.12) v8(178.9,48.88) v8(179.28,7) v8(179.62,48.88) v8(179.9,5.53) v8(180.15,48.88) v8(180.27,6.35) v8(181.24,5.83) v8(183.1,5.75) v8(184.19,8.83) v8(184.23,8.14) v8(184.27,5.82) v8(185.07,57.46) v8(185.08,56.9) v8(185.02,8.87) v8(185.03,8.15) v8(185.74,5.86) v8(185.94,21.62) v8(186.67,46.01) v8(186.67,45.64) v8(187.15,46.01) v8(187.15,45.64) v8(187.49,26.92) v8(187.57,46.04) v8(187.57,45.64) v8(188.24,46.02) v8(188.23,45.63) v8(189.79,46.09) v8(189.8,45.71) v8(189.82,44.79) v8(189.82,44.42) v8(190.27,46.08) v8(190.27,45.72) v8(190.3,44.42) v8(190.3,44.79) v8(190.69,46.11) v8(190.7,45.72) v8(190.72,44.82) v8(190.72,44.42) v8(191.05,7.65) v8(191.22,9.26) v8(191.22,8.37) v8(191.36,46.09) v8(191.36,45.71) v8(191.39,44.8) v8(191.38,44.41) v8(191.45,12.91) v8(191.47,12.44) v8(191.47,11.69) v8(191.48,11.23) v8(191.48,10.52) v8(191.47,10.01) v8(192.23,12.96) v8(192.23,12.41) v8(192.23,11.85) v8(192.23,11.29) v8(192.23,10.73) v8(192.23,10.17) v8(192.23,9.61) v8(192.23,9.05) v8(192.23,8.48) v8(192.48,44.87) v8(192.49,44.49) v8(192.56,46.44) v8(192.57,46.07) v8(192.87,48.22) v8(192.87,47.84) v8(192.87,47.46) v8(192.87,47.08) v8(192.97,44.86) v8(192.96,44.5) v8(193.04,46.44) v8(193.04,46.07) v8(193.38,44.89) v8(193.39,44.5) v8(193.46,46.47) v8(193.46,46.07) v8(194.06,44.87) v8(194.05,44.49) v8(194.15,59.7) v8(194.13,46.45) v8(194.13,46.06) v8(194.17,27) v8(194.17,25.5) v8(194.17,24) v8(194.17,22.5) v8(194.17,21) v8(194.17,19.5) v8(194.17,18) v8(194.17,17) v8(194.17,15.5) v8(194.17,14) v8(194.17,12.5) v8(194.17,11) v8(194.17,9.5) v8(194.17,8) v8(194.25,28.5) v8(194.25,6.5) v8(194.31,48.47) v8(194.32,48.1) v8(194.68,59.7) v8(194.8,48.47) v8(194.79,48.11) v8(195.21,48.5) v8(195.22,48.11) v8(195.34,59.68) v8(195.49,28.15) v8(195.49,26.25) v8(195.49,24.75) v8(195.49,23.25) v8(195.49,19.25) v8(195.49,17.75) v8(195.49,16.25) v8(195.54,6.85) v8(195.87,59.68) v8(195.88,48.48) v8(195.88,48.1) v8(196.19,29.89) v8(196.19,5.1) v8(196.36,57.08) v8(196.37,56.52) v8(196.32,25) v8(196.32,22) v8(196.32,19) v8(196.32,16) v8(196.32,13) v8(196.32,10) v8(196.73,48.5) v8(196.73,48.13) v8(197.21,48.49) v8(197.2,48.13) v8(197.62,48.53) v8(197.63,48.13) v8(197.62,47.27) v8(197.6,46.6) v8(197.63,46.18) v8(197.63,45.7) v8(197.62,43.74) v8(197.6,43.07) v8(197.63,42.65) v8(197.63,42.17) v8(197.76,5.11) v8(197.76,4.54) v8(197.89,30.51) v8(197.89,30) v8(198,46.6) v8(198,46.18) v8(198,43.07) v8(198,42.65) v8(198.01,47.27) v8(198,45.7) v8(198.01,43.74) v8(198,42.17) v8(198.13,74.32) v8(198.3,48.51) v8(198.29,48.12) v8(198.55,74.32) v8(198.69,9.54) v8(198.72,30.51) v8(198.72,29.94) v8(198.79,15.83) v8(198.77,15.15) v8(198.8,14.25) v8(198.76,12.98) v8(198.75,12.31) v8(198.78,11.89) v8(198.77,11.41) v8(198.71,10.21) v8(198.73,9.12) v8(198.72,8.64) v8(198.72,5.11) v8(198.72,4.54) v8(198.86,40.76) v8(198.86,40.37) v8(198.8,14.74) v8(199.1,43.87) v8(199.01,21.09) v8(199.02,20.72) v8(199.1,10.21) v8(199.09,9.55) v8(199.09,9.12) v8(199.09,8.65) v8(199.1,45.43) v8(199.11,44.96) v8(199.11,44.54) v8(199.16,27.6) v8(199.17,27.22) v8(199.11,26.1) v8(199.12,25.72) v8(199.14,24.57) v8(199.14,24.2) v8(199.11,22.87) v8(199.12,22.5) v8(199.15,19.03) v8(199.13,18.35) v8(199.16,17.94) v8(199.15,17.45) v8(199.17,15.82) v8(199.17,15.16) v8(199.17,14.73) v8(199.17,14.26) v8(199.15,12.98) v8(199.14,12.31) v8(199.14,11.89) v8(199.15,11.41) v8(199.22,48.99) v8(199.22,48.6) v8(199.22,48.22) v8(199.22,47.46) v8(199.22,47.08) v8(199.22,46.47) v8(199.27,34.71) v8(199.26,34.33) v8(199.34,38.52) v8(199.34,38.14) v8(199.32,36.77) v8(199.31,36.38) v8(199.48,45.44) v8(199.47,44.96) v8(199.48,43.87) v8(199.5,21.09) v8(199.49,20.72) v8(199.5,44.54) v8(199.52,40.75) v8(199.53,40.35) v8(199.6,26.09) v8(199.59,25.73) v8(199.6,22.87) v8(199.59,22.5) v8(199.53,19.02) v8(199.52,18.36) v8(199.52,17.93) v8(199.53,17.46) v8(199.65,27.59) v8(199.64,27.23) v8(199.62,24.57) v8(199.62,24.2) v8(199.95,40.75) v8(199.95,40.38) v8(199.98,36.76) v8(199.99,36.37) v8(199.93,34.7) v8(199.94,34.31) v8(199.91,21.12) v8(199.92,20.72) v8(200.01,38.51) v8(200.01,38.12) v8(200.06,27.62) v8(200.07,27.23) v8(200.01,26.12) v8(200.02,25.73) v8(200.04,24.6) v8(200.04,24.2) v8(200.01,22.9) v8(200.02,22.5) v8(200.36,34.7) v8(200.35,34.34) v8(200.42,40.75) v8(200.43,40.38) v8(200.43,38.51) v8(200.43,38.15) v8(200.41,36.76) v8(200.4,36.4) v8(200.58,21.1) v8(200.58,20.72) v8(200.69,26.1) v8(200.68,25.72) v8(200.69,22.88) v8(200.68,22.49) v8(200.74,27.6) v8(200.73,27.22) v8(200.71,24.58) v8(200.71,24.2) v8(200.88,36.77) v8(200.89,36.39) v8(200.83,34.71) v8(200.84,34.33) v8(200.91,38.52) v8(200.91,38.14) v8(201.27,58.85) v8(201.27,58.49) v8(201.26,57.95) v8(201.26,57.59) v8(201.68,20.36) v8(201.68,19.98) v8(201.73,21.96) v8(201.73,21.58) v8(201.94,54.72) v8(201.95,39.19) v8(201.95,38.71) v8(201.95,38.29) v8(201.94,37.62) v8(201.92,35.99) v8(201.93,35.51) v8(201.93,35.09) v8(201.92,34.42) v8(202.1,53.25) v8(202.12,53.93) v8(202.13,52.84) v8(202.12,52.35) v8(202.16,20.35) v8(202.16,19.99) v8(202.29,35.99) v8(202.29,35.51) v8(202.21,21.95) v8(202.21,21.59) v8(202.32,39.19) v8(202.31,38.71) v8(202.35,38.29) v8(202.33,37.62) v8(202.32,35.09) v8(202.3,34.42) v8(202.49,53.26) v8(202.49,52.83) v8(202.5,52.36) v8(202.5,53.92) v8(202.58,20.38) v8(202.58,19.99) v8(202.63,21.98) v8(202.63,21.59) v8(203.3,21.58) v8(203.25,20.36) v8(203.25,19.98) v8(203.3,21.96) v8(203.94,35.83) v8(203.94,35.45) v8(204.08,45.26) v8(204.08,44.78) v8(204.08,44.36) v8(204.08,43.7) v8(204.27,18.91) v8(204.27,18.53) v8(204.45,45.26) v8(204.45,44.78) v8(204.48,44.36) v8(204.46,43.69) v8(204.41,38.72) v8(204.42,35.82) v8(204.42,35.46) v8(204.42,17.08) v8(204.43,16.71) v8(204.75,20.23) v8(204.76,19.86) v8(204.75,18.9) v8(204.75,18.54) v8(204.84,35.85) v8(204.84,35.46) v8(204.91,17.07) v8(204.9,16.71) v8(205.01,22.06) v8(205.01,21.68) v8(205.17,18.93) v8(205.17,18.54) v8(205.3,41.19) v8(205.24,20.22) v8(205.23,19.86) v8(205.32,41.86) v8(205.33,40.77) v8(205.32,40.29) v8(205.32,38.72) v8(205.32,17.11) v8(205.33,16.71) v8(205.49,22.05) v8(205.48,21.69) v8(205.51,35.83) v8(205.51,35.45) v8(205.69,41.19) v8(205.69,40.77) v8(205.7,40.29) v8(205.65,20.26) v8(205.66,19.86) v8(205.7,41.86) v8(205.84,18.92) v8(205.84,18.53) v8(205.91,22.08) v8(205.91,21.69) v8(205.99,17.09) v8(205.99,16.7) v8(206.32,20.24) v8(206.32,19.85) v8(206.58,22.07) v8(206.57,21.68) v8(206.77,37.16) v8(206.75,36.49) v8(206.78,36.07) v8(206.77,35.59) v8(206.91,18.02) v8(207.15,37.16) v8(207.14,36.49) v8(207.14,36.07) v8(207.15,35.6) v8(207.32,34.34) v8(207.31,33.67) v8(207.34,33.25) v8(207.33,32.77) v8(207.71,34.34) v8(207.7,33.68) v8(207.7,33.25) v8(207.71,32.78) v8(207.83,17.13) v8(207.83,16.76) v8(207.98,18.02) v8(208.16,20.79) v8(208.16,20.41) v8(208.38,22.57) v8(208.39,22.19) v8(208.31,17.13) v8(208.3,16.76) v8(208.64,20.78) v8(208.63,20.42) v8(208.72,17.16) v8(208.73,16.76) v8(208.87,22.56) v8(208.86,22.2) v8(208.91,17.96) v8(209.05,20.81) v8(209.06,20.42) v8(209.28,22.59) v8(209.29,22.2) v8(209.4,17.14) v8(209.39,16.75) v8(209.73,20.8) v8(209.72,20.41) v8(209.83,7.77) v8(209.83,7.27) v8(209.83,6.82) v8(209.83,6.38) v8(209.83,5.93) v8(209.96,22.57) v8(209.95,22.19) v8(209.96,8.22) v8(209.96,5.49) v8(210.01,17.97) v8(210.17,13.07) v8(210.27,8.47) v8(210.34,5.17) v8(210.5,11.86) v8(210.48,11.19) v8(210.52,17.12) v8(210.51,16.45) v8(210.54,16.03) v8(210.53,15.55) v8(210.51,10.78) v8(210.51,10.29) v8(210.72,8.47) v8(210.85,14.56) v8(210.84,13.88) v8(210.87,13.47) v8(210.86,12.98) v8(210.88,11.86) v8(210.88,11.2) v8(210.88,10.77) v8(210.88,10.3) v8(210.85,5.17) v8(210.91,17.12) v8(210.9,16.45) v8(210.9,16.03) v8(210.91,15.55) v8(211.24,14.55) v8(211.23,13.89) v8(211.23,13.46) v8(211.24,12.99) v9(15.55,61.71) v9(15.71,62.9) v9(29.9,45.1) v9(30.31,58.26) v9(30.46,44.39) v9(31.14,43.66) v9(33.03,42.43) v9(34.68,56.38) v9(34.72,60.46) v9(34.74,59.25) v9(34.7,55.15) v9(35.55,42.21) v9(111.79,45.53) v9(112.46,56.26) v9(112.64,46.76) v9(113.34,45.53) v9(113.75,47.86) v9(115.3,48.24) v9(115.3,50.31) v9(115.67,48.68) v9(117.13,50.64) v9(118.07,49.31) v9(121.76,65.16) v10(36.03,34.43) v10(36.77,35.23) v10(37.82,36.05) v10(147.76,29.3) v10(178.37,31.03) v11(1.75,16.52) v11(1.73,15.96) v11(1.74,15.38) v11(2.19,73.15) v11(2.17,12.83) v11(2.15,12.27) v11(2.15,11.69) v11(2.38,30.97) v11(2.33,8.87) v11(2.31,8.31) v11(2.32,7.73) v11(2.35,4.21) v11(2.44,30.14) v11(2.59,32.38) v11(2.59,31.8) v11(2.58,16.57) v11(2.58,15.98) v11(2.59,15.3) v11(2.61,32.94) v11(2.64,14.54) v11(2.69,13.71) v11(2.75,73.13) v11(2.98,30.97) v11(2.99,12.89) v11(2.99,12.29) v11(3,11.61) v11(3,30.12) v11(3.16,8.93) v11(3.16,8.33) v11(3.16,7.65) v11(3.24,14.54) v11(3.26,13.69) v11(3.31,75.88) v11(3.3,74.72) v11(3.3,74.13) v11(3.33,73.13) v11(3.43,33) v11(3.43,32.4) v11(3.44,31.72) v11(3.5,57.9) v11(3.58,30.13) v11(3.66,30.98) v11(3.75,24.21) v11(3.84,13.7) v11(3.92,14.54) v11(4.16,12.48) v11(4.29,27.97) v11(4.22,11.65) v11(4.39,73.29) v11(4.34,27.15) v11(4.45,72.46) v11(4.46,31.46) v11(4.59,32.98) v11(4.56,8.64) v11(4.54,8.07) v11(4.55,7.5) v11(4.59,6.19) v11(4.59,3.96) v11(4.65,32.15) v11(4.61,6.76) v11(4.6,5.62) v11(4.61,4.52) v11(4.6,3.38) v11(4.89,27.97) v11(4.99,73.29) v11(4.91,27.13) v11(5.01,72.44) v11(5.19,32.98) v11(5.17,31.48) v11(5.19,30.63) v11(5.21,32.13) v11(5.39,8.69) v11(5.39,8.09) v11(5.4,7.41) v11(5.49,27.13) v11(5.44,6.81) v11(5.44,6.21) v11(5.45,5.53) v11(5.44,4.58) v11(5.44,3.98) v11(5.45,3.3) v11(5.59,72.45) v11(5.57,27.98) v11(5.67,73.29) v11(5.79,32.14) v11(5.87,32.98) v11(5.85,31.48) v11(6.6,6.26) v11(6.57,5.69) v11(6.58,5.12) v11(7.28,8.31) v11(7.28,1.36) v11(7.41,68.62) v11(7.41,63.13) v11(7.42,6.31) v11(7.42,5.71) v11(7.43,5.03) v11(7.69,68.62) v11(7.69,63.13) v11(7.97,68.62) v11(7.97,63.13) v11(8.04,28.42) v11(8.36,33.85) v11(9.02,68.88) v11(9.02,63.38) v11(9.34,68.88) v11(9.34,63.38) v11(9.65,68.88) v11(9.65,63.38) v11(10.04,63.38) v11(10.21,68.88) v11(10.58,33.88) v11(10.56,33.32) v11(10.57,32.74) v11(11.19,18.99) v11(11.41,33.94) v11(11.41,33.34) v11(11.42,32.66) v11(11.73,72.72) v11(11.71,72.16) v11(11.71,71.58) v11(11.97,18.99) v11(12.07,20.44) v11(12.55,72.78) v11(12.55,72.18) v11(12.56,71.5) v11(12.57,11.81) v11(12.59,6.75) v11(12.57,6.19) v11(12.58,5.61) v11(12.57,3.91) v11(12.54,3.35) v11(12.55,2.77) v11(12.73,33.94) v11(12.71,33.37) v11(12.72,32.79) v11(13,76.61) v11(12.98,76.04) v11(12.98,75.47) v11(13.26,11.6) v11(13.39,3.97) v11(13.39,3.37) v11(13.4,2.69) v11(13.42,6.81) v11(13.42,6.21) v11(13.43,5.53) v11(13.56,33.99) v11(13.56,33.39) v11(13.56,32.71) v11(13.82,76.66) v11(13.82,76.06) v11(13.83,75.38) v11(14.2,3.93) v11(14.22,4.5) v11(14.2,3.36) v11(14.4,6.4) v11(14.42,6.96) v11(14.41,5.82) v11(14.89,55.38) v11(14.89,20.99) v11(14.94,54.47) v11(14.94,53.47) v11(14.94,52.47) v11(14.94,51.47) v11(14.94,50.47) v11(14.94,49.47) v11(14.94,48.48) v11(14.94,47.48) v11(14.94,46.47) v11(14.93,45.63) v11(15.05,76.18) v11(15.05,74) v11(15.05,67.9) v11(15,60.11) v11(15.02,58.84) v11(15.01,29.9) v11(15.01,29.34) v11(15.04,4.55) v11(15.04,3.95) v11(15.05,3.27) v11(15.24,7.02) v11(15.24,6.42) v11(15.25,5.74) v11(15.63,27.2) v11(15.72,28.02) v11(16.18,56.03) v11(16.18,54.69) v11(16.18,53.35) v11(16.19,52) v11(16.2,50.6) v11(16.18,49) v11(16.19,44.44) v11(16.2,58.02) v11(16.27,28.04) v11(16.25,27.48) v11(16.25,26.9) v11(16.72,44.45) v11(17.04,74.84) v11(17.1,74.01) v11(17.09,28.1) v11(17.09,27.5) v11(17.1,26.82) v11(17.16,49.18) v11(17.23,40.8) v11(17.23,40.28) v11(17.38,44.27) v11(17.4,42.55) v11(17.64,74.84) v11(17.66,73.99) v11(17.62,42.04) v11(17.62,41.43) v11(17.82,70.82) v11(17.8,70.25) v11(17.81,69.67) v11(17.88,44.59) v11(17.95,76.18) v11(17.95,67.9) v11(18.11,25.84) v11(18.24,74) v11(18.21,49.19) v11(18.32,74.84) v11(18.65,70.87) v11(18.65,70.27) v11(18.66,69.59) v11(18.87,30.44) v11(18.91,32.97) v11(18.92,31.69) v11(19.58,49.18) v11(20.3,42.07) v11(20.3,41.46) v11(20.37,30.43) v11(20.37,29.19) v11(20.53,49.2) v11(20.85,76.18) v11(20.85,72.4) v11(20.85,67.9) v11(20.94,66.52) v11(21.06,40.79) v11(21.05,40.27) v11(21.28,51.24) v11(21.41,26.39) v11(21.4,26.04) v11(21.86,40.81) v11(22.48,41.58) v11(22.42,40.81) v11(22.75,65.57) v11(22.79,25.9) v11(22.86,43.79) v11(22.98,40.81) v11(23,41.57) v11(23.84,64.6) v11(23.84,37.03) v11(24.4,37.03) v11(24.47,38.5) v11(24.46,38.01) v11(24.51,75.24) v11(24.95,37.03) v11(25.19,77.16) v11(25.21,77.73) v11(25.2,76.58) v11(25.24,37.72) v11(25.46,44.3) v11(25.46,43.74) v11(25.49,43.18) v11(25.51,37.03) v11(25.75,75.24) v11(26.04,77.78) v11(26.04,77.18) v11(26.05,76.5) v11(26.35,5.78) v11(26.81,32.37) v11(26.8,31.92) v11(26.95,75.24) v11(27.33,76.92) v11(27.38,76.09) v11(27.58,78.94) v11(27.56,78.2) v11(27.56,77.8) v11(27.64,59.55) v11(27.64,58.9) v11(27.77,42.73) v11(27.93,76.92) v11(27.95,76.07) v11(27.97,22.59) v11(28.15,75.24) v11(28.29,58.9) v11(28.3,43.42) v11(28.4,79) v11(28.4,78.22) v11(28.41,77.72) v11(28.52,76.08) v11(28.52,22.61) v11(28.61,76.92) v11(28.6,43.83) v11(28.75,31.64) v11(28.75,31.08) v11(28.74,29.22) v11(28.94,58.9) v11(28.99,30.36) v11(28.9,29.63) v11(29.18,33.44) v11(29.16,32.17) v11(29.16,22.61) v11(29.35,75.24) v11(29.78,33.42) v11(29.71,22.61) v11(29.85,59.14) v11(30.02,67.06) v11(30,46.14) v11(30.07,31.45) v11(30.34,59.23) v11(30.39,31.45) v11(30.5,77.12) v11(30.56,76.3) v11(30.55,75.24) v11(30.68,47.2) v11(30.71,31.45) v11(30.85,79.17) v11(30.85,78.66) v11(30.84,78.03) v11(30.94,34.18) v11(30.92,33.62) v11(30.92,33.04) v11(31.1,77.12) v11(31.12,76.28) v11(31.18,43.99) v11(31.29,31.45) v11(31.3,48.12) v11(31.43,45.08) v11(31.68,79.23) v11(31.69,78.68) v11(31.69,77.95) v11(31.7,76.28) v11(31.61,31.45) v11(31.78,77.13) v11(31.75,75.24) v11(31.76,34.24) v11(31.76,33.64) v11(31.77,32.96) v11(31.94,48.82) v11(31.93,46.26) v11(31.92,31.45) v11(32.33,47.51) v11(32.62,68.63) v11(32.95,75.24) v11(32.94,48.82) v11(33.07,45.06) v11(33.18,44) v11(33.26,46.27) v11(33.32,78.98) v11(33.38,78.15) v11(33.35,76.99) v11(33.4,76.17) v11(33.5,6.07) v11(33.88,45.04) v11(33.92,78.98) v11(33.94,78.13) v11(33.95,76.99) v11(33.97,76.15) v11(34.01,66.44) v11(34.05,47.5) v11(34.09,46.27) v11(34.15,75.24) v11(34.47,45.04) v11(34.52,78.14) v11(34.54,76.16) v11(34.56,48.88) v11(34.6,78.98) v11(34.63,77) v11(34.87,64.16) v11(34.97,47.49) v11(35.08,4.58) v11(35.1,69.41) v11(35.16,45.05) v11(35.15,6.58) v11(35.13,6.01) v11(35.13,5.43) v11(35.13,3.76) v11(35.24,46.21) v11(35.35,75.24) v11(35.59,51.87) v11(35.61,55.07) v11(35.64,54.18) v11(35.62,53.02) v11(35.66,50.36) v11(35.67,49.09) v11(35.68,4.58) v11(35.7,3.74) v11(35.79,77.17) v11(35.84,76.35) v11(35.97,6.63) v11(35.97,6.03) v11(35.98,5.35) v11(36.28,3.74) v11(36.38,77.17) v11(36.36,4.59) v11(36.4,76.33) v11(36.55,75.24) v11(36.98,76.33) v11(37,69.11) v11(37,68.53) v11(37.06,77.18) v11(37.02,64.1) v11(37.55,72.32) v11(37.66,6.63) v11(37.64,6.06) v11(37.65,5.48) v11(37.75,75.24) v11(37.85,4.58) v11(37.95,72.32) v11(37.95,69.63) v11(37.95,66.96) v11(37.9,3.76) v11(38.05,78.98) v11(38.1,78.15) v11(38.17,77.17) v11(38.14,60.59) v11(38.23,76.35) v11(38.22,62.84) v11(38.37,70.09) v11(38.39,66.5) v11(38.49,6.68) v11(38.49,6.08) v11(38.5,5.4) v11(38.45,4.58) v11(38.47,3.74) v11(38.64,78.98) v11(38.66,78.13) v11(38.77,77.17) v11(38.79,76.33) v11(38.95,75.24) v11(39.01,70.09) v11(39.06,66.5) v11(39.04,3.74) v11(39.18,43.35) v11(39.18,42.59) v11(39.18,41.82) v11(39.18,41.06) v11(39.13,4.59) v11(39.24,78.14) v11(39.33,78.98) v11(39.37,76.33) v11(39.45,77.18) v11(39.66,69.69) v11(39.68,66.89) v11(40.15,75.24) v11(40.43,78.95) v11(40.49,78.12) v11(40.54,77.2) v11(40.59,76.37) v11(40.9,6.07) v11(40.88,3.77) v11(40.97,4.62) v11(41.03,78.95) v11(41.05,78.1) v11(41.13,77.2) v11(41.15,76.35) v11(41.16,10.58) v11(41.16,9.99) v11(41.39,75.24) v11(41.54,4.63) v11(41.56,3.78) v11(41.63,78.11) v11(41.71,78.96) v11(41.73,76.36) v11(41.81,77.2) v11(42.15,6.54) v11(42.16,5.86) v11(42.16,5.26) v11(42.11,4.6) v11(42.16,3.78) v11(43,6.46) v11(42.98,5.32) v11(43,5.88) v11(44.16,58.66) v11(44.12,57.02) v11(44.7,6.25) v11(45.49,7.21) v11(45.4,6.36) v11(45.66,58.1) v11(45.66,56.3) v11(45.66,55.38) v11(45.71,57.23) v11(45.7,8.75) v11(45.95,54.02) v11(46.06,7.22) v11(46.09,6.37) v11(46.63,7.2) v11(46.68,6.37) v11(46.81,55.69) v11(47.26,57.08) v11(47.26,55.94) v11(47.36,6.36) v11(47.44,7.21) v11(47.7,54.2) v11(47.76,57.08) v11(47.76,55.94) v11(48.02,7.22) v11(48.04,6.37) v11(48.58,7.2) v11(48.64,6.37) v11(49.02,55.96) v11(49.07,55.14) v11(49.37,52.43) v11(49.34,6.34) v11(49.43,51.61) v11(49.42,7.18) v11(49.53,58.37) v11(49.52,53.24) v11(49.62,55.96) v11(49.64,55.12) v11(49.84,54.54) v11(49.97,52.43) v11(49.99,51.59) v11(50,7.19) v11(50.02,6.34) v11(50.3,55.97) v11(50.22,55.12) v11(50.52,53.35) v11(50.57,51.59) v11(50.57,7.17) v11(50.65,52.44) v11(50.62,6.34) v11(51.07,54.21) v11(51.26,57.08) v11(51.26,55.97) v11(51.2,6.25) v11(51.59,79.6) v11(51.51,78.76) v11(51.59,58.38) v11(52.17,79.61) v11(52.19,78.76) v11(52.15,66.35) v11(52.39,54.74) v11(52.66,55.34) v11(52.73,79.59) v11(52.78,78.76) v11(52.76,57.08) v11(52.76,56.09) v11(52.83,54.12) v11(53.07,59.3) v11(53.16,51.71) v11(53.29,53.55) v11(53.34,52.72) v11(53.43,58.27) v11(53.52,54.24) v11(53.77,80.83) v11(53.76,79.62) v11(53.78,78.43) v11(53.88,53.55) v11(53.9,52.7) v11(54.26,58.13) v11(54.26,57.08) v11(54.48,52.71) v11(54.58,55.06) v11(54.57,53.56) v11(54.92,80.81) v11(54.92,79.62) v11(54.92,78.42) v11(55.25,5.54) v11(55.35,75.28) v11(55.4,74.76) v11(55.46,4.75) v11(55.53,51.79) v11(55.76,58.13) v11(55.76,57.08) v11(55.8,53.53) v11(56.05,80.8) v11(56.09,79.62) v11(56.08,78.41) v11(56.05,59.4) v11(56.02,5.55) v11(56.22,4.76) v11(56.36,55.12) v11(56.41,54.3) v11(56.46,53.22) v11(56.52,52.39) v11(56.96,55.12) v11(56.98,54.28) v11(56.98,4.84) v11(57.06,53.22) v11(57.08,52.37) v11(57.26,58.11) v11(57.26,57.08) v11(57.37,78.63) v11(57.46,79.47) v11(57.56,54.29) v11(57.64,55.13) v11(57.66,52.38) v11(57.74,53.23) v11(57.78,51.68) v11(57.84,55.81) v11(57.97,59.39) v11(58.03,79.48) v11(58.05,78.64) v11(58.6,79.46) v11(58.54,52.84) v11(58.6,52.01) v11(58.65,78.64) v11(58.61,53.7) v11(58.63,5.26) v11(58.76,58.11) v11(58.76,57.08) v11(58.92,54.68) v11(59.14,52.84) v11(59.16,51.99) v11(59.39,6.17) v11(59.4,5.27) v11(59.66,55.66) v11(59.79,59.43) v11(59.72,54.83) v11(59.74,52) v11(59.82,52.85) v11(59.99,78.53) v11(60.07,79.37) v11(60.16,6.18) v11(60.26,55.66) v11(60.28,54.81) v11(60.35,46.58) v11(60.34,38.42) v11(60.65,79.38) v11(60.67,78.53) v11(60.78,10.41) v11(60.86,54.82) v11(60.94,55.67) v11(61.08,58.35) v11(61.08,57.67) v11(61.08,57.07) v11(61.04,37.73) v11(61.13,47.03) v11(61.21,79.36) v11(61.27,78.53) v11(61.5,55.85) v11(61.67,52.92) v11(61.72,52.09) v11(61.79,50.44) v11(61.88,49.41) v11(61.92,58.27) v11(61.93,57.69) v11(61.91,57.13) v11(61.91,48.35) v11(62.17,36.55) v11(62.25,54.85) v11(62.27,52.92) v11(62.29,52.07) v11(62.31,54.02) v11(62.6,55.84) v11(62.76,57.08) v11(62.85,54.85) v11(62.87,54) v11(62.86,52.08) v11(62.95,52.92) v11(63.35,35.37) v11(63.45,54.01) v11(63.53,54.85) v11(63.56,10.39) v11(64.26,57.08) v11(64.33,53.8) v11(64.39,52.98) v11(64.32,10.4) v11(64.4,55.72) v11(64.76,58.47) v11(64.76,57.08) v11(64.7,34.09) v11(64.93,53.8) v11(64.95,52.96) v11(65.25,78.55) v11(65.21,9.88) v11(65.33,79.4) v11(65.39,39.6) v11(65.4,39.02) v11(65.41,40.17) v11(65.53,52.96) v11(65.61,53.81) v11(65.91,79.41) v11(65.93,78.56) v11(65.97,9.89) v11(66.24,40.22) v11(66.24,39.62) v11(66.24,38.94) v11(66.27,32.55) v11(66.32,57.3) v11(66.36,56.3) v11(66.47,79.38) v11(66.41,55.31) v11(66.53,78.56) v11(66.85,9.89) v11(67.59,79.27) v11(67.51,78.43) v11(67.77,30.95) v11(67.93,60.49) v11(67.93,59.59) v11(67.94,59.21) v11(68.17,79.28) v11(68.19,78.43) v11(68.4,47.69) v11(68.47,51.1) v11(68.48,48.54) v11(68.55,51.94) v11(68.55,44.9) v11(68.63,45.74) v11(68.73,79.26) v11(68.79,78.43) v11(68.78,60.4) v11(68.79,59.83) v11(68.77,59.26) v11(69.03,55.96) v11(69.03,55.28) v11(69.03,54.68) v11(69.06,48.54) v11(69.08,47.7) v11(69.13,51.95) v11(69.15,51.1) v11(69.14,29.79) v11(69.3,51.52) v11(69.21,45.75) v11(69.23,44.9) v11(69.7,51.93) v11(69.62,48.52) v11(69.68,47.7) v11(69.75,51.1) v11(69.77,45.73) v11(69.79,10.57) v11(69.87,55.88) v11(69.88,55.3) v11(69.86,54.74) v11(69.83,44.9) v11(69.86,9.97) v11(69.84,9.27) v11(70.3,63.74) v11(70.38,79.12) v11(70.38,78.66) v11(70.38,78.13) v11(70.32,75.37) v11(70.33,74.69) v11(70.33,74.09) v11(70.3,63.06) v11(70.3,62.46) v11(70.37,61.02) v11(70.38,60.34) v11(70.38,59.74) v11(70.56,10.57) v11(70.66,72.01) v11(70.66,71.34) v11(70.69,28.58) v11(70.62,9.97) v11(70.61,9.28) v11(70.79,48.72) v11(70.71,47.87) v11(70.8,56.95) v11(70.81,56.27) v11(70.81,51.52) v11(71.04,72.62) v11(71.17,75.29) v11(71.17,74.71) v11(71.15,74.15) v11(71.12,70.9) v11(71.14,63.65) v11(71.15,63.08) v11(71.13,62.51) v11(71.22,60.94) v11(71.22,60.36) v11(71.2,59.79) v11(71.35,79.6) v11(71.37,48.72) v11(71.39,47.88) v11(71.44,10.57) v11(71.49,9.28) v11(71.59,66.96) v11(71.6,66.28) v11(71.6,65.68) v11(71.5,9.97) v11(71.65,56.87) v11(71.66,56.29) v11(71.64,55.73) v11(71.93,48.7) v11(71.99,47.88) v11(72.31,79.07) v11(72.31,78.61) v11(72.31,78.08) v11(72.44,66.88) v11(72.44,66.3) v11(72.42,65.74) v11(72.49,9.91) v11(72.51,10.52) v11(72.54,9.3) v11(73.09,64.17) v11(73.1,63.49) v11(73.1,62.89) v11(73.27,10.52) v11(73.25,9.91) v11(73.3,9.3) v11(73.47,61.22) v11(73.48,60.54) v11(73.48,59.94) v11(73.6,66.94) v11(73.6,66.26) v11(73.6,65.66) v11(73.79,70.9) v11(73.86,72.62) v11(73.85,69.53) v11(73.86,68.85) v11(73.86,68.25) v11(73.95,76.11) v11(73.96,75.43) v11(73.96,74.83) v11(73.94,64.09) v11(73.94,63.51) v11(73.92,62.94) v11(74.04,53.51) v11(74.04,52.94) v11(74.13,51.13) v11(74.11,50.57) v11(74.12,49.99) v11(74.13,48.29) v11(74.11,47.72) v11(74.12,47.14) v11(74.19,44.7) v11(74.2,44.12) v11(74.16,42.57) v11(74.14,42.01) v11(74.15,41.43) v11(74.16,10.52) v11(74.13,9.91) v11(74.18,9.3) v11(74.25,72.01) v11(74.25,71.34) v11(74.21,45.26) v11(74.29,40.01) v11(74.27,39.44) v11(74.27,38.86) v11(74.32,61.14) v11(74.32,60.56) v11(74.3,60) v11(74.44,66.85) v11(74.45,66.28) v11(74.43,65.71) v11(74.43,54.45) v11(74.46,52.19) v11(74.7,69.45) v11(74.68,68.3) v11(74.8,76.02) v11(74.79,74.88) v11(74.7,68.87) v11(74.79,28.03) v11(74.81,75.45) v11(74.88,54.13) v11(74.88,53.53) v11(74.89,52.85) v11(74.96,51.19) v11(74.96,50.59) v11(74.97,49.91) v11(74.96,48.34) v11(74.96,47.74) v11(74.97,47.06) v11(74.99,42.63) v11(74.99,42.03) v11(74.99,41.35) v11(74.95,10.59) v11(74.95,9.86) v11(75.04,45.32) v11(75.04,44.72) v11(75.04,44.04) v11(75.05,40.06) v11(75.05,39.46) v11(75,9.22) v11(75.12,38.78) v11(75.71,10.6) v11(75.71,9.86) v11(75.76,9.23) v11(76.18,24.69) v11(76.55,28.22) v11(76.59,10.6) v11(76.59,9.86) v11(76.64,9.23) v11(77.01,79.69) v11(77.06,78.86) v11(77.28,76.64) v11(77.29,75.96) v11(77.29,75.36) v11(77.49,22.56) v11(77.61,79.69) v11(77.63,78.84) v11(77.69,10.54) v11(77.77,9.8) v11(77.86,24.58) v11(78.13,76.56) v11(78.13,75.98) v11(78.11,75.42) v11(78.1,28.61) v11(78.29,79.69) v11(78.21,78.85) v11(78.28,37.69) v11(78.2,36.85) v11(78.46,10.55) v11(78.59,26.99) v11(78.53,9.81) v11(78.62,23.57) v11(78.86,37.7) v11(78.88,36.85) v11(79.24,20.17) v11(79.4,79.64) v11(79.34,10.55) v11(79.45,78.81) v11(79.42,37.68) v11(79.48,36.85) v11(79.41,9.81) v11(79.57,22.18) v11(80,79.64) v11(80.02,78.79) v11(80.39,10.46) v11(80.44,9.6) v11(80.59,78.8) v11(80.59,36.87) v11(80.68,79.64) v11(80.67,37.72) v11(80.64,20.7) v11(81.15,10.47) v11(81.2,9.61) v11(81.25,37.72) v11(81.27,36.88) v11(81.57,18.08) v11(81.54,7.16) v11(81.62,39.55) v11(81.81,37.7) v11(81.87,36.88) v11(82.03,10.47) v11(82.08,9.61) v11(82.17,79.59) v11(82.22,78.76) v11(82.31,7.17) v11(82.65,10.98) v11(82.65,10.21) v11(82.65,9.33) v11(82.76,79.59) v11(82.78,78.74) v11(82.94,18.48) v11(83.19,20.48) v11(83.13,4.84) v11(83.36,78.75) v11(83.45,79.59) v11(84.04,6.16) v11(84.04,5.4) v11(84.04,4.52) v11(84.29,17.37) v11(84.39,12.85) v11(84.77,18.36) v11(84.84,5.27) v11(85.15,12.86) v11(85.37,20.1) v11(85.68,4.12) v11(85.91,39.67) v11(85.91,18.5) v11(86.03,12.86) v11(86.28,9.38) v11(86.29,8.62) v11(86.29,7.74) v11(86.45,4.12) v11(86.52,39.67) v11(86.78,11.65) v11(86.79,10.89) v11(86.79,10.01) v11(87.67,9.5) v11(87.68,8.74) v11(87.68,7.86) v11(87.72,39.64) v11(87.89,58.58) v11(88.29,12.04) v11(88.25,4.09) v11(88.3,11.27) v11(88.3,10.39) v11(88.44,79.81) v11(88.49,78.99) v11(88.71,39.63) v11(89.04,79.81) v11(89.06,78.97) v11(89.01,4.1) v11(89.64,78.97) v11(89.72,79.82) v11(89.8,6.35) v11(89.8,39.65) v11(89.87,12.85) v11(90.19,59.74) v11(90.1,5.06) v11(90.13,4.27) v11(90.88,79.76) v11(90.87,5.06) v11(90.89,4.28) v11(90.93,78.94) v11(91.09,6.44) v11(91.09,5.56) v11(91.48,79.76) v11(91.5,78.92) v11(91.46,15.56) v11(91.46,14.8) v11(91.46,13.92) v11(91.78,6.07) v11(91.89,5.08) v11(91.89,4.2) v11(92.07,78.92) v11(92.16,79.77) v11(92.3,9.2) v11(92.54,6.08) v11(92.59,4.65) v11(93.13,6.48) v11(93.13,5.6) v11(93.36,4.66) v11(93.52,79.81) v11(93.57,78.99) v11(93.86,6.15) v11(94.08,5.07) v11(94.08,4.19) v11(94.12,79.81) v11(94.14,78.97) v11(94.3,11.55) v11(94.63,6.16) v11(94.8,79.82) v11(94.72,78.97) v11(95.08,4.65) v11(95.3,6.35) v11(95.42,65) v11(95.84,4.66) v11(95.94,39.59) v11(96.54,5.27) v11(96.54,4.39) v11(96.86,39.6) v11(97.33,5.24) v11(97.33,4.48) v11(97.91,39.59) v11(98.12,5.3) v11(98.12,4.42) v11(98.86,39.58) v11(98.92,50.95) v11(98.97,47.5) v11(99.13,5.9) v11(99.14,5.14) v11(99.21,8.55) v11(99.21,7.78) v11(99.45,6.92) v11(99.95,39.55) v11(100.28,79.97) v11(100.33,79.14) v11(100.65,49.21) v11(100.87,79.97) v11(100.89,79.12) v11(100.89,39.5) v11(101.47,79.13) v11(101.56,79.97) v11(102.57,7.92) v11(102.57,7.04) v11(102.69,79.92) v11(102.74,79.09) v11(103.09,39.56) v11(103.29,79.92) v11(103.31,79.07) v11(103.42,6.32) v11(103.42,5.44) v11(103.89,79.08) v11(103.86,39.6) v11(103.97,79.92) v11(104.15,7.94) v11(104.15,7.06) v11(104.92,80.3) v11(104.98,79.47) v11(105,6.35) v11(105,5.47) v11(105.52,80.3) v11(105.54,79.45) v11(105.93,41.91) v11(106.12,79.46) v11(106.2,80.3) v11(106.33,41.48) v11(106.31,8.27) v11(106.31,7.39) v11(106.53,6.51) v11(106.53,5.63) v11(107.33,41.45) v11(107.89,8.3) v11(107.89,7.42) v11(107.99,41.48) v11(108.04,39.58) v11(108.11,6.54) v11(108.11,5.66) v11(108.6,41.45) v11(108.89,51.58) v11(108.92,52.74) v11(109,39.58) v11(109.49,53.3) v11(109.64,8.74) v11(109.64,7.86) v11(109.98,39.57) v11(110.35,7.01) v11(110.35,6.13) v11(110.65,53.33) v11(111.21,52.76) v11(111.22,8.77) v11(111.22,7.89) v11(111.88,44.75) v11(111.82,41.49) v11(111.98,37.62) v11(111.93,7.04) v11(111.93,6.15) v11(112.53,9.79) v11(112.53,8.91) v11(112.72,13.9) v11(112.97,54.52) v11(113.25,37.62) v11(113.59,79.84) v11(113.64,79.01) v11(113.68,41.19) v11(113.83,42.71) v11(113.99,13.9) v11(114.18,79.84) v11(114.11,9.81) v11(114.11,8.93) v11(114.2,78.99) v11(114.52,37.62) v11(114.78,79) v11(114.73,56.28) v11(114.86,79.85) v11(114.95,44.57) v11(114.95,43.78) v11(114.95,43.02) v11(115.26,13.9) v11(115.51,41.6) v11(115.79,44.59) v11(115.79,43.75) v11(115.79,43.02) v11(115.79,37.62) v11(115.73,15.42) v11(115.91,67.27) v11(116.13,39.56) v11(116.29,66.89) v11(116.29,41.56) v11(116.53,13.9) v11(116.67,66.51) v11(116.85,15.42) v11(116.93,69.75) v11(116.93,68.67) v11(116.93,67.53) v11(117.06,66.13) v11(117.06,37.62) v11(117.12,71.08) v11(117.44,66.51) v11(117.44,65.75) v11(117.45,39.63) v11(117.63,72.16) v11(117.82,70.51) v11(117.82,69.81) v11(117.82,68.99) v11(117.82,68.16) v11(117.83,67.31) v11(117.82,65.37) v11(117.8,13.9) v11(117.98,72.76) v11(117.99,66.04) v11(118.07,15.43) v11(118.3,71.15) v11(118.39,65.24) v11(118.39,64.35) v11(118.39,63.46) v11(118.33,37.62) v11(118.64,62.26) v11(118.61,36.12) v11(118.71,35.04) v11(118.71,34.56) v11(118.71,34.18) v11(118.83,72.96) v11(119.07,13.9) v11(119.15,61.75) v11(119.24,42.36) v11(119.21,39.62) v11(119.34,65.69) v11(119.34,64.8) v11(119.34,63.78) v11(119.41,62.89) v11(119.41,47.2) v11(119.6,37.62) v11(119.8,6.89) v11(119.89,36.5) v11(119.89,35.23) v11(119.89,33.96) v11(119.89,32.69) v11(119.89,31.42) v11(119.89,30.15) v11(119.89,28.88) v11(119.89,25.07) v11(119.89,23.8) v11(119.89,22.53) v11(119.89,21.26) v11(119.89,19.99) v11(119.89,18.72) v11(119.89,17.45) v11(119.89,16.18) v11(119.89,14.91) v11(119.99,69) v11(119.97,68.44) v11(119.98,67.86) v11(119.99,66.16) v11(119.99,65.59) v11(119.97,63.53) v11(120.01,66.73) v11(120.01,64.75) v11(120.59,56.16) v11(120.74,60.83) v11(120.82,78.39) v11(120.81,39.61) v11(120.99,63.03) v11(121.04,74) v11(121.05,73.43) v11(121.06,72.85) v11(121.06,64.31) v11(121.04,63.75) v11(121.02,49.34) v11(121.17,77.81) v11(121.17,77.23) v11(121.26,61.63) v11(121.46,54.28) v11(121.5,46.52) v11(121.65,78.44) v11(121.65,77.84) v11(121.65,77.16) v11(121.67,69.09) v11(121.67,68.49) v11(121.68,67.81) v11(121.65,49.34) v11(121.8,74.07) v11(121.8,73.47) v11(121.8,66.78) v11(121.8,66.18) v11(121.8,64.37) v11(121.8,63.77) v11(121.8,72.79) v11(121.86,65.5) v11(121.8,63.09) v11(121.85,60.81) v11(122.02,46.52) v11(122.23,61.79) v11(122.29,39.55) v11(122.3,8.4) v11(122.52,46.52) v11(123.06,15.37) v11(123.06,15.02) v11(123.18,77.94) v11(123.18,39.24) v11(123.27,78.79) v11(123.23,43.69) v11(123.23,43.13) v11(123.23,42.57) v11(123.21,36.41) v11(123.24,34.66) v11(123.23,33.35) v11(123.24,32.24) v11(123.25,31.03) v11(123.25,28.95) v11(123.23,21.62) v11(123.21,21.01) v11(123.24,18.51) v11(123.24,17.29) v11(123.25,16.11) v11(123.41,12.7) v11(123.41,12.14) v11(123.6,47.55) v11(123.84,78.8) v11(123.86,77.95) v11(124.1,74.75) v11(124.35,65.1) v11(124.41,78.78) v11(124.46,77.95) v11(124.49,51.03) v11(124.42,24.61) v11(124.56,23.24) v11(124.54,20.72) v11(124.56,19.81) v11(124.68,62.97) v11(124.69,14.9) v11(124.96,50.75) v11(125.05,14.9) v11(125.26,77.01) v11(125.31,72.54) v11(125.35,50.57) v11(125.4,18.09) v11(125.6,50.85) v11(126.1,4.3) v11(126.11,3.54) v11(126.27,77.01) v11(126.32,72.54) v11(126.32,14.9) v11(126.68,14.9) v11(126.97,4.3) v11(126.97,3.54) v11(127.29,77.01) v11(127.34,72.54) v11(127.34,34.57) v11(127.47,34.06) v11(127.66,34.95) v11(127.85,19.39) v11(127.81,5.88) v11(127.81,5.12) v11(127.81,4.3) v11(127.81,3.54) v11(127.97,33.9) v11(127.95,14.9) v11(128.17,34.95) v11(128.3,14.9) v11(128.46,11.44) v11(128.63,76.96) v11(128.61,73.71) v11(128.66,70.33) v11(128.66,69.31) v11(128.66,34.8) v11(128.67,5.88) v11(128.68,5.12) v11(128.67,4.3) v11(128.68,3.54) v11(128.94,50.4) v11(129.16,62.96) v11(129.17,44.01) v11(129.3,50.99) v11(129.25,34.44) v11(129.48,7.58) v11(129.49,6.82) v11(129.58,5.9) v11(129.59,5.14) v11(129.58,4.3) v11(129.59,3.54) v11(129.65,76.96) v11(129.68,70.33) v11(129.68,69.31) v11(129.65,68.04) v11(129.65,67.03) v11(129.65,66.01) v11(129.63,33.56) v11(129.76,34.93) v11(129.8,62.72) v11(129.98,56.98) v11(130.14,34.32) v11(130.25,34.93) v11(130.2,22.57) v11(130.29,18.3) v11(130.29,17.87) v11(130.35,7.58) v11(130.35,6.82) v11(130.45,5.9) v11(130.45,5.14) v11(130.45,4.3) v11(130.45,3.54) v11(130.67,76.96) v11(130.64,73.71) v11(130.64,72.69) v11(130.69,70.33) v11(130.69,69.31) v11(130.67,68.04) v11(130.67,67.03) v11(130.67,66.01) v11(130.71,33.68) v11(130.71,25.87) v11(130.71,25.36) v11(130.75,18.3) v11(130.75,17.87) v11(130.81,60.89) v11(130.95,37.77) v11(130.98,9.16) v11(130.99,8.39) v11(131.15,60.26) v11(131.15,33.3) v11(131.2,18.3) v11(131.2,17.87) v11(131.31,62.7) v11(131.39,5.96) v11(131.39,5.19) v11(131.47,32.98) v11(131.47,31.71) v11(131.46,7.58) v11(131.47,6.82) v11(131.41,4.3) v11(131.42,3.54) v11(131.55,65.1) v11(131.53,37.78) v11(131.66,78.85) v11(131.67,78.17) v11(131.67,77.57) v11(131.71,76.82) v11(131.72,76.14) v11(131.72,75.54) v11(131.75,18.06) v11(131.85,32.6) v11(131.82,30.98) v11(131.89,18.8) v11(131.84,9.16) v11(131.85,8.39) v11(132.04,33.43) v11(132.25,30.59) v11(132.25,5.96) v11(132.26,5.19) v11(132.28,4.3) v11(132.28,3.54) v11(132.33,62.71) v11(132.33,7.58) v11(132.33,6.82) v11(132.49,77.63) v11(132.49,33.81) v11(132.51,78.77) v11(132.51,78.19) v11(132.56,76.74) v11(132.57,76.16) v11(132.55,75.59) v11(132.57,54.65) v11(132.57,54.05) v11(132.76,9.23) v11(132.77,8.47) v11(132.92,62.73) v11(132.99,34.12) v11(133.08,30.69) v11(133.06,7.58) v11(133.07,6.82) v11(133.12,32.54) v11(133.12,31.94) v11(133.13,31.35) v11(133.31,33) v11(133.45,64.5) v11(133.44,4.36) v11(133.45,3.59) v11(133.52,6.08) v11(133.53,5.32) v11(133.63,34.06) v11(133.62,9.23) v11(133.63,8.47) v11(133.82,33.49) v11(133.96,32.28) v11(133.93,7.58) v11(133.93,6.82) v11(134.38,6.08) v11(134.39,5.32) v11(134.31,4.36) v11(134.32,3.59) v11(134.45,14.9) v11(134.51,64.85) v11(134.51,64.17) v11(134.54,63.63) v11(134.58,62.61) v11(134.64,57.86) v11(134.64,56.56) v11(134.64,38.77) v11(134.64,36.14) v11(134.83,19.78) v11(134.8,14.9) v11(134.96,52.04) v11(134.96,47) v11(134.96,44.48) v11(134.96,41.96) v11(135.09,58.31) v11(135.05,48.26) v11(135.05,43.22) v11(135.05,40.7) v11(135.09,35.68) v11(135.06,30.88) v11(135.26,57.04) v11(135.26,36.31) v11(135.49,63.63) v11(135.43,6.01) v11(135.43,5.24) v11(135.43,4.33) v11(135.43,3.57) v11(135.51,64.77) v11(135.51,64.19) v11(135.58,38.21) v11(135.75,70.07) v11(135.75,68.93) v11(135.75,65.55) v11(135.75,64.42) v11(135.75,62.72) v11(135.7,53.3) v11(135.7,50.78) v11(135.7,48.26) v11(135.7,45.74) v11(135.7,43.22) v11(135.7,40.7) v11(135.74,35.68) v11(135.81,67.84) v11(135.81,66.59) v11(135.81,19.75) v11(135.95,32.46) v11(135.95,30.68) v11(136.07,14.9) v11(136.14,54.53) v11(136.13,13.62) v11(136.13,12.68) v11(136.13,11.74) v11(136.29,6.01) v11(136.3,5.24) v11(136.29,4.33) v11(136.3,3.57) v11(136.32,10.97) v11(136.43,14.9) v11(136.59,55.83) v11(136.59,50.78) v11(136.59,48.26) v11(136.59,45.74) v11(136.59,43.22) v11(136.59,40.7) v11(136.59,38.22) v11(136.76,19.76) v11(136.89,36.1) v11(137.07,65.79) v11(137.33,5.73) v11(137.34,4.96) v11(137.33,4.38) v11(137.34,3.62) v11(137.55,39.68) v11(137.7,14.9) v11(137.81,52.72) v11(137.89,49.9) v11(137.89,46.78) v11(137.89,43.67) v11(137.89,41.63) v11(138.07,57.89) v11(138.07,57.24) v11(138.05,14.9) v11(138.12,56.04) v11(138.19,5.73) v11(138.19,4.38) v11(138.2,4.96) v11(138.2,3.62) v11(138.38,33.6) v11(138.7,7.72) v11(138.7,6.47) v11(138.72,54.67) v11(138.88,77.25) v11(139,20.26) v11(139,19.88) v11(139.06,26.88) v11(139.06,26.5) v11(139.01,5.75) v11(139.01,4.99) v11(139.06,4.33) v11(139.07,3.57) v11(139.33,56.04) v11(139.4,39.68) v11(139.32,14.9) v11(139.44,77.25) v11(139.53,19.25) v11(139.63,52.72) v11(139.68,14.9) v11(139.84,49.9) v11(139.84,46.78) v11(139.84,43.67) v11(139.84,41.63) v11(139.86,37.67) v11(139.86,36.67) v11(139.86,36.01) v11(139.88,24.2) v11(139.87,5.75) v11(139.88,4.99) v11(139.92,4.33) v11(139.93,3.57) v11(140.32,39.68) v11(140.59,57.89) v11(140.59,57.24) v11(140.59,56.04) v11(140.59,22.2) v11(140.58,19.47) v11(140.62,80.33) v11(140.66,51.14) v11(140.66,50.3) v11(140.66,47.79) v11(140.66,43.59) v11(140.66,42.75) v11(140.66,41.91) v11(140.95,14.9) v11(140.91,5.68) v11(140.92,4.91) v11(141.02,65.84) v11(141.25,39.68) v11(141.31,51.14) v11(141.31,50.3) v11(141.31,47.79) v11(141.31,45.27) v11(141.31,43.59) v11(141.31,41.91) v11(141.31,14.9) v11(141.49,80.33) v11(141.46,54.67) v11(141.46,52.72) v11(141.45,33.04) v11(141.63,29.71) v11(141.63,29.15) v11(141.63,28.59) v11(141.61,27.82) v11(141.66,3.89) v11(141.66,3.48) v11(141.78,5.68) v11(141.78,4.91) v11(141.89,19.89) v11(141.96,51.14) v11(141.96,50.3) v11(141.96,47.79) v11(141.96,46.95) v11(141.96,46.11) v11(141.96,41.91) v11(142.03,15.11) v11(142.17,39.68) v11(142.13,33.04) v11(142.32,65.84) v11(142.31,37.67) v11(142.31,36.67) v11(142.31,36.01) v11(142.58,14.9) v11(142.61,51.14) v11(142.61,48.63) v11(142.61,44.43) v11(142.61,41.91) v11(142.89,5.68) v11(142.91,80.26) v11(142.97,68.24) v11(142.93,14.9) v11(142.9,4.91) v11(143.05,77.25) v11(143.09,38.38) v11(143.11,57.24) v11(143.11,56.04) v11(143.28,52.72) v11(143.26,51.14) v11(143.26,46.95) v11(143.26,44.43) v11(143.26,41.91) v11(143.62,67.44) v11(143.62,13.07) v11(143.77,80.26) v11(143.76,5.68) v11(143.76,4.91) v11(143.91,50.3) v11(143.91,44.43) v11(143.91,41.91) v11(144.02,39.68) v11(144.19,54.67) v11(144.31,30.49) v11(144.31,29.99) v11(144.31,29.48) v11(144.31,28.97) v11(144.31,28.46) v11(144.56,41.91) v11(144.75,36.67) v11(144.91,80.28) v11(144.94,39.68) v11(144.93,5.83) v11(144.93,5.07) v11(145.21,51.14) v11(145.21,50.3) v11(145.21,49.47) v11(145.21,45.27) v11(145.21,41.91) v11(145.22,15.03) v11(145.32,29.48) v11(145.47,60.26) v11(145.56,3.82) v11(145.56,3.33) v11(145.78,80.28) v11(145.79,5.83) v11(145.8,5.07) v11(145.86,51.14) v11(145.86,45.27) v11(145.86,44.43) v11(145.86,43.59) v11(145.86,38.38) v11(145.92,7.23) v11(145.92,6.46) v11(146.17,9.71) v11(146.18,8.95) v11(146.51,51.14) v11(146.55,4.61) v11(146.56,3.85) v11(146.79,39.68) v11(146.77,15.14) v11(146.74,7.99) v11(146.78,7.23) v11(146.79,6.46) v11(146.88,57.99) v11(146.92,55.32) v11(147.05,15.69) v11(147.08,14.53) v11(147.06,11.21) v11(147.07,10.45) v11(147.03,9.71) v11(147.04,8.95) v11(147.16,42.75) v11(147.19,37.67) v11(147.19,36.67) v11(147.13,5.51) v11(147.28,30.36) v11(147.28,29.8) v11(147.28,29.24) v11(147.29,27.82) v11(147.33,80.26) v11(147.41,15.78) v11(147.47,14.44) v11(147.47,8.44) v11(147.47,7.68) v11(147.41,4.61) v11(147.42,3.85) v11(147.52,73.04) v11(147.62,6.51) v11(147.71,39.68) v11(147.84,54.02) v11(147.85,15.78) v11(147.98,14.44) v11(147.92,11.21) v11(147.93,10.45) v11(148.06,9.7) v11(148.19,80.26) v11(148.14,57.89) v11(148.14,57.24) v11(148.17,40.79) v11(148.3,15.78) v11(148.33,8.44) v11(148.34,7.68) v11(148.49,14.44) v11(148.75,55.32) v11(148.75,51.14) v11(148.78,29.53) v11(148.74,15.78) v11(148.71,4.56) v11(148.72,3.8) v11(148.82,73.04) v11(148.89,7.94) v11(148.93,14.44) v11(149.12,15.78) v11(149.14,7.07) v11(149.15,6.31) v11(149.25,11.7) v11(149.27,5.46) v11(149.33,80.23) v11(149.4,56.04) v11(149.32,11.16) v11(149.33,10.4) v11(149.44,14.44) v11(149.45,9.18) v11(149.45,8.42) v11(149.57,15.71) v11(149.57,4.56) v11(149.58,3.8) v11(149.63,37.67) v11(149.63,36.67) v11(149.63,36.01) v11(150.03,15.03) v11(150.01,7.07) v11(150.01,6.31) v11(150.2,80.23) v11(150.17,26.31) v11(150.12,23.04) v11(150.18,11.16) v11(150.19,10.4) v11(150.21,9.64) v11(150.31,9.18) v11(150.32,8.42) v11(150.42,15.05) v11(150.43,7.72) v11(150.57,55.32) v11(150.54,16.51) v11(150.66,57.24) v11(150.66,56.04) v11(150.86,15.04) v11(150.82,5.24) v11(151.09,62.03) v11(151.01,11.62) v11(151.07,4.61) v11(151.08,3.85) v11(151.19,15.01) v11(151.12,8.78) v11(151.13,8.01) v11(151.17,6.95) v11(151.18,6.18) v11(151.31,80.23) v11(151.37,16.38) v11(151.41,37.63) v11(151.45,11.11) v11(151.46,10.35) v11(151.57,15.69) v11(151.66,73.59) v11(151.66,73.03) v11(151.66,69.68) v11(151.66,69.12) v11(151.66,68.56) v11(151.66,68) v11(151.66,66.89) v11(151.66,65.21) v11(151.66,64.65) v11(151.66,62.97) v11(151.63,14.54) v11(151.75,9.42) v11(151.92,57.99) v11(151.92,56.04) v11(151.92,15.78) v11(151.98,14.44) v11(151.99,8.78) v11(151.99,8.01) v11(151.94,4.61) v11(151.94,3.85) v11(152.07,37.67) v11(152.07,36.67) v11(152.04,6.95) v11(152.04,6.18) v11(152.18,80.23) v11(152.16,33.46) v11(152.14,16.38) v11(152.21,77.33) v11(152.24,76.78) v11(152.24,71.91) v11(152.24,71.36) v11(152.24,70.8) v11(152.24,70.24) v11(152.24,67.44) v11(152.24,66.33) v11(152.24,65.77) v11(152.24,64.09) v11(152.24,63.53) v11(152.36,15.78) v11(152.32,11.11) v11(152.32,10.35) v11(152.49,14.44) v11(152.55,7.58) v11(152.73,37.63) v11(152.73,36.98) v11(152.87,15.78) v11(152.96,16.51) v11(152.91,11.65) v11(153.06,14.44) v11(153.17,56.04) v11(153.3,80.23) v11(153.25,39.03) v11(153.29,37.31) v11(153.31,15.78) v11(153.57,14.44) v11(153.73,9.34) v11(153.85,37.63) v11(154.16,80.23) v11(154.1,15.67) v11(154.1,14.53) v11(154.23,77.32) v11(154.22,55.32) v11(154.43,57.99) v11(154.43,56.04) v11(154.47,28.8) v11(154.42,13.07) v11(154.43,12.3) v11(154.51,37.67) v11(154.51,36.67) v11(154.79,77.32) v11(154.77,16.47) v11(154.94,65.84) v11(155.09,15.13) v11(155.08,14.3) v11(155.17,37.63) v11(155.17,36.98) v11(155.29,13.07) v11(155.3,12.3) v11(155.32,28.97) v11(155.69,56.04) v11(155.73,37.31) v11(155.74,16.39) v11(155.95,15.13) v11(155.94,14.3) v11(156.24,65.84) v11(156.29,37.63) v11(156.29,36.98) v11(156.24,13.6) v11(156.28,12.97) v11(156.29,12.2) v11(156.95,56.04) v11(156.95,37.67) v11(156.95,36.67) v11(157.14,12.97) v11(157.15,12.2) v11(157.24,14.31) v11(157.25,13.55) v11(157.47,28.09) v11(157.54,65.84) v11(157.64,77.91) v11(157.61,37.63) v11(157.69,11.51) v11(157.86,55.32) v11(157.94,28.97) v11(158.03,15.1) v11(158.16,77.31) v11(158.19,68.24) v11(158.17,37.31) v11(158.11,14.31) v11(158.12,13.55) v11(158.21,56.04) v11(158.3,28.09) v11(158.28,16.48) v11(158.46,12.66) v11(158.47,11.9) v11(158.73,37.63) v11(158.84,73.84) v11(158.84,67.44) v11(159.12,28.09) v11(159.3,15.1) v11(159.39,37.67) v11(159.39,36.67) v11(159.33,16.51) v11(159.33,12.66) v11(159.33,11.9) v11(159.47,56.04) v11(159.45,13.38) v11(159.53,10.91) v11(159.54,10.15) v11(159.95,28.09) v11(160.3,13.78) v11(160.3,14.29) v11(160.32,12.89) v11(160.32,12.13) v11(160.39,10.91) v11(160.4,10.15) v11(160.65,38.38) v11(160.64,15.11) v11(160.78,28.34) v11(161.17,14.29) v11(161.16,13.78) v11(161.18,12.89) v11(161.19,12.13) v11(161.39,77.32) v11(161.44,27.92) v11(161.51,55.32) v11(161.57,39.68) v11(161.58,16.68) v11(161.79,4.56) v11(161.8,3.8) v11(161.83,37.67) v11(161.83,36.67) v11(161.81,15.11) v11(161.82,11.34) v11(161.98,56.04) v11(161.99,13.24) v11(161.96,7.77) v11(162.59,5.82) v11(162.65,4.56) v11(162.66,3.8) v11(162.76,25.94) v11(162.76,13.02) v11(162.76,12.25) v11(162.83,10.05) v11(162.84,9.28) v11(162.96,8.32) v11(162.97,7.55) v11(163.09,14.26) v11(163.06,11.65) v11(163.12,13.68) v11(163.24,6.36) v11(163.25,5.6) v11(163.33,54.67) v11(163.33,54.02) v11(163.33,53.37) v11(163.33,52.07) v11(163.42,38.38) v11(163.54,30.91) v11(163.5,15.1) v11(163.62,13.02) v11(163.63,12.25) v11(163.7,10.05) v11(163.79,51.61) v11(163.79,50.68) v11(163.7,9.28) v11(163.82,8.32) v11(163.83,7.55) v11(163.95,14.26) v11(163.98,13.68) v11(164.03,6.36) v11(164.03,5.6) v11(164,4.43) v11(164.08,3.67) v11(164.22,76.19) v11(164.24,54.02) v11(164.24,52.07) v11(164.24,51.14) v11(164.27,37.67) v11(164.27,36.67) v11(164.36,31.16) v11(164.5,56.04) v11(164.7,51.61) v11(164.7,50.68) v11(164.74,76.74) v11(164.74,15.16) v11(164.81,76.19) v11(164.85,14.49) v11(164.89,13.51) v11(164.94,4.43) v11(164.95,3.67) v11(165.15,54.02) v11(165.15,52.07) v11(165.15,51.14) v11(165.19,31.21) v11(165.3,76.74) v11(165.27,22.2) v11(165.31,60.99) v11(165.76,56.04) v11(165.9,60.96) v11(166.06,52.07) v11(166.19,38.38) v11(166.19,9.75) v11(166.31,11.55) v11(166.45,12.4) v11(166.57,3.57) v11(166.67,61.43) v11(166.82,29.12) v11(166.82,28.56) v11(166.81,27.91) v11(166.8,27.37) v11(166.95,70.27) v11(166.98,52.07) v11(167.02,57.99) v11(167.02,56.04) v11(167.09,15.33) v11(167.13,13.03) v11(167.24,73.26) v11(167.24,72.7) v11(167.24,72.14) v11(167.24,71.58) v11(167.24,71.02) v11(167.25,68.07) v11(167.25,67.51) v11(167.25,66.95) v11(167.25,66.39) v11(167.25,65.84) v11(167.43,3.57) v11(167.61,61.43) v11(167.89,52.07) v11(168.23,65.23) v11(168.22,64.68) v11(168.28,57.24) v11(168.28,56.04) v11(168.37,62.21) v11(168.34,51.61) v11(168.34,3.59) v11(168.46,73.34) v11(168.66,67.85) v11(168.8,52.07) v11(168.84,71.95) v11(168.97,75.01) v11(169.07,69.71) v11(169.25,51.61) v11(169.21,3.59) v11(169.37,75.03) v11(169.58,63.63) v11(169.54,57.99) v11(169.54,56.04) v11(169.76,75.03) v11(169.71,52.07) v11(169.87,67.43) v11(170.05,71.07) v11(170.03,61.52) v11(170.1,65.51) v11(170.17,51.61) v11(170.27,75.01) v11(170.32,73.7) v11(170.5,69.37) v11(170.55,3.62) v11(170.62,52.07) v11(170.7,75.01) v11(170.79,57.89) v11(170.79,57.24) v11(170.79,56.04) v11(171.11,75.01) v11(171.14,66.59) v11(171.25,68.69) v11(171.29,60.66) v11(171.37,71.58) v11(171.35,64) v11(171.46,33.02) v11(171.42,3.62) v11(171.55,74.98) v11(171.53,54.67) v11(171.51,31.37) v11(171.61,73.16) v11(171.65,67.85) v11(171.72,4.88) v11(171.83,62.52) v11(171.95,74.98) v11(172.05,57.99) v11(172.13,64.91) v11(172.2,33.02) v11(172.25,31.37) v11(172.33,74.98) v11(172.48,3.62) v11(172.59,62.39) v11(172.59,4.88) v11(172.73,74.96) v11(172.73,59.22) v11(172.81,33.02) v11(172.97,73.01) v11(172.97,72.45) v11(172.99,70.74) v11(172.99,70.18) v11(172.99,69.63) v11(172.99,69.07) v11(172.99,68.51) v11(172.95,67.24) v11(172.95,66.68) v11(172.95,66.12) v11(172.91,31.4) v11(173.14,74.96) v11(173.35,3.62) v11(173.44,33.02) v11(173.55,74.96) v11(173.59,59.89) v11(173.57,31.4) v11(173.65,4.88) v11(173.84,63.4) v11(174.04,36.67) v11(174.33,33.02) v11(174.38,31.45) v11(174.39,3.62) v11(174.57,57.99) v11(174.57,56.04) v11(174.52,4.88) v11(174.72,46.39) v11(174.82,77.31) v11(174.89,60.48) v11(174.86,15.33) v11(174.9,13.08) v11(174.99,33.02) v11(174.99,31.45) v11(175.25,3.62) v11(175.38,77.31) v11(175.63,31.45) v11(175.78,56.04) v11(175.89,40.79) v11(176.15,73.84) v11(176.16,65.84) v11(176.16,33.02) v11(176.32,3.62) v11(176.45,56.15) v11(176.67,46.39) v11(176.99,55.78) v11(177.18,3.62) v11(177.46,65.84) v11(177.93,32.63) v11(178.16,58.31) v11(178.37,77.91) v11(178.58,3.62) v11(178.62,46.39) v11(178.75,77.33) v11(178.76,65.84) v11(178.81,58.31) v11(178.85,48.28) v11(178.94,52.05) v11(178.94,49.53) v11(178.94,39.43) v11(179.12,32.63) v11(179.27,57.86) v11(179.41,68.24) v11(179.44,3.62) v11(180.06,67.44) v11(180.51,3.62) v11(180.71,65.84) v11(181.36,73.84) v11(181.37,3.62) v11(181.98,77.31) v11(182.49,15.33) v11(182.67,13.08) v11(182.82,3.59) v11(182.9,34.3) v11(182.9,33.69) v11(183.69,3.59) v11(183.83,44.21) v11(184.26,44.24) v11(184.21,36) v11(184.7,36.03) v11(184.65,35.52) v11(184.72,44.24) v11(184.75,3.59) v11(185.18,44.24) v11(185.15,36.03) v11(185.11,35.52) v11(185.34,76.72) v11(185.37,62.67) v11(185.53,44.19) v11(185.54,36.02) v11(185.56,35.52) v11(185.62,3.59) v11(185.9,76.72) v11(185.91,62.67) v11(185.97,44.21) v11(186.17,5.92) v11(186.46,76.72) v11(186.42,44.21) v11(186.51,62.69) v11(186.83,58.97) v11(186.83,57.67) v11(186.83,56.37) v11(186.88,44.21) v11(186.86,3.62) v11(186.93,5.83) v11(187.39,44.24) v11(187.72,3.62) v11(187.82,44.26) v11(188.18,63.78) v11(188.28,44.26) v11(188.43,55.07) v11(188.56,71.34) v11(188.56,70.75) v11(188.61,70.19) v11(188.73,44.26) v11(188.79,3.62) v11(189.23,55.72) v11(189.47,23.11) v11(189.47,22.28) v11(189.65,72.05) v11(189.65,3.62) v11(189.86,29.14) v11(190.24,28.11) v11(190.29,25.18) v11(190.33,80.21) v11(190.54,64.92) v11(190.59,14.62) v11(190.61,14.21) v11(190.64,13.45) v11(190.64,13.02) v11(190.89,65.75) v11(191.19,80.21) v11(191.1,3.7) v11(191.49,21.19) v11(191.54,62.24) v11(191.96,46.24) v11(191.94,23.43) v11(191.97,3.7) v11(192.09,62.24) v11(192.37,46.24) v11(192.34,18.51) v11(192.85,46.24) v11(193.16,28.6) v11(193.23,54.37) v11(193.33,46.24) v11(193.48,71.41) v11(193.69,71.66) v11(193.99,28.6) v11(194.03,55.72) v11(194.35,14.57) v11(194.35,14.19) v11(194.35,13.43) v11(194.35,13.02) v11(194.83,55.07) v11(194.91,18.55) v11(195.06,28.61) v11(195.21,16.64) v11(195.89,28.61) v11(195.82,18.56) v11(195.99,72.27) v11(196.08,6.41) v11(196.13,5.42) v11(196.75,72.42) v11(196.94,6.41) v11(197,5.42) v11(197.17,7.17) v11(197.7,27.79) v11(197.71,49.17) v11(197.71,48.61) v11(197.85,29.42) v11(197.92,47) v11(198.11,46.74) v11(198.19,6.44) v11(198.3,60.31) v11(198.3,59.75) v11(198.3,56.4) v11(198.3,55.84) v11(198.3,55.28) v11(198.24,5.45) v11(198.74,7.2) v11(198.98,28.2) v11(199.05,6.44) v11(199.1,5.45) v11(199.28,7.2) v11(200.14,7.2) v11(200.12,6.44) v11(200.17,5.45) v11(200.35,51) v11(200.35,50.13) v11(200.32,48.69) v11(200.32,47.82) v11(200.45,61.06) v11(200.6,46.58) v11(200.6,45.71) v11(200.6,29.43) v11(200.77,30.47) v11(200.77,30.09) v11(200.98,6.44) v11(201.09,58.52) v11(201.03,20.78) v11(201.03,16.51) v11(201.03,5.45) v11(201.21,7.2) v11(201.36,57.49) v11(201.41,23.76) v11(201.59,56.64) v11(201.67,3.64) v11(201.74,27.09) v11(201.87,53.74) v11(201.87,52.88) v11(201.87,45.79) v11(201.87,44.93) v11(201.95,16.5) v11(201.95,6.34) v11(202,5.42) v11(202.08,7.2) v11(202.15,24.86) v11(202.15,24.47) v11(202.15,24.09) v11(202.15,23.71) v11(202.27,25.62) v11(202.27,25.24) v11(202.51,28.95) v11(202.51,28.06) v11(202.53,3.64) v11(202.83,52.8) v11(202.81,6.34) v11(202.86,5.42) v11(203.1,53.7) v11(203.07,7.15) v11(203.7,45.49) v11(203.7,44.62) v11(203.78,3.67) v11(203.93,7.15) v11(204.06,6.36) v11(204.19,16.42) v11(204.11,5.45) v11(204.64,3.67) v11(204.97,45.38) v11(204.97,44.52) v11(204.92,6.36) v11(204.97,5.45) v11(205.13,43.12) v11(205.4,42.39) v11(205.61,35.46) v11(205.61,35.11) v11(205.71,3.67) v11(205.99,6.36) v11(206.04,5.45) v11(206.57,3.67) v11(206.85,6.36) v11(206.9,5.45) v11(207.51,3.62) v11(207.87,6.36) v11(207.92,5.55) v11(208.37,3.62) v11(208.73,6.36) v11(208.78,5.55) v11(209.44,3.62) v11(209.74,22.87) v11(209.74,22) v11(209.77,20.9) v11(209.77,20.04) v11(209.77,6.12) v11(209.77,5.62) v11(209.89,8.07) v11(209.89,7.65) v11(209.89,7.2) v11(209.89,6.76) v11(210.11,4.82) v11(210.34,8.6) v11(210.3,3.62) v11(210.53,5.11) v11(210.78,8.6) v11(210.82,5.11)
